# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
UPD_GPU_SMBDAT: length 486
  TOP w0.14: QT1.1 9.04,43.75 v2(9.04,44.26) 9.25,44.46 11.89,44.46 12.26,44.09 RT200.1 ; UE3.B48 296.52,19.77 296.4,19.65 296.4,19.17 v2(296.81,18.76) ; RE94.1 298.64,29.33 v3(298.9,29.08) 299.62,29.08 v2(299.81,29.27)
  IN1 w0.099: v2(206.5,59.05) 207.79,57.76 207.79,49.63 212.59,44.83 233.4,44.83 247.63,30.6 251.53,30.6 261.67,20.46 267.17,20.46 269.44,22.74 281.39,22.74 281.96,23.31 286.36,23.31 286.65,23.01 288.26,23.01 290.97,25.73 296.55,25.73 297.51,26.69 298.74,26.69 299.29,27.24 299.29,28.75 v2(299.81,29.27) ; v2(290.67,19.38) 290.91,19.13 293.26,19.13 293.9,19.77 296.12,19.77 296.42,19.46 296.42,19.11 296.76,18.76 v2(296.81,18.76)
  IN3 w0.091: v2(5.13,28.97) 5.13,27.57 7.69,25 12.29,25 v2(12.68,24.62)
  IN4 w0.091: v2(296.81,18.76) 296.43,19.15 296.43,19.52 296.83,19.92 297.7,19.92 297.85,20.07 297.85,20.25 297.76,20.35 296.19,20.35 296.1,20.44 296.1,20.65 296.19,20.75 296.98,20.75 297.09,20.85 297.09,21 296.98,21.11 296.19,21.11 296.1,21.2 296.1,21.39 296.19,21.48 296.58,21.48 296.67,21.57 296.67,21.75 296.58,21.84 296.19,21.84 296.1,21.93 296.1,23.24 296.19,23.33 296.63,23.33 296.72,23.42 296.72,23.61 296.63,23.7 296.19,23.7 296.1,23.79 296.1,23.98 296.46,24.34 296.59,24.34 297.09,23.84 297.24,23.84 297.35,23.95 297.35,24.1 296.85,24.6 296.85,24.73 296.98,24.86 297.11,24.86 297.44,24.53 297.57,24.53 297.7,24.66 297.7,24.79 297.37,25.12 297.37,25.25 297.76,25.64 297.76,27.22 v2(299.81,29.27)
  IN6 w0.089: 91.38,14.18 91.55,14.18 92.06,14.69 ; 101.6,13.66 100.84,14.42 100.05,14.42 99.94,14.31 98.62,14.31 98.49,14.44 96.44,14.44 96.19,14.69 95.32,14.69
  IN6 w0.099: v2(9.04,44.26) 8.82,44.48 4.39,44.48 3.39,43.48 3.39,37.13 4.48,36.03 4.48,29.61 v2(5.13,28.97) ; v2(12.68,24.62) 14.05,24.62 15.77,26.34 17.2,26.34 18.16,27.31 21.42,27.31 22.08,27.97 23.84,27.97 23.84,27.96 27.58,27.96 27.58,27.96 32.61,27.96 33.87,29.22 34.38,29.22 34.91,29.76 43.89,29.76 45.91,27.74 49.61,27.74 50.17,27.19 55.65,27.19 58.28,24.56 61.78,24.56 64.6,21.73 64.6,21.45 65.34,20.71 66.49,20.71 67.47,19.74 67.47,19.03 v2(67.73,18.78) 67.51,18.56 67.51,18.34 69.14,16.71 72.28,16.71 74.65,14.34 77.96,14.34 78.25,14.63 83.67,14.63 84.39,15.35 85.03,15.35 85.45,14.93 86.04,14.93 86.21,14.77 86.21,14.4 86.43,14.18 91.38,14.18 ; 92.06,14.69 95.32,14.69 ; 101.6,13.66 124.81,13.66 125.06,13.91 159.75,13.91 160.6,13.07 168.75,13.07 169.35,13.66 186.16,13.66 186.68,14.18 215.19,14.18 215.94,13.44 224.53,13.44 224.7,13.6 228.95,13.6 230.91,11.63 234.65,11.63 235.13,11.15 236.58,11.15 237.03,11.6 249.58,11.6 250.76,10.42 261.65,10.42 263.27,12.04 265.96,12.04 269.77,15.85 277.42,15.85 278.69,17.12 281.17,17.12 283.38,19.33 284.63,19.33 285.18,19.87 290.17,19.87 v2(290.67,19.38)
  BOTTOM w0.14: QV21.3 v2(206.5,59.05) ; v2(67.73,18.78) 68.34,19.39 QE18.6
UPD_MRESET: length 410.8
  TOP w0.14: UE3.A4 296.77,9.59 296.91,9.46 296.91,9.02 297.22,8.71 297.22,8.24 v2(297.41,8.05) ; v2(24.86,50.41) 25.15,50.7 25.15,50.87 25.54,51.27 RT244.1 ; v2(281.95,20.13) 281.89,20.06 281.33,20.06 RZ41.1 281.32,20.82 v3(281.61,21.11)
  IN2 w0.099: v2(41.33,25.55) 41.54,25.55 44.01,23.07 46,23.07 46.74,22.34 v2(46.74,21.03)
  IN3 w0.089: 101.98,4.18 101.88,4.07 99.32,4.07 99.22,4.17 97.63,4.17 97.55,4.09 92.8,4.09 92.53,3.82 91.27,3.82 91.1,3.99 90.29,3.99 90.03,4.25 88.51,4.25 88.32,4.07 86.97,4.07 86.66,4.38 85.91,4.38 85.59,4.07 79.85,4.07 79.52,3.74 76.37,3.74 75.39,2.75 75.06,2.75
  IN3 w0.091: v2(6.64,17.8) 6.11,17.8 5.77,18.15 5.77,21.65 6.56,22.45 6.56,24.81 3.89,27.48 3.89,38.04 3.28,38.64 v2(2.49,38.64) ; 75.06,2.75 73.39,2.75 73.07,3.08 70.91,3.08 69.78,1.94 67.5,1.94 65.87,3.58 64.57,3.58 63.06,5.09 61.63,5.09 59.77,6.96 59.05,6.96 57.85,8.16 57.85,12.45 53.47,16.83 53.47,18.38 51.45,20.39 50.49,20.39 49.61,21.27 46.98,21.27 v2(46.74,21.03) ; 101.98,4.18 104.59,4.18 106.42,6.01 114.92,6.01 117.4,8.49 120.15,8.49 122.04,10.38 127.72,10.38 128.7,9.39 134.97,9.39 135.87,10.3 146.72,10.3 147.97,9.05 152.04,9.05 152.77,9.77 155.62,9.77 155.96,10.11 163.23,10.11 164.38,11.25 210.15,11.25 213.9,7.5 221.43,7.5 223.28,9.35 230.96,9.35 231.77,10.16 242.65,10.16 243.43,10.93 252.74,10.93 254.46,12.65 257.1,12.65 257.32,12.87 261.26,12.87 261.37,12.98 267.15,12.98 269.19,15.02 278.09,15.02 280.03,16.97 281.04,16.97 281.49,17.41 281.49,19.66 v2(281.95,20.13)
  IN4 w0.091: v2(24.86,50.41) 24.88,50.41 25.74,51.27 26.86,51.27 28.17,49.97 30.45,49.97 31.14,49.28 31.14,45.68 32.73,44.09 33.39,44.09 34.8,42.68 34.8,41.41 38.01,38.2 38.95,38.2 39.63,38.88 39.63,39.89 40.01,40.27 40.51,40.27 42.55,38.24 42.93,38.24 43.44,37.73 43.44,34.17 43.53,34.08 43.53,29.94 43,29.41 43,27.39 41.33,25.72 v2(41.33,25.55)
  IN6 w0.099: v2(41.33,25.55) 40.72,24.95 36.67,24.95 36.67,24.95 30.88,24.95 30.48,25.35 24.87,25.35 23.88,24.36 22.41,24.36 21.38,23.34 20.23,23.34 18.3,21.4 18.3,18.49 16.74,16.94 9.56,16.94 9.32,16.7 7.75,16.7 v2(6.64,17.8)
  BOTTOM w0.14: v2(297.41,8.05) 297.31,8.05 296.31,7.05 289.4,7.05 289.29,7.16 284.57,7.16 281.69,10.04 281.69,13.14 281.82,13.28 281.82,18.14 281.95,18.28 v2(281.95,20.13) ; RT245.2 2.99,38.19 2.53,38.64 v2(2.49,38.64)
UPD_SMBCLK: length 10.2
  TOP w0.14: v2(8.97,40.94) 8.97,41.44 8.26,42.15 8.26,42.59 RT192.2 8.6,42.77 8.81,42.56 8.81,42.32 8.97,42.16 QT1.3 ; v2(12.41,42.05) 13.46,41 RT201.2
  IN2 w0.099: v2(12.41,42.05) 12.1,41.74 12.03,41.74 11.13,40.84 9.07,40.84 v2(8.97,40.94)
  BOTTOM w0.081: UT4.B5 9.05,40.17 9.05,40.86 v2(8.97,40.94)
UPD_SMBDAT: length 9.4
  TOP w0.14: v2(9.64,44.02) 10.32,43.34 11.12,43.34 QT1.6 11.82,43.46 12.1,43.18 RT200.2 13.34,43.18 RT193.2 14.01,42.5 v3(14.39,42.5)
  BOTTOM w0.081: UT4.A5 9.3,40.73 9.35,40.77 9.35,41.08 9.2,41.23 9.2,41.35
  BOTTOM w0.14: 9.2,41.35 9.2,43.59 v2(9.64,44.02)
USB3RN1: length 237.9
  IN3 w0.099: v2(313.98,25.5) 314.16,25.33 314.16,25.25 313.94,25.03 306.03,25.03 305.4,25.65 293.32,25.65 292.47,24.8 289.46,24.8 288.21,23.55 281.5,23.55 279.48,21.53 270.7,21.53 268.45,19.28 257.59,19.28 257.28,18.97 253.96,18.97 251.37,16.38 231.53,16.38 230.66,15.5 223.01,15.5 222.15,14.64 125.49,14.64 123.42,16.71 123.42,17.37 120.91,19.88 109.59,19.88 108.94,20.53 108.94,20.92 107.96,21.89 107.96,22.57 106.26,24.27 103.52,24.27 102.06,25.73 100.71,25.73 99.83,26.62 97.52,26.62 97.32,26.82 97.23,26.82 v2(96.78,27.28)
  BOTTOM w0.089: UH2.B7 96.09,25.61 96.09,25.88 96.17,25.95 96.17,26.76 96.57,27.16 96.66,27.16 v2(96.78,27.28)
  BOTTOM w0.152: CI8.1 318.8,27.47 318.8,27.15 318.15,26.5 314.49,26.5 314.12,26.13 314.12,25.64 v2(313.98,25.5)
USB3RN1_C: length 1.8
  BOTTOM w0.14: UI3.23 318.91,29.05 CI8.2
USB3RN1_D-: length 7.4
  TOP w0.152: JUSB2.5 335.82,76.31 335.61,76.11 334.74,76.11 334.24,75.61 334.24,74.55 334.05,74.36 333.85,74.36 333.76,74.44 DI9.9 DI9.1 332.2,74.44 332.14,74.38 331.01,74.38 RI40.2
USB3RN1_RE: length 45.9
  TOP w0.152: v2(328.35,74.43) 328.4,74.38 329.49,74.38 RI40.1
  IN2 w0.107: v2(328.35,74.43) 328.14,74.23 327.58,74.23 327.07,73.71 327.07,56.73 325.24,54.89 325.24,47.12 318.88,40.77 v2(318.88,35.37)
  BOTTOM w0.152: UI3.8 318.91,34.89 318.92,34.9 318.92,35.33 v2(318.88,35.37)
USB3RN2: length 148.8
  TOP w0.152: v2(23.78,102.46) 23.65,102.59 23.03,102.59 RI44.1
  IN3 w0.099: v2(95.54,26.21) 95.77,26.44 95.98,26.44 96.2,26.66 96.2,27.38 96,27.58 95.44,27.58 95.01,28.01 89.28,28.01 86.56,25.29 84.02,25.29 82.73,24 81.02,24 80.69,24.33 79.67,24.33 79.56,24.44 77.93,24.44 77.29,23.81 76.32,23.81 75.67,24.46 57.7,24.46 56.78,25.37 52.15,25.37 51.65,25.87 48.54,25.87 47.78,26.63 46.06,26.63 45.76,26.93 45.76,27.67 43.55,29.88 42.24,29.88 41.96,30.16 41.96,30.7 41.88,30.78 41.28,31.38 40.07,31.38 34.34,37.1 34.34,41.13 34.53,41.32 34.53,44.57 33.85,45.25 33.85,46.74 33.16,47.43 33.16,48.84 29.72,52.27 27.88,52.27 27.5,52.65 27.5,54.75 27.04,55.21 27.04,58.43 26.61,58.86 26.61,62.43 24.4,64.64 24.4,66.75 22.11,69.04 22.11,87.22 21.67,87.67 21.67,101.69 22.67,102.69 23.55,102.69 v2(23.78,102.46)
  BOTTOM w0.089: UH2.C8 95.51,25.22 95.51,25.47 95.62,25.57 95.62,26.13 v2(95.54,26.21)
USB3RN2_D-: length 7.7
  TOP w0.152: JUSB1.5 17.08,100.1 17.5,100.1 18.14,100.73 v4(18.14,101.1) 18.14,102.05 18.47,102.39 DI7.9 DI7.1 19.96,102.39 20.04,102.47 21.29,102.47 RI44.2
USB3RP1: length 238
  IN3 w0.099: v2(314.57,25.5) 314.35,25.29 314.35,25.17 314.02,24.84 305.95,24.84 305.32,25.46 293.4,25.46 292.55,24.61 289.54,24.61 288.29,23.36 281.58,23.36 279.56,21.34 270.78,21.34 268.53,19.09 257.67,19.09 257.36,18.78 254.04,18.78 251.45,16.19 231.61,16.19 230.74,15.31 223.09,15.31 222.23,14.45 125.42,14.45 123.23,16.63 123.23,17.29 120.83,19.69 109.51,19.69 108.75,20.46 108.75,20.84 107.77,21.81 107.77,22.49 106.19,24.08 103.44,24.08 101.98,25.54 100.64,25.54 99.75,26.42 97.45,26.42 97.24,26.63 96.99,26.63 v2(96.79,26.42)
  BOTTOM w0.089: UH2.A7 96.5,25.83 96.5,26.06 96.36,26.2 96.36,26.68 96.57,26.89 97,26.89 97.08,26.82 97.08,26.72 v2(96.79,26.42)
  BOTTOM w0.152: v2(314.57,25.5) 314.45,25.62 314.45,25.99 314.63,26.17 318.29,26.17 319.13,27.01 319.13,27.47 CI7.1
USB3RP1_C: length 1.8
  BOTTOM w0.14: UI3.22 319.41,29.95 319.23,29.76 319.23,28.84 CI7.2
USB3RP1_D+: length 7.3
  TOP w0.152: RI39.2 331.09,74.05 332.14,74.05 332.25,73.94 DI9.2 DI9.8 333.74,73.94 333.82,74.03 334.18,74.03 334.57,74.41 334.57,75.47 334.87,75.78 335.57,75.78 335.82,75.53 JUSB2.6
USB3RP1_RE: length 45.9
  TOP w0.152: RI39.1 329.52,74.05 328.58,74.05 328.37,73.85 v2(328.33,73.85)
  IN2 w0.107: v2(328.33,73.85) 328.15,74.02 327.67,74.02 327.27,73.63 327.27,56.64 325.44,54.81 325.44,47.04 319.08,40.68 319.08,35.75 v2(319.46,35.37)
  BOTTOM w0.152: UI3.9 319.41,34.84 319.28,34.97 319.28,35.19 v2(319.46,35.37)
USB3RP2: length 148.9
  TOP w0.152: RI43.1 22.77,102.92 23.65,102.92 v2(23.78,103.04)
  IN3 w0.099: v2(23.78,103.04) 23.61,102.88 22.59,102.88 21.48,101.76 21.48,87.59 21.92,87.15 21.92,68.96 24.21,66.67 24.21,64.56 26.42,62.35 26.42,58.78 26.85,58.35 26.85,55.13 27.31,54.67 27.31,52.57 27.8,52.08 29.65,52.08 32.97,48.76 32.97,47.35 33.66,46.67 33.66,45.17 34.34,44.49 34.34,41.4 34.15,41.21 34.15,37.03 39.99,31.19 41.2,31.19 41.65,30.73 41.77,30.62 41.77,30.09 42.16,29.69 43.47,29.69 45.57,27.59 45.57,26.85 45.98,26.44 47.7,26.44 48.46,25.68 51.57,25.68 52.07,25.18 56.71,25.18 57.62,24.27 75.59,24.27 76.24,23.62 77.37,23.62 78,24.25 79.48,24.25 79.59,24.14 80.61,24.14 80.94,23.81 82.81,23.81 84.1,25.1 86.64,25.1 89.36,27.82 94.93,27.82 95.37,27.39 95.92,27.39 96.01,27.3 96.01,26.74 95.9,26.63 95.77,26.63 v2(95.54,26.86)
  BOTTOM w0.089: v2(95.54,26.86) 95.71,26.86 95.91,26.65 95.91,25.59 95.78,25.45 UH2.B8
USB3RP2_D+: length 7.7
  TOP w0.152: JUSB1.6 16.95,100.43 17.36,100.43 17.81,100.87 17.81,102.19 18.5,102.89 DI7.8 DI7.2 19.93,102.89 20.02,102.8 21.31,102.8 RI43.2
USB3T_N1: length 40.8
  TOP w0.152: RI37.1 329.59,72.53 328.38,72.53 v2(328.33,72.58)
  IN2 w0.107: v2(328.33,72.58) 328.18,72.42 327.87,72.42 327.68,72.24 327.68,56.14 326.7,55.15 326.7,47.21 320.5,41.01 320.5,37.96 v2(320.38,37.85)
  BOTTOM w0.152: CI16.2 320.49,37.23 320.49,37.75 v2(320.38,37.85)
USB3T_N2: length 2.5
  TOP w0.152: RI41.1 22.89,104.35 23.65,104.35 v2(23.78,104.23)
  BOTTOM w0.152: CI9.2 23.1,104.31 23.69,104.31 v2(23.78,104.23)
USB3T_P1: length 40.8
  TOP w0.152: RI38.1 329.46,72.2 328.53,72.2 v2(328.33,71.99)
  IN2 w0.107: v2(320.97,37.85) 320.7,38.11 320.7,40.93 326.9,47.13 326.9,55.06 327.89,56.05 327.89,72.16 327.95,72.22 328.12,72.22 328.33,72.01 v2(328.33,71.99)
  BOTTOM w0.152: v2(320.97,37.85) 320.82,37.7 320.82,37.33 321.11,37.04 CI20.2
USB3T_P2: length 2.6
  TOP w0.152: RI42.1 22.91,104.68 23.65,104.68 v2(23.78,104.81)
  BOTTOM w0.152: v2(23.78,104.81) 23.61,104.64 23.08,104.64 CI10.2
USB3TN1: length 243.8
  IN3 w0.099: v2(314.06,23.29) 314.33,23.55 314.33,23.72 314.2,23.85 289.84,23.85 288.76,22.76 281.83,22.76 279.27,20.2 273.07,20.2 270.77,17.9 261.05,17.9 260.59,17.44 253.54,17.44 251.7,15.59 247.53,15.59 246.92,14.98 245.21,14.98 244.62,15.57 231.89,15.57 230.94,14.61 223.39,14.61 222.23,13.45 211.94,13.45 211.83,13.56 124.87,13.56 121.98,16.44 121.98,17.42 120.66,18.74 104.74,18.74 101.98,21.5 101.78,21.5 99.56,23.72 99.56,24.38 98.74,25.19 95.64,25.19 94.98,25.85 94.98,26.32 94.85,26.45 94.57,26.45 94.38,26.27 v2(94.38,26.2)
  BOTTOM w0.089: UH2.C11 94.73,24.94 94.46,25.21 94.46,25.52 94.5,25.56 94.5,25.71 94.68,25.89 94.68,26.09 94.57,26.2 v2(94.38,26.2)
  BOTTOM w0.152: CI6.1 320.57,27.47 v4(320.57,26.26) 320.57,25.8 319.06,24.29 314.55,24.29 314.2,23.94 314.2,23.43 v2(314.06,23.29)
USB3TN1_C: length 1.8
  BOTTOM w0.152: UI3.20 320.41,29.93 320.52,29.82 320.52,28.89 CI6.2
USB3TN1_D-: length 8
  TOP w0.152: RI37.2 330.96,72.58 331.59,72.58 331.86,72.84 332.09,72.84 332.18,72.94 DI9.4 DI9.7 333.76,72.94 333.85,72.86 334.13,72.86 334.6,72.39 334.6,70.69 335.19,70.1 335.33,70.1 335.82,70.59 JUSB2.8
USB3TN1_RE: length 1.8
  BOTTOM w0.152: CI16.1 320.54,35.89 320.54,34.98 320.41,34.86 UI3.11
USB3TN2: length 152.7
  IN3 w0.099: v2(93.52,25.82) 93.31,26.03 93.13,26.03 92.9,26.26 92.9,26.79 92.58,27.11 89.74,27.11 89.36,26.73 89.36,25.93 87.49,24.06 84.99,24.06 84.7,23.77 84.24,23.77 83.55,23.08 83.55,21.7 83.17,21.32 82.14,21.32 81.95,21.51 80.7,21.51 80.13,22.08 76.77,22.08 75.18,23.67 72.08,23.67 71.44,23.03 66.22,23.03 65.71,23.54 57.42,23.54 56.37,24.58 52.91,24.58 52.66,24.33 51.42,24.33 50.67,25.08 48.21,25.08 47.45,25.84 45.65,25.84 44.34,27.16 44.34,27.7 42.95,29.08 41.53,29.08 40.04,30.57 39.76,30.57 33.4,36.92 33.4,41.46 33.75,41.81 33.75,43.27 33.01,44.01 31.81,44.01 31.44,44.39 31.44,48.24 31.21,48.48 31.21,49.5 30.34,50.36 28.65,50.36 26.67,52.34 26.67,54.43 26.25,54.85 26.25,58.09 25.81,58.53 25.81,62.07 23.48,64.4 23.48,66 20.65,68.83 20.65,79.08 19.8,79.93 19.8,100.8 20.17,101.16 20.17,101.89 21.24,102.96 21.24,104.36 20.5,105.1 20.23,105.1 v2(20.03,104.9)
  BOTTOM w0.089: v2(93.52,25.82) 93.61,25.82 94.11,25.31 UH2.B12
  BOTTOM w0.152: CI9.1 21.62,104.3 21.21,104.3 20.43,105.09 20.22,105.09 v2(20.03,104.9)
USB3TN2_D-: length 7.8
  TOP w0.152: JUSB1.8 17.01,106.02 17.55,106.02 17.78,105.79 17.78,104.44 18.2,104.02 18.28,104.02 18.42,103.89 DI7.7 DI7.4 19.88,103.89 19.97,103.97 20.27,103.97 20.6,104.3 21.36,104.3 RI41.2
USB3TP1: length 243.8
  IN3 w0.099: v2(314.64,23.29) 314.52,23.41 314.52,23.47 314.52,23.8 314.28,24.04 289.76,24.04 288.68,22.96 281.75,22.96 279.19,20.39 272.99,20.39 270.69,18.09 260.97,18.09 260.51,17.63 253.46,17.63 251.62,15.78 247.45,15.78 246.84,15.17 245.29,15.17 244.7,15.76 231.81,15.76 230.86,14.8 223.32,14.8 222.15,13.64 212.02,13.64 211.91,13.75 124.95,13.75 122.18,16.52 122.18,17.5 120.74,18.93 104.82,18.93 102.06,21.69 101.86,21.69 99.75,23.8 99.75,24.46 98.82,25.38 95.72,25.38 95.17,25.93 95.17,26.4 94.92,26.65 94.69,26.65 v2(94.51,26.83)
  BOTTOM w0.089: UH2.B11 94.73,25.64 94.88,25.79 94.88,26.46 v2(94.51,26.83)
  BOTTOM w0.152: CI5.1 320.9,27.47 320.9,25.67 319.2,23.96 314.69,23.96 314.53,23.8 314.53,23.4 v2(314.64,23.29)
USB3TP1_C: length 1.8
  BOTTOM w0.152: CI5.2 320.85,28.99 320.85,29.85 320.91,29.91 UI3.19
USB3TP1_D+: length 8.1
  TOP w0.152: RI38.2 331.19,72.25 331.73,72.25 331.99,72.51 332.14,72.51 332.22,72.44 DI9.5 DI9.6 333.76,72.44 333.85,72.53 333.99,72.53 334.27,72.25 334.27,70.56 335.05,69.77 335.37,69.77 335.82,69.32 JUSB2.9
USB3TP1_RE: length 1.8
  BOTTOM w0.152: UI3.12 320.91,34.87 320.87,34.91 320.87,35.81 CI20.1
USB3TP2: length 152.6
  IN3 w0.099: v2(93.5,26.41) 93.31,26.22 93.21,26.22 93.09,26.34 93.09,26.87 92.66,27.3 89.66,27.3 89.17,26.81 89.17,26.01 87.42,24.25 84.91,24.25 84.62,23.96 84.16,23.96 83.36,23.16 83.36,21.78 83.09,21.51 82.22,21.51 82.03,21.7 80.78,21.7 80.2,22.27 76.85,22.27 75.26,23.86 72,23.86 71.36,23.22 66.3,23.22 65.79,23.73 57.49,23.73 56.45,24.77 52.83,24.77 52.58,24.52 51.5,24.52 50.74,25.27 48.29,25.27 47.53,26.03 45.73,26.03 44.53,27.24 44.53,27.78 43.03,29.27 41.61,29.27 40.12,30.76 39.83,30.76 33.59,37 33.59,41.38 33.94,41.73 33.94,43.35 33.08,44.2 31.89,44.2 31.63,44.46 31.63,48.32 31.4,48.56 31.4,49.57 30.42,50.55 28.73,50.55 26.86,52.42 26.86,54.51 26.44,54.93 26.44,58.16 26,58.61 26,62.15 23.67,64.48 23.67,66.07 20.84,68.91 20.84,79.16 19.99,80.01 19.99,100.72 20.36,101.09 20.36,101.81 21.43,102.88 21.43,104.44 20.58,105.29 20.22,105.29 v2(20.03,105.48)
  BOTTOM w0.089: v2(93.5,26.41) 94.11,25.8 UH2.A12
  BOTTOM w0.152: CI10.1 21.62,104.63 21.35,104.63 20.56,105.42 20.09,105.42 v2(20.03,105.48)
USB3TP2_D+: length 7.8
  TOP w0.152: JUSB1.9 17.03,106.35 17.68,106.35 18.11,105.93 v4(18.11,105.55) 18.11,104.58 18.34,104.35 18.71,104.35 DI7.6 DI7.5 19.89,104.39 19.97,104.3 20.13,104.3 20.46,104.63 21.24,104.63 RI42.2
USB20_N1: length 268.7
  IN1 w0.107: v2(329.81,59.08) 329.78,59.08 329.6,58.91 329.6,56.92 327.36,54.67 327.36,50.22 326.26,49.12 326.26,48.33 324.81,46.87 324.81,46.87 322.19,44.26 319.24,44.26 314.72,39.74 314.72,39.03 313.69,38 313.18,38 306.91,31.73 306.91,31.1 304.88,29.07 304.88,26.21 304.26,25.6 304.26,24.64 303.77,24.15 297.17,24.15 296.72,23.7 291.78,23.7 290.99,22.91 290.99,22.64 290.14,21.79 282.53,21.79 281.47,20.73 279.07,20.73 277.57,19.24 274.26,19.24 273.18,18.16 270.63,18.16 266.31,13.85 265.88,13.85 265.06,13.03 263.59,13.03 262.53,11.97 260.5,11.97 259.44,10.92 254.16,10.92 253.25,11.82 243.66,11.82 243.1,12.38 224.91,12.38 224.58,12.06 215.89,12.06 215.1,12.84 176.17,12.84 175.47,13.54 155.16,13.54 153.92,14.79 151.49,14.79 151.03,15.25 130.16,15.25 128.16,17.25 102.92,17.25 102.19,16.52 102.19,16.02 100.9,14.74 99.71,14.74 99.18,14.21 97.44,14.21 97.32,14.09 97.32,13.87 v2(97.44,13.75)
  BOTTOM w0.089: UH2.AF5 97.44,13.24 v2(97.44,13.75)
  BOTTOM w0.152: v2(329.81,59.08) 329.63,59.26 329.63,60.78 329.99,61.13 329.99,61.46 330.07,61.54 UI2.2
USB20_N2: length 173
  TOP w0.152: UI1.2 25.14,88.7 25.22,88.62 25.22,86.33 24.77,85.87 23.85,85.87 23.53,85.55 23.53,85.11 v2(23.42,84.99)
  IN6 w0.107: v2(97.71,14.8) 97.71,15.12 97.62,15.21 91.45,15.21 90.32,16.34 90.32,17.92 90.01,18.23 85.59,18.23 85.17,17.81 85.17,17.31 83.56,15.7 75.62,15.7 71.16,20.16 68.66,20.16 66.8,22.02 65.19,22.02 61.91,25.29 58.52,25.29 56.02,27.8 50.42,27.8 49.86,28.35 46.19,28.35 43.63,30.92 35.21,30.92 34.59,30.3 34.04,30.3 32.85,29.11 28.98,29.11 27.39,30.7 25.55,30.7 24.91,30.07 21.4,30.07 20.21,28.88 15.34,28.88 14.13,30.09 14.13,31.15 16.55,33.58 16.55,36.67 15.89,37.33 15.89,40.06 16.18,40.35 17.31,40.35 19.74,42.78 19.74,49.75 20.29,50.29 20.29,56.64 19.36,57.57 19.36,60.73 18.52,61.56 18.52,65.36 16.88,66.99 16.88,76.69 18.14,77.94 18.14,78.93 18.9,79.69 18.9,85.84 21.39,88.33 22.4,88.33 22.99,87.73 22.99,86.44 23.72,85.71 23.72,85.29 v2(23.42,84.99)
  BOTTOM w0.089: UH2.AD5 97.4,14.26 97.31,14.35 97.31,14.44 97.68,14.8 v2(97.71,14.8)
USB20_N4: length 291.7
  IN1 w0.107: v2(324.09,81.08) 324.47,81.46 324.98,81.46 325.49,80.95 325.49,69.11 329.03,65.57 329.03,61.6 330.76,59.87 330.76,57.49 327.9,54.63 327.9,49.72 327.53,49.35 327.53,48.6 325.26,46.32 322.76,43.82 319.47,43.82 315.34,39.7 315.34,39.07 313.86,37.59 313.49,37.59 310.41,34.51 310.41,32.88 308.84,31.31 307.71,31.31 305.92,29.52 305.92,27.96 306.31,27.57 306.31,26.73 305.75,26.17 305.75,24.71 305.5,24.46 304.67,24.46 303.95,23.73 297.33,23.73 296.89,23.29 296.08,23.29 295.86,23.07 292.34,23.07 290.6,21.33 285.1,21.33 284.09,20.32 284.01,20.32 282.95,20.32 282.3,19.67 279.24,19.67 278.38,18.8 274.43,18.8 273.29,17.66 270.73,17.66 266.5,13.43 266.05,13.43 265.19,12.58 263.72,12.58 262.21,11.07 260.18,11.07 259.62,10.51 253.79,10.51 252.98,11.32 225.16,11.32 224.83,11.64 215.37,11.64 214.66,12.36 175.84,12.36 175.1,13.09 155,13.09 153.72,14.37 151.1,14.37 150.66,14.82 130.01,14.82 128.68,16.15 105.2,16.15 104.49,15.44 102.42,15.44 101.15,14.17 100.82,14.17 100.5,14.5 100.06,14.5 99.98,14.41 99.98,14.3 100.22,14.06 v2(100.36,14.06)
  BOTTOM w0.089: UH2.AE1 99.33,13.97 99.66,14.29 100.12,14.29 v2(100.36,14.06)
  BOTTOM w0.152: v2(324.09,81.08) 324.18,81.17 324.48,81.17 324.56,81.09 LN1.1
USB20_N4_R: length 5.4
  BOTTOM w0.152: LN1.2 327.8,81.09 328.13,81.42 328.13,82.18 328.45,82.5 329.26,82.5 329.55,82.79 JNGFF1.5
USB20_N9: length 252.6
  IN1 w0.107: v2(320.24,45.53) 319.86,45.53 319.32,45 318.73,45 304.05,30.32 304.05,28.51 300.88,25.35 297.49,25.35 296.46,24.32 290.43,24.32 288.52,22.4 286.4,22.4 286.1,22.7 282.3,22.7 280.95,21.34 278.81,21.34 277.37,19.9 273.93,19.9 273.35,19.32 268.98,19.32 268.29,18.63 268.29,16.69 266.09,14.49 265.61,14.49 264.77,13.65 263.26,13.65 262.65,13.04 260.7,13.04 259.22,11.57 254.38,11.57 253.51,12.44 243.92,12.44 243.36,13 224.65,13 224.33,12.67 216.38,12.67 215.6,13.46 176.54,13.46 175.85,14.16 155.5,14.16 154.2,15.45 151.88,15.45 151.25,16.09 130.2,16.09 128.29,17.99 100.86,17.99 99.98,17.1 99.98,16.85 100.31,16.52 v2(100.34,16.52)
  BOTTOM w0.089: UH2.AA1 99.45,16.16 99.45,16.16 99.47,16.16 99.52,16.11 99.93,16.11 v2(100.34,16.52)
  BOTTOM w0.152: LI1.1 328.09,44.51 328.01,44.43 328.01,43.66 327.66,43.31 326.91,43.31 325.31,44.91 321.94,44.91 320.91,45.94 320.64,45.94 v2(320.24,45.53)
USB20_N9_R: length 12
  BOTTOM w0.152: JTS.4 331.39,50.09 331.16,49.86 331.16,49.74 v4(331.63,49.27) 332.61,48.28 332.61,47.21 331.89,46.49 331.51,46.49 331.28,46.26 DI3.2 330.92,45.72 330.13,46.52 329.99,46.52 329.68,46.52 329.19,47.01 329.19,47.48 328.98,47.68 328.32,47.68 328.01,47.37 328.01,46.88 328.09,46.8 LI1.2
USB20_N12: length 50.6
  IN1 w0.107: v2(58.19,18.32) 59.2,18.32 60.92,16.61 61.86,16.61 62.21,16.95 64.8,16.95 65.18,17.33 71.47,17.33 71.92,16.87 77.13,16.87 78.18,17.92 83.09,17.92 83.63,18.46 91.9,18.46 93.64,16.72 98.5,16.72 99.11,16.11 100.21,16.11 100.44,15.88 100.44,15.48 v2(100.57,15.35)
  BOTTOM w0.089: UH2.AD3 98.69,14.29 99.12,14.29 99.3,14.47 100.21,14.47 100.53,14.79 100.53,15.31 v2(100.57,15.35)
  BOTTOM w0.152: v2(58.19,18.32) 58.3,18.21 58.54,18.21 58.65,18.32 58.65,18.5 58.19,18.96 58.19,19.34 LV22.1
USB20_N12_R: length 17
  BOTTOM w0.152: JEDP1.31 56.55,31.36 57.06,30.84 58.53,30.84 60.07,29.31 60.07,27.82 59.59,27.33 59.59,27.02 v3(60.07,26.54) DV12.3 60.07,24.57 59.69,24.19 59.13,24.19 58.7,23.75 57.98,23.75 57.97,23.75 57.95,23.75 57.52,23.32 57.52,22.34 58.21,21.65 58.21,21.36 58.29,21.27 LV22.2
USB20_P1: length 268.8
  IN1 w0.107: v2(96.88,13.75) 97.12,13.99 97.12,14.17 97.36,14.41 99.09,14.41 99.62,14.94 100.82,14.94 101.98,16.11 101.98,16.6 102.83,17.45 128.25,17.45 130.25,15.45 151.11,15.45 151.57,14.99 154,14.99 155.25,13.75 175.56,13.75 176.26,13.05 215.18,13.05 215.97,12.26 224.5,12.26 224.82,12.58 243.19,12.58 243.75,12.03 253.34,12.03 254.25,11.12 259.36,11.12 260.41,12.17 262.44,12.17 263.51,13.24 264.98,13.24 265.79,14.05 266.23,14.05 270.54,18.36 273.1,18.36 274.18,19.44 277.49,19.44 278.98,20.93 281.39,20.93 282.45,21.99 290.05,21.99 290.79,22.72 290.79,23 291.7,23.91 296.63,23.91 297.08,24.35 303.68,24.35 304.06,24.73 304.06,25.68 304.67,26.3 304.67,29.16 306.71,31.19 306.71,31.82 313.1,38.21 313.61,38.21 314.52,39.12 314.52,39.82 319.15,44.46 322.11,44.46 324.72,47.08 324.72,47.08 326.06,48.41 326.06,49.21 327.15,50.3 327.15,54.75 329.4,57 329.4,58.91 v2(329.22,59.08)
  BOTTOM w0.089: v2(96.88,13.75) 96.88,13.34 UH2.AG7
  BOTTOM w0.152: v2(329.22,59.08) 329.3,59.16 329.3,60.92 329.65,61.27 329.65,61.46 329.57,61.54 UI2.3
USB20_P2: length 173
  TOP w0.152: UI1.3 25.64,88.73 25.55,88.64 25.55,86.19 24.91,85.54 23.99,85.54 23.86,85.42 23.86,85.13 v2(24,84.99)
  IN6 w0.107: v2(24,84.99) 23.92,85.08 23.92,85.8 23.2,86.52 23.2,87.82 22.49,88.53 21.3,88.53 18.69,85.92 18.69,79.77 17.93,79.01 17.93,78.03 16.68,76.78 16.68,66.91 18.31,65.28 18.31,61.48 19.15,60.64 19.15,57.49 20.08,56.56 20.08,50.38 19.54,49.83 19.54,42.86 17.23,40.55 16.09,40.55 15.69,40.15 15.69,37.24 16.35,36.59 16.35,33.66 13.92,31.24 13.92,30.01 15.26,28.67 20.29,28.67 21.48,29.87 24.99,29.87 25.63,30.5 27.3,30.5 28.9,28.91 32.93,28.91 34.13,30.1 34.68,30.1 35.29,30.72 43.54,30.72 46.11,28.15 49.78,28.15 50.34,27.59 55.94,27.59 58.44,25.09 61.83,25.09 65.11,21.81 66.72,21.81 68.57,19.96 71.07,19.96 75.54,15.5 83.64,15.5 85.37,17.23 85.37,17.73 85.67,18.03 89.93,18.03 90.12,17.84 90.12,16.25 91.36,15.01 96.95,15.01 v2(97.14,14.82)
  BOTTOM w0.089: UH2.AD7 96.7,14.37 v2(97.14,14.82)
USB20_P4: length 291.8
  IN1 w0.107: v2(99.81,13.92) 99.81,13.89 100.02,13.69 100.53,13.69 100.82,13.97 101.24,13.97 102.51,15.24 104.58,15.24 105.28,15.95 128.59,15.95 129.93,14.61 150.57,14.61 151.02,14.17 153.64,14.17 154.92,12.89 175.02,12.89 175.75,12.15 214.58,12.15 215.29,11.44 224.75,11.44 225.08,11.11 252.9,11.11 253.71,10.3 259.7,10.3 260.26,10.87 262.3,10.87 263.81,12.38 265.28,12.38 266.13,13.23 266.58,13.23 270.81,17.46 273.37,17.46 274.52,18.6 278.46,18.6 279.33,19.47 282.39,19.47 283.04,20.12 283.92,20.12 284.17,20.12 285.19,21.13 290.68,21.13 292.42,22.87 295.94,22.87 296.16,23.09 296.97,23.09 297.41,23.53 304.03,23.53 304.76,24.25 305.58,24.25 305.96,24.63 305.96,26.09 306.52,26.65 306.52,27.65 306.12,28.05 306.12,29.44 307.79,31.11 308.93,31.11 310.62,32.8 310.62,34.43 313.58,37.39 313.95,37.39 315.55,38.99 315.55,39.61 319.55,43.62 322.84,43.62 325.46,46.24 327.74,48.51 327.74,49.26 328.11,49.63 328.11,54.55 330.97,57.41 330.97,59.95 329.24,61.68 329.24,65.65 325.69,69.19 325.69,81.03 325.06,81.66 v2(324.09,81.66)
  BOTTOM w0.089: UH2.AE2 98.96,13.88 99.22,13.62 99.5,13.62 v2(99.81,13.92)
  BOTTOM w0.152: LN1.4 324.56,81.59 324.48,81.5 324.25,81.5 v2(324.09,81.66)
USB20_P4_R: length 5.4
  BOTTOM w0.152: JNGFF1.3 329.05,83.21 329.22,83.04 329.22,82.92 329.12,82.83 328.31,82.83 327.8,82.32 v4(327.8,81.9) 327.8,81.56 327.65,81.41 327.45,81.41 327.34,81.51 327.34,81.71 327.2,81.85 326.97,81.85 326.7,81.59 LN1.3
USB20_P9: length 252.5
  IN1 w0.107: v2(319.67,46.11) 319.82,45.95 319.82,45.78 319.24,45.2 318.65,45.2 303.85,30.4 303.85,28.6 300.8,25.55 297.41,25.55 296.38,24.52 290.35,24.52 288.43,22.6 286.48,22.6 286.19,22.9 282.22,22.9 280.87,21.55 278.73,21.55 277.29,20.11 273.85,20.11 273.26,19.52 268.89,19.52 268.09,18.72 268.09,16.77 266,14.69 265.52,14.69 264.69,13.85 263.17,13.85 262.57,13.24 260.61,13.24 259.14,11.77 254.47,11.77 253.59,12.64 244,12.64 243.44,13.2 224.57,13.2 224.24,12.87 216.47,12.87 215.68,13.66 176.63,13.66 175.93,14.36 155.58,14.36 154.28,15.66 151.97,15.66 151.33,16.29 130.28,16.29 128.37,18.2 100.78,18.2 99.77,17.19 v2(99.77,16.49)
  BOTTOM w0.089: v2(99.77,16.49) 99.67,16.39 99.16,16.39 98.93,16.16 UH2.AA2
  BOTTOM w0.152: LI1.4 327.59,44.53 327.68,44.44 327.68,43.8 327.52,43.64 327.05,43.64 325.45,45.24 322.08,45.24 321.05,46.27 320.51,46.27 320.34,46.11 v2(319.67,46.11)
USB20_P9_R: length 12.1
  BOTTOM w0.152: LI1.3 327.59,46.8 327.68,46.88 327.68,47.51 328.18,48.01 v4(328.61,48.01) 329.12,48.01 329.52,47.62 329.52,47.15 329.82,46.85 330.12,46.85 330.92,47.65 DI3.3 331.28,47.06 331.52,46.82 331.75,46.82 332.28,47.35 332.28,48.14 330.82,49.6 330.82,49.85 330.59,50.09 JTS.5
USB20_P12: length 50.6
  IN1 w0.107: v2(99.96,15.38) 100.1,15.38 100.24,15.51 100.24,15.8 100.13,15.91 99.03,15.91 98.42,16.52 93.56,16.52 91.82,18.26 83.71,18.26 83.17,17.72 78.26,17.72 77.21,16.67 71.84,16.67 71.38,17.12 65.26,17.12 64.89,16.75 62.29,16.75 61.95,16.4 60.83,16.4 59.12,18.12 58.65,18.12 v2(58.26,17.73)
  BOTTOM w0.089: v2(99.96,15.38) 100.03,15.38 100.27,15.13 100.27,14.9 100.03,14.66 99.23,14.66 99.1,14.79 98.75,14.79 98.65,14.7 98.65,14.6 98.75,14.5 98.9,14.5 UH2.AD2
  BOTTOM w0.152: LV22.4 57.86,19.37 57.86,18.66 57.76,18.55 57.76,18.14 58.18,17.73 v2(58.26,17.73)
USB20_P12_R: length 17
  BOTTOM w0.152: JEDP1.32 56.05,32.3 56.22,32.13 56.22,31.22 56.92,30.51 58.4,30.51 59.74,29.17 59.74,27.95 58.47,26.68 v3(58.36,26.68) 58.17,26.49 DV12.1 58.17,24.56 58.23,24.49 58.51,24.49 58.67,24.33 58.67,24.19 58.56,24.08 57.84,24.08 57.84,24.08 57.81,24.08 57.19,23.45 57.19,22.2 57.88,21.51 57.88,21.36 57.79,21.27 LV22.3
USB8723_TEST: length 1.7
  BOTTOM w0.14: UI3.14 323.13,33.14 RI24.1
USB_DET#_L: length 374.1
  TOP w0.14: v2(283.63,10.4) 283.63,7.9 v1(284.28,7.25) 284.28,7.1 287.26,4.12 CE71.1 RE89.2
  IN2 w0.099: JUSB1.10 14.83,108.21 21.88,108.21 25.03,105.06 25.03,102.54 27.33,100.24 27.33,90.18 25.99,88.83 25.99,77.83 26.77,77.04 26.77,58.49 28.44,56.83 28.44,55.01 28.2,54.77 28.2,51.22 29.45,49.96 29.72,49.96 30,49.68 30.87,49.68 31.4,49.16 31.4,48.52 32.02,47.89 32.02,47.23 32.41,46.85 32.41,46.54 32.14,46.26 32.14,44.68 32.63,44.19 33.13,44.19 33.85,43.47 34.15,43.47 35.15,42.47 35.15,40.45 41.19,34.42 46.11,34.42 46.61,33.91 46.61,33.01 47.32,32.3 51.96,32.3 52.11,32.45 81.6,32.45 81.92,32.77 83.63,32.77 86.63,35.77 96.64,35.77 100.41,39.55 111.33,39.55 116.68,34.2 139.62,34.2 144.89,28.92 153.08,28.92 155.66,26.34 157.99,26.34 159.49,24.84 159.49,20.2 160.32,19.36 173.16,19.36 173.31,19.22 175.66,19.22 176.22,18.65 252.41,18.65 254.91,21.14 256.71,21.14 257.43,20.42 259.61,20.42 260.12,20.93 264.35,20.93 264.75,21.33 278.05,21.33 278.78,22.06 v2(279.43,22.06)
  BOTTOM w0.14: v2(279.43,22.06) 281.22,22.06 282.68,20.59 282.68,18.27 282.3,17.89 282.3,15.16 284,13.47 284,10.77 v2(283.63,10.4)
USB_DET#_R: length 100.7
  TOP w0.14: v1(286.73,16.2) 286.28,15.76 v2(286.28,15.57) 286.64,15.21 RE54.2 CE37.1
  IN3 w0.091: v2(329.39,67.46) 329.39,66.29 330.65,65.03 334.07,65.03 337.12,68.08 JUSB2.10
  IN6 w0.099: v2(329.39,67.46) 329.18,67.25 329.18,60.4 328.02,59.24 328.02,55.33 326.51,53.81 326.51,52.99 324.99,51.48 324.99,45.76 320.85,41.62 320.85,40.27 320.27,39.68 319.46,39.68 318.42,38.64 318.42,35 319.18,34.24 319.18,30.8 315.75,27.37 315.75,20.99 312.07,17.31 312.07,16.76 311.64,16.33 307.49,16.33 307.03,15.86 304.3,15.86 303.72,15.29 301.74,15.29 301.39,14.93 295.09,14.93 294.8,14.64 291.64,14.64 291.02,15.25 291.02,15.92 290.29,16.66 287.51,16.66 286.42,15.57 v2(286.28,15.57)
USB_DET_EC#_L: length 9.4
  TOP w0.14: UE3.B68 294.01,11.38 293.93,11.29 293.51,11.29 293.26,11.03 293.26,9.35 292.89,8.98 v3(292.89,8.34) 292.89,7.99 CE70.1 292.09,7.45 291.06,6.42 291.06,6.21 290.7,5.85 RE89.1 RE90.2
USB_DET_EC#_R: length 16.9
  TOP w0.14: UE3.B63 294.74,13.88 295.23,14.36 v2(295.23,14.5) ; v2(285.56,12.9) 285.56,12.96 286.63,14.03 RE54.1 RE50.2 287.86,14.36 288.6,14.36 CE38.1
  IN6 w0.099: v2(295.23,14.5) 295.15,14.42 291.43,14.42 291.31,14.54 289.45,14.54 288.62,15.36 287.25,15.36 285.56,13.67 v2(285.56,12.9)
USB_ILIM_SEL: length 83.3
  TOP w0.14: v2(276.7,9.86) 277.23,10.4 UE4.3 ; v2(326,43.46) 325.51,42.97 v3(325.02,42.97) 324.74,43.25 RI35.1 324.52,44.22 323.37,44.22 323.03,43.87 DI12.1
  IN6 w0.099: v2(276.7,9.86) 277.14,10.31 281.62,10.31 281.95,9.98 283.87,9.98 284.95,8.9 287.78,8.9 288.6,9.71 288.6,10.1 289.13,10.64 292.44,10.64 293.24,11.43 294.51,11.43 295.3,10.65 303.68,10.65 304.03,10.3 311.22,10.3 314.17,13.24 314.17,16.41 318.12,20.36 318.12,24.71 318.6,25.19 318.6,26.49 322.04,29.93 322.04,32.07 323.66,33.69 323.66,35.13 324.2,35.67 324.2,37.8 326.7,40.29 326.7,43.01 326.25,43.46 v2(326,43.46)
USB_L_CTL: length 6.4
  TOP w0.127: 27.57,90.96 UI1.7
  TOP w0.14: 27.67,91.06 27.57,90.96 ; 27.67,91.06 27.73,91.12 RI4.2 27.81,91.63 27.81,93.24 27.62,93.43 27.62,94.43 v3(27.86,94.67) ; 27.67,91.06 27.67,91.27 27.48,91.46 UI1.8
USB_OC0#: length 316.4
  TOP w0.14: v2(70.47,12.53) 70.47,12.72 v1(70.85,13.1)
  IN1 w0.099: v2(331.06,65.6) 331.06,65.59 332.63,64.02 332.63,57.97 329.04,54.38 329.04,49.64 328.39,48.99 328.39,48.07 322.73,42.42 320.45,42.42 319.44,41.4 318.82,41.4 314.31,36.9 314.31,36.44 312.18,34.31 312.18,32.66 310.32,30.81 310.32,28.37 309.96,28 309.96,25.65 309.36,25.05 308.38,25.05 306.26,22.93 306.26,22.07 304.9,20.71 301.32,20.71 300.76,20.14 291.55,20.14 291.3,19.9 287.64,19.9 287.33,19.58 287.33,18.91 287.04,18.62 285.71,18.62 285.46,18.37 284.15,18.37 283.98,18.2 282.1,18.2 281.16,17.26 278.95,17.26 277.41,15.72 270.54,15.72 267.04,12.22 266.55,12.22 264.19,9.87 262.72,9.87 262.13,9.28 249.31,9.28 248.73,9.85 233.55,9.85 233.32,10.08 218.04,10.08 217.83,9.87 213.12,9.87 211.85,11.14 175.29,11.14 174.59,11.85 154.32,11.85 153.02,13.15 129.85,13.15 128.31,14.69 105.59,14.69 104.99,14.09 102.78,14.09 101.48,12.78 101.24,12.78 100.48,12.02 99.43,12.02 98.75,12.69 96.5,12.69 95.91,13.28 95.91,13.95 95.35,14.51 92.34,14.51 91.24,13.41 85.01,13.41 84.71,13.11 78.55,13.11 78.14,13.51 71.45,13.51 v2(70.47,12.53)
  BOTTOM w0.089: UH2.AD43 78.51,14.32 78.13,13.94 77.05,13.94 76.71,13.6 75.16,13.6 75.06,13.7
  BOTTOM w0.127: 74.96,13.79 72.91,13.79 72.73,13.62 71.35,13.62 RH552.1 70.88,12.94 v2(70.47,12.53)
  BOTTOM w0.14: 74.96,13.79 75.06,13.7 ; v2(331.06,65.6) 330.92,65.46 330.92,64.64 331.05,64.51 UI2.13
USB_OC1#: length 146.7
  TOP w0.127: UI1.13 23.51,91.46 22.75,92.22 v2(22.75,92.46)
  TOP w0.14: v2(22.75,92.46) 22.36,92.86 v3(22.35,92.86)
  IN2 w0.099: v2(22.65,34.79) 23.04,35.18 29.86,35.18 31.04,34 32.96,34 33.24,33.72 38.58,33.72 40.76,31.55 45.89,31.55 48.14,29.3 57.89,29.3 58.45,28.73 58.45,28.25 61.32,25.38 73.53,25.38 75.37,23.54 75.37,21.48 74.02,20.13 74.02,14.96 74.83,14.15 76.08,14.15 v2(76.63,14.7)
  IN5 w0.089: 22.89,47.13 22.89,44.8 23.26,44.43 23.26,43.96 22.46,43.17 22.46,38.42 22.4,38.35 22.4,35.05 v2(22.65,34.79)
  IN5 w0.099: v2(22.75,92.46) 22.75,92.27 24.33,90.69 24.33,85.75 25.32,84.76 25.59,84.76 25.87,84.48 25.87,84 25.65,83.78 25.65,83.77 23.51,81.64 23.51,78.46 21.63,76.58 21.63,67.25 23.39,65.49 23.39,63.39 24.18,62.6 24.18,59.81 23.88,59.51 23.88,58.16 23.3,57.57 23.3,56.32 22.76,55.78 22.76,53.81 21.91,52.96 21.91,51.37 23.08,50.2 23.08,47.32 22.89,47.13
  BOTTOM w0.089: UH2.AD42 78.89,14.45 78.78,14.56 77.98,14.56 77.84,14.42 76.91,14.42 v2(76.63,14.7)
  BOTTOM w0.127: RH553.1 70.73,14.68 71.17,14.68 71.32,14.53 71.33,14.53 71.68,14.17 72.63,14.17 72.82,14.35 74.8,14.35 75.08,14.63 76.26,14.63 76.34,14.7 v2(76.63,14.7)
USB_OC2#: length 6.4
  TOP w0.089: v2(80.7,13.74) 80.7,14.24 79.4,15.54 v3(77.89,15.54) 76.19,15.54 RH554.1
  BOTTOM w0.089: UH2.AD39 v2(80.7,13.74)
USB_OC3#: length 6.3
  BOTTOM w0.089: UH2.AC44 77.99,14.84 77.85,14.7 77.15,14.7 76.73,15.12 76.26,15.12
  BOTTOM w0.127: RH555.1 73.39,14.77 74.03,14.77 v3(74.1,14.7) 74.16,14.64 74.66,14.64 74.88,14.86 ; 75.05,15.02 76.16,15.02 76.26,15.12
  BOTTOM w0.14: 74.88,14.86 75.05,15.02
USB_OC4#: length 7
  BOTTOM w0.089: 75.06,16.84 76.43,16.84 76.48,16.79 77.93,16.79 77.98,16.83 78.4,16.83 UH2.Y43
  BOTTOM w0.127: RP8.3 72.67,17.86 73.69,16.84 v3(74.68,16.84) 75.06,16.84
USB_OC5#: length 9.9
  TOP w0.089: v1(76.11,16.8) 76.65,16.26 v2(76.65,16.25)
  IN6 w0.089: v2(76.65,16.25) 76.65,16.26 77.25,16.87 79.64,16.87 v2(79.92,17.15)
  BOTTOM w0.089: 75.06,16.48 76.42,16.48 v2(76.65,16.25) ; v2(79.92,17.15) 79.64,16.87 UH2.Y41
  BOTTOM w0.127: 75.03,16.48 73.48,16.48 72.61,17.36 RP8.4
  BOTTOM w0.14: 75.03,16.48 75.06,16.48
USB_OC6#: length 6.7
  BOTTOM w0.089: UH2.W44 78.2,17.02 77.9,17.02 77.85,16.98 76.63,16.98 76.35,17.26 75.1,17.26
  BOTTOM w0.127: RP8.2 72.78,18.36 v3(73.55,17.59) 73.88,17.26 75.1,17.26
USB_OC7#: length 7.3
  BOTTOM w0.089: UH2.W43 78.67,17.11 78.43,17.34 77.96,17.34 77.85,17.45 77.28,17.45 77.06,17.66 77.04,17.66 77,17.71 v3(75.69,17.71) 75.06,17.71
  BOTTOM w0.127: 75.06,17.71 74.09,17.71 72.94,18.86 RP8.1
USB_PWR_EN: length 459.2
  TOP w0.127: v2(108.33,5.34) 108.4,5.28 RH544.1 ; UI4.1 26.15,83.1 25.97,82.93 25.07,82.93 24.78,83.22 v3(24.36,83.22)
  TOP w0.14: v2(321.69,49.41) 321.31,49.79 UI5.1 ; v3(24.36,83.22) 24.05,82.91 24.05,80.24 24.49,79.81 24.49,76.74 23.4,75.65 22.49,75.65 19.61,72.77 v2(19.61,69.7)
  IN2 w0.099: v2(59.54,7.81) 59.54,11.07 60.24,11.77 60.24,18.43 59.57,19.1 59.57,20.12 59.26,20.43 58.87,20.43 54.3,25 52.72,25 51.89,25.83 50.52,25.83 50.35,25.66 47.32,25.66 44.95,28.02 42.7,28.02 42,28.73 39.1,28.73 37.92,29.91 34.14,29.91 33.35,29.12 29.32,29.12 27.84,27.63 27.84,26.97 25.94,25.08 25.44,25.08 23.86,23.5 22.69,23.5 21.92,22.73 v2(20.67,22.73)
  IN3 w0.091: v2(321.69,49.41) 324.61,49.41 325.03,48.99 328.33,48.99 v2(328.8,48.52)
  IN5 w0.089: v2(90.33,2.73) 90.2,2.87 90.2,3.28 89.35,4.13 87.07,4.13 86.56,4.64 76.99,4.64 76.3,5.33 75.97,5.33 75.68,5.62 75.06,5.62
  IN5 w0.099: v2(59.54,7.81) 59.78,7.57 61.92,7.57 62.61,6.87 64.96,6.87 66.2,5.62 75.06,5.62 ; v2(20.67,22.73) 20.67,24.04 20.38,24.33 20.38,25.15 20.58,25.35 20.58,25.92 20.13,26.36 20.13,27.56 20.09,27.6 20.09,39.05 17.85,41.28 17.85,60.39 19.61,62.15 v2(19.61,69.7)
  IN6 w0.089: 101.98,6.38 101.89,6.38 101.83,6.32 101.83,6.32 99.89,6.32 99.05,5.48 99.05,4.52 98.55,4.02 97.47,4.02 97.17,4.32 95.58,4.32 95.47,4.43 92.93,4.43 92.15,3.65 91.61,3.65 90.69,2.74 90.34,2.74 v2(90.33,2.73)
  IN6 w0.099: v2(328.8,48.52) 328.41,48.13 328.41,40.87 325.2,37.66 325.2,35.49 324.46,34.75 324.46,26.92 319.88,22.34 319.88,10.22 316.14,6.48 306.89,6.48 306.36,5.95 306.36,5.62 305.78,5.04 303.1,5.04 302.97,5.17 301.67,5.17 301.01,4.51 295.23,4.51 295.06,4.68 270.51,4.68 269.75,3.92 269.11,3.92 267.03,6 263.4,6 263.06,5.66 256.73,5.66 256.53,5.86 246.44,5.86 245.38,4.8 243.37,4.8 242.49,3.92 215.3,3.92 210.68,8.53 178.93,8.53 177.75,7.35 172.35,7.35 170.75,5.75 162.87,5.75 162.87,5.76 158.76,5.76 157.8,4.79 150.41,4.79 149.8,5.41 148.12,5.41 144.66,8.87 135.91,8.87 134.64,7.61 134.48,7.61 134.48,7.61 133.17,7.61 132.75,7.19 130.11,7.19 129.47,7.83 126.82,7.83 126.06,8.59 118.8,8.59 118.04,7.83 117.49,7.83 115.65,5.98 109.55,5.98 108.91,5.34 v2(108.33,5.34) 107.69,5.98 104.97,5.98 104.57,6.38 101.98,6.38
  BOTTOM w0.089: v2(90.33,2.73) 90.34,2.73 90.34,2.74 90.21,2.87 90.21,3.43 90.35,3.57 90.35,4.2 90.16,4.39 90.16,4.76 90.31,4.91 UH2.BC19
USB_PWR_EN_L: length 7.1
  TOP w0.127: UI1.5 27.51,89.96 27.83,89.65 27.83,88.55 27.9,88.48 27.9,87.14 RI26.1
  TOP w0.14: v3(28.53,84.72) 27.75,84.72 27.45,85.02 UI4.4 27.45,86.66 RI26.1
USB_PWR_EN_R: length 16.5
  TOP w0.14: v1(324.64,52.98) 324.64,53.31 v2(324.42,53.53) RI27.1 322.61,53.11 UI5.4 322.61,51.87 322.9,51.58 RI28.2
  BOTTOM w0.14: v2(324.42,53.53) 327.69,56.79 327.69,62.87 327.83,63.01 UI2.5
USB_PWR_SHR_EN_L#: length 354.8
  TOP w0.127: UI1.6 27.92,90.46 v2(27.93,90.48) 28.32,90.09 RI5.2
  TOP w0.14: UE3.A55 292.9,16.13 v2(292.81,16.04) ; v2(289.61,22.74) 289.27,22.74 v1(288.86,22.34)
  IN2 w0.089: 33.17,47.13 33.4,46.89
  IN2 w0.099: v2(289.61,22.74) 289.42,22.55 268.6,22.55 267.58,21.53 264.67,21.53 264.27,21.14 260.04,21.14 259.52,20.62 257.52,20.62 256.79,21.34 254.82,21.34 252.37,18.89 176.27,18.89 175.74,19.42 173.39,19.42 173.24,19.56 160.41,19.56 159.69,20.28 159.69,24.93 158.07,26.54 155.74,26.54 153.17,29.12 144.98,29.12 139.7,34.4 116.76,34.4 111.41,39.75 98.47,39.75 95.43,36.71 87.24,36.71 84.04,33.51 81.69,33.51 80.84,32.65 52.03,32.65 51.87,32.5 47.4,32.5 46.81,33.09 46.81,34 46.19,34.62 41.27,34.62 35.35,40.54 35.35,42.56 33.72,44.18 33.72,46.57 33.4,46.89 ; 33.17,47.13 32.97,47.33 32.97,48.72 31.8,49.88 30.08,49.88 29.8,50.16 29.53,50.16 28.4,51.3 28.4,54.68 28.64,54.92 28.64,56.91 26.98,58.57 26.98,77.12 26.19,77.91 26.19,88.73 v2(27.93,90.48)
  BOTTOM w0.14: v2(292.81,16.04) 294.78,14.07 296.15,14.07 296.61,14.52 296.61,18.25 296.27,18.59 295.89,18.59 295.5,18.98 295.5,19.41 295.77,19.68 295.77,21.82 295.78,21.84 295.78,22.73 295.11,23.4 291.34,23.4 290.37,22.44 289.92,22.44 v2(289.61,22.74)
USB_PWR_SHR_EN_R#: length 84.6
  TOP w0.14: v2(325.63,56.87) 325.51,56.98 v1(325.51,57.65) ; v2(276.63,18.13) 277.23,17.53 UE4.19
  IN6 w0.099: v2(325.63,56.87) 325.63,55.87 323.09,53.34 323.09,53.06 320.89,50.85 320.89,49.16 318.24,46.52 318.24,44.93 312.03,38.72 312.03,37.14 308.8,33.91 308.8,28.9 307.73,27.83 307.73,25.83 305.93,24.03 298.52,24.03 297.85,23.36 295.27,23.36 292.5,20.6 290.6,20.6 289.87,21.33 286.36,21.33 285.88,21.81 282.73,21.81 280.58,19.66 280.23,19.66 279.75,19.19 277.51,19.19 276.63,18.31 v2(276.63,18.13)
  BOTTOM w0.14: v2(325.63,56.87) RI10.2 326.82,58.1 327.45,58.72 327.45,63.03 327.93,63.51 UI2.6
USB_PWR_SHR_VBUS_EN_L: length 317.9
  TOP w0.14: v2(277.39,20.87) 278.53,19.73 UE4.17 ; v2(25.5,82.14) 26.4,82.14 RI8.2 26.8,82.53 UI4.2
  IN2 w0.089: 33.66,43.38 33.02,44.01 32.54,44.01
  IN2 w0.099: v2(25.5,82.14) 25.5,78.03 26.57,76.96 26.57,58.41 28.23,56.75 28.23,55.1 27.99,54.86 27.99,51.1 28.13,50.96 28.13,48.36 28.32,48.16 31.1,48.16 31.65,47.61 31.65,44.91 32.54,44.01 ; v2(277.39,20.87) 277.13,21.13 264.83,21.13 264.43,20.73 260.2,20.73 259.69,20.22 257.35,20.22 256.63,20.94 254.99,20.94 252.49,18.44 176.15,18.44 175.71,18.88 173.36,18.88 173.08,19.16 160.24,19.16 159.28,20.12 159.28,24.67 157.81,26.14 155.55,26.14 154.65,27.04 146.48,27.04 139.53,33.99 116.6,33.99 111.26,39.33 100.48,39.33 96.72,35.57 87.73,35.57 84.73,32.57 82,32.57 81.68,32.25 52.19,32.25 52.04,32.1 50.54,32.1 49.77,31.34 47.99,31.34 46.41,32.92 46.41,33.83 46.02,34.21 41.1,34.21 34.95,40.37 34.95,42.39 34.07,43.27 33.77,43.27 33.66,43.38
USB_PWR_SHR_VBUS_EN_R: length 76.3
  TOP w0.14: v2(277.22,18.18) 277.88,17.52 UE4.18 ; RI13.2 323.79,49.4 RI28.1 323.23,50.67 322.84,51.06 322.26,51.06 321.96,50.76 UI5.2 321.96,49.84 322.2,49.6 322.2,49.2 321.95,48.94 321.34,48.94 v1(321.21,48.81) 320.68,48.28 v2(320.68,48.15)
  IN6 w0.099: v2(320.68,48.15) 320.34,48.15 318.44,46.26 318.44,44.85 312.23,38.64 312.23,37.06 309.46,34.29 v2(309.46,33.11) 309,32.64 309,28.81 307.93,27.75 307.93,25.75 306.02,23.83 298.61,23.83 297.93,23.16 295.35,23.16 292.59,20.4 290.52,20.4 289.79,21.13 286.27,21.13 285.79,21.61 282.81,21.61 280.67,19.46 280.31,19.46 279.84,18.99 278.08,18.99 277.28,18.18 v2(277.22,18.18)
  BOTTOM w0.14: v2(309.46,33.11) 309.69,32.88 312.97,32.88 313.56,32.28 DI11.1
USB_R_CTL: length 5.8
  BOTTOM w0.14: 327.6,64.01 327.6,64.4 327.71,64.51 UI2.8 ; 327.6,64.01 UI2.7 ; 327.6,64.01 327.6,63.52 327.2,63.13 327.2,62.37 v3(326.66,61.82) RI9.2
USB_STATUS#_L: length 399.6
  TOP w0.14: UI1.9 26.14,91.9 26.25,91.79 26.53,91.79 27.2,92.46 27.2,95.98 v1(27.64,96.42) 28,96.78 v2(28.39,96.78) ; RI32.2 323.91,48.09 324.79,48.09 326.26,46.62 v2(326.26,45.37)
  IN2 w0.099: v2(45.91,33.75) 45.91,33.13 47.9,31.14 49.86,31.14 50.62,31.9 52.86,31.9 53.89,30.88 70.17,30.88 71.13,29.92 73.53,29.92 74.73,31.12 78.3,31.12 79.19,32.01 84.46,32.01 87.69,35.25 96.68,35.25 99.86,38.43 111.29,38.43 116.34,33.39 139.28,33.39 145.96,26.71 154.42,26.71 155.62,25.51 157.19,25.51 157.97,24.73 157.97,19.89 158.97,18.89 173.06,18.89 173.31,18.64 175.66,18.64 176.09,18.21 254.24,18.21 254.93,18.89 257.44,18.89 258.03,19.48 262.39,19.48 263.15,20.24 264.79,20.24 265.33,20.78 274.93,20.78 275.28,20.43 278.07,20.43 278.85,21.22 279.17,21.22 280.25,22.3 290.13,22.3 290.61,22.78 290.61,23.36 293.09,25.84 293.86,25.84 296.28,28.26 300.17,28.26 300.79,27.64 302.18,27.64 303,28.46 314.18,28.46 318.52,32.8 318.83,32.8 322.24,36.2 322.24,37 325.35,40.12 325.35,44.46 326.26,45.37 v2(326.26,45.37)
  IN5 w0.099: v2(45.91,33.75) 44.88,34.79 40.38,34.79 38.98,36.18 38.98,37.69 35.87,40.79 35.87,43.05 34.31,44.61 34.31,45.86 33.72,46.45 33.72,47.05 33.34,47.43 33.34,48.38 33.34,48.54 33.17,48.71 33.17,48.86 32.63,49.4 32.63,49.74 29.72,52.65 29.72,55.72 27.13,58.32 27.13,66.48 26.82,66.79 26.82,75.13 26.75,75.2 26.75,75.2 25.83,76.12 25.83,79.61 26.87,80.65 26.87,81.78 27.57,82.48 27.57,82.93 28.64,83.99 28.64,96.53 v2(28.39,96.78)
USB_STATUS#_R: length 23
  TOP w0.14: RI33.2 v2(321.77,48.28) 321.12,47.63 v3(321.12,47.01)
  BOTTOM w0.14: v2(321.77,48.28) 323.05,49.56 323.05,53.11 324.98,55.04 324.98,60.99 326.96,62.98 326.96,63.23 327.23,63.49 327.23,64.44 327.65,64.86 328.92,64.86 329.07,65.01 UI2.9
USBC_MCP23017_SMBCLK: length 32.9
  TOP w0.14: RE21.1 296.37,4.12 RE109.2 ; RE21.1 295.4,2.87 v1(295.4,2.86) ; RE21.1 295.9,4.63 295.9,5.35 295.52,5.73 v2(295.52,5.77) ; v2(296.52,12.14) 296.67,11.98 296.67,11.25 296.52,11.1 UE3.B4 ; UE4.8 281.28,12.16 v2(283.01,10.42)
  IN3 w0.091: v2(296.52,12.14) 296.66,12 296.66,11.1 295.87,10.31 295.87,6.63 295.52,6.27 v2(295.52,5.77)
  BOTTOM w0.14: v2(283.01,10.42) 283.01,10.15 285.03,8.13 293.69,8.13 294.23,8.66 294.72,8.66 294.97,8.91 294.97,9.34 296.69,11.05 296.69,11.97 v2(296.52,12.14)
USBC_MCP23017_SMBDAT: length 28.6
  TOP w0.14: UE4.9 281.39,12.81 v2(282.65,11.55) ; RE108.2 296.47,6.99 296.18,6.99 296.04,7.13 RE20.1 295.76,7.17 295.68,7.17 295.59,7.27 295.59,7.83 295.4,8.01 295.4,8.14 295.53,8.26 295.67,8.26 295.91,8.02 296.03,8.02 296.1,8.1 296.1,8.38 295.89,8.59 295.89,8.68 296.08,8.87 296.18,8.87 v3(296.35,8.7) 296.53,8.52 v2(296.53,8.21) 296.53,7.98 296.6,7.9 296.9,7.9 296.97,7.97 296.97,8.59 296.65,8.91 296.65,9.15 296.57,9.23 296.17,9.23 296.1,9.3 296.1,9.44 296.27,9.62 UE3.A3
  BOTTOM w0.14: v2(296.53,8.21) 295.85,7.53 289.6,7.53 289.49,7.65 284.79,7.65 282.31,10.13 282.31,11.21 v2(282.65,11.55)
USBP1_D+: length 3.8
  BOTTOM w0.152: LI2.4 327.59,66.79 327.68,66.7 327.68,66.38 327.94,66.11 329.44,66.11 329.65,65.9 329.65,65.77 329.57,65.68 UI2.10
USBP1_D-: length 3.8
  BOTTOM w0.152: UI2.11 330.07,65.72 329.99,65.81 329.99,66.04 329.58,66.44 328.08,66.44 328.01,66.51 328.01,66.7 328.09,66.79 LI2.1
USBP1_R_D+: length 15.6
  IN5 w0.107: JUSB2.3 335.59,73.95 334.76,73.12 331.65,73.12 330.47,71.95 330.47,71.32 v2(330.28,71.13)
  BOTTOM w0.152: LI2.3 327.59,69.2 327.68,69.29 327.68,69.58 328.01,69.91 328.65,69.91 329.45,69.11 329.73,69.11 330.4,69.78 330.4,70.02 330.16,70.27 DI10.2 329.62,71 329.74,71.13 v2(330.28,71.13)
USBP1_R_D-: length 15.6
  IN5 w0.107: JUSB2.2 335.27,71.95 334.85,72.37 334.85,72.74 334.67,72.92 331.73,72.92 330.67,71.86 330.67,71.32 v2(330.86,71.13)
  BOTTOM w0.152: LI2.2 328.09,69.2 328.01,69.29 328.01,69.44 328.15,69.58 328.51,69.58 329.31,68.78 329.87,68.78 330.73,69.64 330.73,70.07 330.93,70.27 DI10.3 331.55,71 331.42,71.13 v2(330.86,71.13)
USBP2_D+: length 8.8
  TOP w0.152: v2(26.51,93.46) 25.64,92.59 UI1.10 ; v2(23.33,97.39) 23.29,97.36 22.76,97.36 22.6,97.2 22.51,97.2 22.43,97.28 LI5.4
  IN3 w0.099: v2(26.51,93.46) 26.35,93.61 26.35,93.95 24.83,95.47 24.83,96.61 24.05,97.38 23.34,97.38 v2(23.33,97.39)
USBP2_D-: length 8.8
  TOP w0.152: v2(25.88,93.46) 25.88,93.3 25.14,92.56 UI1.11 ; LI5.1 22.43,96.78 22.51,96.87 22.74,96.87 22.9,97.02 23.1,97.02 v2(23.33,96.8)
  IN3 w0.099: v2(23.33,96.8) 23.33,96.82 23.71,97.19 23.97,97.19 24.64,96.53 24.64,95.4 26.16,93.87 26.16,93.68 25.93,93.46 v2(25.88,93.46)
USBP2_R_D+: length 23.8
  TOP w0.152: LI5.3 20.01,97.28 19.93,97.2 18.67,97.2 18.24,97.62 v4(18.24,98.74) 18.24,98.95 18.51,99.22 18.89,99.22 19.63,98.48 20.8,98.48 21.62,99.3 21.62,99.63 21.9,99.91 22.15,99.91 22.38,99.68 DI8.2 23.1,99.46 23.11,99.45 23.5,99.45 v2(23.75,99.2)
  IN2 w0.107: JUSB1.3 14.68,101.31 14.86,101.14 15.15,101.14 15.3,101.29 15.3,101.54 15.8,102.04 16.81,102.04 19.42,99.42 23.52,99.42 v2(23.75,99.2)
USBP2_R_D-: length 23.8
  TOP w0.152: LI5.2 20.01,96.78 19.93,96.87 v4(18.98,96.87) 18.53,96.87 17.91,97.49 17.91,99.09 18.38,99.55 19.02,99.55 19.76,98.81 20.67,98.81 21.29,99.43 21.29,99.76 21.76,100.24 21.95,100.24 DI8.3 22.38,100.64 23.24,99.78 23.7,99.78 v2(23.75,99.83)
  IN2 w0.107: v2(23.75,99.83) 23.55,99.63 19.51,99.63 16.89,102.24 15.88,102.24 14.68,103.44 JUSB1.2
VCORE_B+: length 10
  BOTTOM w0.508: PR1102.1 118.76,112.42 118.87,112.42 120,113.55 123.06,113.55 123.9,112.71 127.43,112.71
  vias: v1(137.97,119.78) v2(137.92,119.13) v2(137.92,118.5) v2(138.53,119.08) v2(138.53,118.5) v2(138.56,117.86) v2(139.73,109.91) v2(139.73,109.31) v2(139.83,116.57) v2(139.8,115.93) v2(139.8,115.32) v2(139.75,110.52) v2(140.44,110.5) v2(140.44,109.91) v2(140.44,109.31) v2(140.49,116.57) v2(140.51,115.91) v2(140.49,115.32) v2(142.11,106.31) v2(142.16,105.72) v2(156.39,116.72) v2(156.43,115.71) v2(156.77,116.24) v2(157.2,116.72) v2(157.18,115.73) v2(157.53,116.22) v2(157.86,116.72) v2(157.96,115.76) v2(158.32,116.26) v2(158.66,115.72) v2(158.75,116.71) v2(159.64,118.13) v2(160.27,118.13) v2(160.91,118.13) v2(161.54,118.13) v2(162.18,118.13)
VGA_CLK_REQ#: length 172.3
  TOP w0.127: RH551.2 70.88,11.7 v2(70.46,11.28)
  TOP w0.14: v2(198.22,57.97) 197.66,57.41 QV39.1
  IN5 w0.089: 101.98,12.4 101.07,11.48 99.15,11.48 98.78,11.85 92.14,11.85 91.49,11.2 91.49,10.16 91.47,10.14 90.78,9.45 89.1,9.45 88.79,9.15 87.97,9.15 87.76,9.36 85.56,9.36 85.08,9.83 84.39,9.83 v2(83.92,9.37) 83.6,9.04 81.54,9.04 81.2,9.38 81.2,9.49 80.87,9.83 79.24,9.83 79.15,9.91 75.06,9.91
  IN5 w0.099: 101.98,12.4 102.05,12.47 105.78,12.47 105.99,12.26 107.67,12.26 108.5,11.42 113.74,11.42 114.37,12.06 175.2,12.06 182.34,19.19 v2(182.34,19.72) ; 75.06,9.91 72,9.91 71.23,9.15 69.77,9.15 69.09,9.84 69.09,10.17 70.19,11.28 v2(70.46,11.28)
  IN6 w0.099: v2(182.34,19.72) 182.33,19.72 182.33,20.32 180.5,22.16 180.5,23.81 182.04,25.36 182.04,30.9 194.74,43.6 194.74,54.14 195.23,54.62 195.23,54.97 v2(198.22,57.97)
  BOTTOM w0.089: UH2.AR31 84.18,9.14 v2(83.92,9.37)
VGA_ID: length 7.2
  TOP w0.14: RE112.1 299.4,5.39 299.77,5.76 v2(300.17,5.76) ; v2(299.67,9.17) 299.77,9.27 UE3.A10
  IN3 w0.091: v2(300.17,5.76) 300.98,5.76 301.41,6.19 301.41,7.43 v2(299.67,9.17)
VR_ON: length 208.8
  TOP w0.14: RZ60.2 171.92,5.84 172.11,5.65 172.11,5.22 172.36,4.97 172.78,4.97 173.08,5.27 174.07,5.27 174.43,5.62 UZ12.4 174.66,6.39 175.18,5.86 RZ71.1 v1(175.53,12.59) 175.53,13.23 178.09,15.79 178.09,19.52 177.74,19.87 177.74,21.18 v2(177.03,21.88)
  TOP w0.254: PR1118.1 v2(111.99,112.72)
  IN4 w0.089: 134.62,76.74 136.83,76.74 137.67,77.58 137.67,79.96 137.2,80.43 137.2,81.3
  IN4 w0.091: 134.62,76.74 133.26,76.74 132.21,75.69 132.21,71 132.91,70.3 132.91,68.84 132.02,67.95 132.02,66.4 132.59,65.82 132.59,57.48 125.8,50.69 125.8,46.88 113.62,34.69 113.62,26.35 113.96,26.01 172.91,26.01 v2(177.03,21.88) ; 137.2,81.3 135.78,82.73 135.78,85.23 134.91,86.1 134.91,94.49 135.6,95.19 135.6,99.23 133.34,101.49 129.63,101.49 128.84,102.28 124.49,102.28 123.24,103.53 123.24,108.3 120.42,111.12 113.62,111.12 112.02,112.72 v2(111.99,112.72)
VR_SVID_ALERT#: length 28.1
  TOP w0.14: PR1132.1 115.76,112.66 v2(115.83,112.72) ; v2(134.37,104.38) 133.95,104.8 RH153.1 RH152.2 132.42,105.18 v1(132.42,106.04)
  IN4 w0.091: v2(134.37,104.38) 134.37,105.1 129.1,110.37 126.68,110.37 122.55,114.51 117.24,114.51 116.61,113.88 116.61,113.23 116.1,112.72 v2(115.83,112.72)
VR_SVID_ALERT#_C: length 2.6
  TOP w0.14: PR1132.2 116.31,110.64 v2(116.31,110.54) 116.31,110.21 116.6,109.92 PU1100.44
