# Allegro board LA-C361P R10-0731.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
RZ41  100K_0402_5%  [R_0402]  281.32 20.07 180 top
RZ43  100K_0402_5%  [R_0402]  314.14 34.16 90 bottom
RZ46  100K_0402_5%  [R_0402]  57.28 7.9 270 top
RZ48  0_0603_5%  [R0603_0OHM]  182.35 82.56 0 bottom
RZ50  100K_0402_5%  [R_0402]  109.92 65.43 270 top
RZ52  19.6K_0402_1%  [R_0402]  183.16 14.35 90 top
RZ53  0_0603_5%  [R0603_0OHM]  179.77 15.63 270 top
RZ54  30.1K_0402_1%  [R_0402]  182.25 14.35 90 top
RZ58  0_0402_5%  [R0402_0OHM]  176.96 5.58 90 top
RZ59  0_0402_5%  [R_0402]  177.85 3.18 0 top
RZ60  0_0402_5%  [R0402_0OHM]  171.49 4.92 90 top
RZ61  0_0402_5%  [R_0402]  174.54 3.18 180 top
RZ66  0_0603_5%  [R0603_0OHM]  182.06 79.83 180 top
RZ67  0_0603_5%  [R0603_0OHM]  130.09 66.93 270 top
RZ69  0_0805_5%  [R0805_0OHM]  228.63 59.83 180 top
RZ70  0_0805_5%  [R0805_0OHM]  107.67 15.25 0 top
RZ71  100K_0402_5%  [R_0402]  175.53 5.86 270 top
RZ72  0_0402_5%  [R_0402]  134.15 70.06 180 top
RZ74  100K_0402_5%  [R_0402]  243.51 1.55 0 top
RZ75  0_0402_5%  [R_0402]  242.65 1.55 180 top
RZ76  0_0402_5%  [R0402_0OHM]  239.95 1.55 0 top
RZ80  100K_0402_5%  [R_0402]  128.27 67.95 0 top
RZ81  0_0402_5%  [R0402_0OHM]  120.3 57.6 0 top
RZ82  0_0402_5%  [R_0402]  122.94 59.62 90 top
RZ84  100K_0402_5%  [R_0402]  119.59 60.95 270 top
RZ85  100K_0402_5%  [R_0402]  180.54 3.18 180 top
RZ86  100K_0402_5%  [R_0402]  171.5 3.44 0 top
RZ87  100K_0402_5%  [R_0402]  120.34 66.29 0 top
RZ88  100K_0402_5%  [R_0402]  108.95 51.95 0 top
RZ89  0_0402_5%  [R_0402]  170.12 9.39 90 bottom
RZ90  0_0402_5%  [R0402_0OHM]  133.08 65.41 0 top
RZ91  0_0402_5%  [R0402_0OHM]  105.4 54.43 0 top
SW1  SKRBAAE010_4P  [SW_SKRBAAE010_4P]  336.54 114.25 90 top
SW2  NTC311-EA1T-A160T_4P  [SW_NTC311-EA1T-A160T_4P]  348.63 110.32 90 top
SW4  SSAL120100_3P  [SW_SSAL120100_3P]  114 4.26 0 top
T2  PAD~D  [TPC12]  74.23 18.88 180 bottom
T4  PAD~D  [TPC12]  75.36 22.41 180 bottom
T8  PAD~D  [TPC12]  80.61 4.05 0 top
T11  PAD~D  [TPC12]  196.05 63.48 180 bottom
T12  PAD~D  [TPC12]  194.79 65.17 180 bottom
T13  PAD~D  [TPC12]  196.11 65.99 180 bottom
T17  PAD~D  [TPC12]  90.74 1.63 180 bottom
T18  PAD~D  [TPC12]  84.41 6.83 0 top
T20  PAD~D  [TPC12]  92.58 7.98 0 top
T39  PAD~D  [TPC12]  177.32 58.3 0 top
T40  PAD~D  [TPC12]  175.1 58.59 0 top
T41  PAD~D  [TPC12]  175.65 60.85 0 top
T42  PAD~D  [TPC12]  176.39 59.5 0 top
T43  PAD~D  [TPC12]  137.34 59 0 top
T44  PAD~D  [TPC12]  137.42 60.46 0 top
T45  PAD~D  [TPC12]  138.6 84.29 0 top
T46  PAD~D  [TPC12]  172.89 74.87 0 top
T47  PAD~D  [TPC12]  174.33 76.77 0 top
T48  PAD~D  [TPC12]  138.74 82.69 0 top
T49  PAD~D  [TPC12]  140.81 85.35 0 top
T50  PAD~D  [TPC12]  170.07 80.7 0 top
T51  PAD~D  [TPC12]  168.13 68.21 0 top
T52  PAD~D  [TPC12]  160.91 81 0 top
T53  PAD~D  [TPC12]  162.61 68.21 0 top
T57  PAD~D  [TPC12]  173.97 81.67 0 top
T58  PAD~D  [TPC12]  180.57 81.1 180 bottom
T59  PAD~D  [TPC12]  177.99 80.44 0 top
T60  PAD~D  [TPC12]  176.77 81.35 0 top
T61  PAD~D  [TPC12]  174.21 59.94 0 top
T62  PAD~D  [TPC12]  173.29 61.05 0 top
T63  PAD~D  [TPC12]  134.29 84.85 180 bottom
T64  PAD~D  [TPC12]  138.81 81.05 0 top
T65  PAD~D  [TPC12]  143.28 81.07 0 top
T66  PAD~D  [TPC12]  140.12 82.71 0 top
T67  PAD~D  [TPC12]  140.5 83.97 0 top
T68  PAD~D  [TPC12]  141.82 69.26 0 top
T69  PAD~D  [TPC12]  143.41 69.4 0 top
T70  PAD~D  [TPC12]  140.76 80.34 0 top
T71  PAD~D  [TPC12]  143.21 78.9 0 top
T73  PAD~D  [TPC12]  142.5 70.42 0 top
T74  PAD~D  [TPC12]  140.49 70.49 0 top
T75  PAD~D  [TPC12]  141.4 76.4 0 top
T76  PAD~D  [TPC12]  143.05 76.53 0 top
T77  PAD~D  [TPC12]  141.38 74.13 0 top
T78  PAD~D  [TPC12]  143.17 74.35 0 top
T79  PAD~D  [TPC12]  138.09 70.14 0 top
T80  PAD~D  [TPC12]  134.92 70.94 180 bottom
T81  PAD~D  [TPC12]  142.29 84.53 0 top
T82  PAD~D  [TPC12]  142.51 83.16 0 top
T83  PAD~D  [TPC12]  178 68.91 0 top
T84  PAD~D  [TPC12]  156.38 61.95 0 top
T85  PAD~D  [TPC12]  177.55 56.8 180 bottom
T86  PAD~D  [TPC12]  180.54 91.3 180 bottom
T87  PAD~D  [TPC12]  135.05 57.22 0 top
T88  PAD~D  [TPC12]  136.32 57.99 0 top
T89  PAD~D  [TPC12]  176.39 56.16 180 bottom
T90  PAD~D  [TPC12]  179.64 90.12 180 bottom
T91  PAD~D  [TPC12]  75.41 20.75 180 bottom
T92  PAD~D  [TPC12]  74.18 20.28 180 bottom
T94  PAD~D  [TPC12]  75.43 19.38 180 bottom
T104  PAD~D  [TPC12]  82.6 14.52 0 top
T105  PAD~D  [TPC12]  84.81 13.23 0 top
T106  PAD~D  [TPC12]  81.19 14.52 0 top
T107  PAD~D  [TPC12]  75.38 15.34 180 bottom
T108  PAD~D  [TPC12]  73.65 15.99 180 bottom
T120  PAD~D  [TPC12]  75.55 11.39 180 bottom
T121  PAD~D  [TPC12]  74.8 10.35 180 bottom
T122  PAD~D  [TPC12]  73.75 11.11 180 bottom
T123  PAD~D  [TPC12]  83.44 11.82 0 top
T124  PAD~D  [TPC12]  75.59 12.73 180 bottom
T127  PAD~D  [TPC12]  74.02 12.52 180 bottom
T174  PAD~D  [TPC12]  194.39 63.45 180 bottom
T176  PAD~D  [TPC12]  225.18 68.49 0 top
T182  PAD~D  [TPC12]  83.44 13.22 0 top
T185  PAD~D  [TPC12]  11.94 43.82 180 bottom
T187  PAD~D  [TPC12]  4.67 36.5 180 bottom
T191  PAD~D  [TPC12]  8.51 44.33 180 bottom
T192  PAD~D  [TPC12]  8.64 42.81 180 bottom
T193  PAD~D  [TPC12]  13.08 33.82 0 top
T194  PAD~D  [TPC12]  9.15 37.22 0 top
T195  PAD~D  [TPC12]  23.57 46.69 180 bottom
T196  PAD~D  [TPC12]  38.67 36.84 0 top
T197  PAD~D  [TPC12]  39.94 38.74 0 top
T198  PAD~D  [TPC12]  39.43 40.01 0 top
T199  PAD~D  [TPC12]  37.02 37.98 0 top
T200  PAD~D  [TPC12]  4.38 37.6 180 bottom
UC1  -  [74AUP1G07GW_TSSOP5]  124.85 53.21 90 top
UD2  S IC TC7SZ14FU SSOP 5P  [NL17SZ14DFT2G_SOT353-5]  258.13 6.25 270 bottom
UE1  -  [NPCT650JAAYX_QFN32_5X5]  156.73 5.43 180 top
UE2  -  [TCS20DLR_SOT23F-3]  347.44 119.85 90 top
UE3  MEC5085-LZY-HST01_DQFN132_11X11  [MEC5085-LZY_DQFN132_11X11]  295.27 9.93 0 top
UE4  -  [MCP23017T-E-ML_QFN28_6X6]  275.93 11.13 0 top
UE6  -  [APE8937GN2_DFN8_2X2]  222.01 7.54 0 top
UF1  LNG3DMTR_LGA16_3X3~D  [LNG3DMTR_LGA16_3X3]  231.03 56.4 180 top
UH1  SKL-H_BGA1440  [SKL-H_BGA_1440P-T]  178.08 59.74 270 bottom
UH2  SKY-H-PCH_BGA837  [SKY-S-PCH_BGA_837P-T]  99.33 25.75 0 bottom
UH7  -  [MC74VHC1G08DFT2G_SC70-5]  61.47 8.5 90 top
UH8  -  [W25Q128FVSIQ_SO8]  68.65 8.9 270 bottom
UH14  -  [MC74VHC1G08DFT2G_SC70-5]  111.89 6.47 90 top
UI1  -  [TPS2546RTER_QFN16_3X3]  24.64 89.16 0 top
UI2  -  [TPS2546RTER_QFN16_3X3]  330.57 62.21 180 bottom
UI3  -  [PS8713BTQFN24GTR2_TQFN24_4X4]  317.61 31.14 90 bottom
UI4  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  26.8 84.46 0 top
UI5  MC74VHC1G32DFT2G_SC70-5~D  [MC74VHC1G32DFT2G_SC70-5]  321.96 51.26 0 top
UN3  -  [APE8937GN2_DFN8_2X2]  338.03 100.54 90 top
UR1  -  [RTS5242-GR_QFN32_4X4]  335.28 34.03 90 bottom
UT1  ALPINE-RIDGE_BGA337  [ALPINE-RIDGE_BGA_337P]  21.97 45.73 270 bottom
UT2  -  [W25Q80DVSSIG_SO8]  32.96 27.31 90 bottom
UT3  -  [APE8937GN2_DFN8_2X2]  16.17 30.98 270 top
UT4  TPS65982_BGA96  [TPS65982_BGA_96P]  11.3 40.42 180 bottom
UT5  -  [W25Q32FVSSIQ_SO8]  15.11 33.99 0 bottom
UV1  N16P-GX-A2  [N13M_FCBGA_908P]  226.8 63.85 90 bottom
UV5  K4G41325FC-HC04_FBGA170~D  [K4G41325FC-HC04_FBGA_170P]  224.29 100.56 90 bottom
UV6  K4G41325FC-HC04_FBGA170~D  [K4G41325FC-HC04_FBGA_170P]  206.26 100.56 90 bottom
UV9  K4G41325FC-HC04_FBGA170~D  [K4G41325FC-HC04_FBGA_170P]  235.51 66.03 0 bottom
UV10  K4G41325FC-HC04_FBGA170~D  [K4G41325FC-HC04_FBGA_170P]  235.51 84.06 0 bottom
UV14  -  [MC74VHC1G08DFT2G_SC70-5]  198.63 45.35 0 top
UV16  -  [AP2330W-7_SC59-3]  18.67 88.09 180 top
UV17  -  [PCA9515BDGKR_VSSOP8]  64.37 25.75 270 top
UZ1  -  [EM5209VF_DFN14_3X2]  314.24 33.41 90 top
UZ4  -  [APE8937GN2_DFN8_2X2]  57.58 5.11 180 top
UZ5  -  [APE8937GN2_DFN8_2X2]  344 43.24 270 bottom
UZ7  -  [EM5209VF_DFN14_3X2]  240.39 3.5 0 top
UZ8  -  [SY6288C20AAC_SOT23-5]  43.13 27.35 90 top
UZ9  -  [TPS22961DNYR_WSON8]  182.51 84.96 90 bottom
UZ10  G9090-250T11U_SOT23-5  [G9141T11U_SOT23-5]  181.11 9.75 0 top
UZ11  -  [MC74VHC1G08DFT2G_SC70-5]  178.02 4.47 0 top
UZ12  -  [MC74VHC1G08DFT2G_SC70-5]  173.13 4.49 0 top
UZ15  -  [TPS22961DNYR_WSON8]  181.97 84.68 180 top
UZ16  -  [APE8937GN2_DFN8_2X2]  133.79 66.7 90 top
UZ17  -  [APE8937GN2_DFN8_2X2]  232.43 59.84 90 top
UZ18  -  [MC74VHC1G08DFT2G_SC70-5]  125.29 68.86 270 top
UZ19  -  [MC74VHC1G09DFT2G_SC70-5]  120.62 58.56 0 top
UZ20  -  [MC74VHC1G08DFT2G_SC70-5]  182.9 5.15 180 top
UZ21  -  [MC74VHC1G08DFT2G_SC70-5]  168.47 4.98 270 top
UZ22  -  [MC74VHC1G08DFT2G_SC70-5]  122.49 63.87 90 top
UZ23  -  [MC74VHC1G08DFT2G_SC70-5]  105.99 53.36 270 top
YE1  32.768KHZ_12.5PF_CM7V-12520  [Y_CM7V-12520_2P]  287.28 12.82 270 top
YH1  32.768KHZ_X1A000141000300  [Y_CM31532768DZFT_2P]  101.43 2.18 0 top
YH2  24MHZ_12PF_X3G024000DC1H  [Y_X3G024000DC1H_4P]  104.28 27.4 270 top
YT1  25MHZ_10PF_7V25000014  [Y_7V25000014_4P]  23.05 33.47 0 bottom
YV1  27MHZ_10PF_5YEA27000102IF50Q3  [Y_5YEA27000102IF50Q3_4P]  223.8 54.72 180 bottom

## Library data of the parts
ADP100 = ACES_50290-00701-001_7P-T
BAT100 = ACES_50290-01201-P01_12P-T
CD1-CD4 CD12 CD16-CD18 CD69 CD74-CD79 = C_0402: room: DIMMA
CD5-CD10 CD13-CD15 CD70-CD73 = C_0603: room: DIMMA
CD11 = C_EEFSS0D221R: room: DIMMA
CD19-CD22 CD29-CD32 CD34 CD35 CD80-CD83 = C_0402: room: DIMMB
CD23-CD28 CD84-CD90 = C_0603: room: DIMMB
CD33 = C_EEFSS0D221R: room: DIMMB
CD36 = C_0603: room: NGFF SSD
CD37-CD47 CD51 CD53 = C_0402: room: NGFF SSD
CE8 CE11-CE13 = C_0402: room: TPM
CE14 = C_0603: room: TPM
CE15 CE16 = C_0402: room: LID
CE17-CE21 CE23-CE39 CE42-CE44 CE48 CE51 CE70 CE71 = C_0402: room: EC5085
CE22 CE40 = C_0603: room: EC5085
CE41 CE45-CE47 CE49 CE50 CE52 CE68 CE69 = C_0402: room: THERMAL
CE53 = C_0603: room: EC23017
CE54 CE55 = C_0402: room: EC23017
CE65 = C_0402: room: TOUCH PAD
CE66 CE67 = C_0402: room: FAN
CE72-CE75 CE77-CE82 CH200 CH203 CI21 CI22 CT146 CT158-CT160 CV790 CV792-CV796 CV799-CV814 CZ96 CZ97 PC106-PC110 PC112-PC115 PC201-PC206 PC210-PC218 PC223-PC225 PC306 PC313 PC314 PC322 PC327 PC328 PC330-PC332 PC334 PC401-PC405 PC407 PC408 PC415 PC416 PC418 PC500 PC502 PC503 PC505 PC507 PC603 PC604 PC609 PC612-PC614 PC701-PC704 PC708 PC800 PC802 PC803 PC807 PC900 PC902 PC905 PC907 PC1000 PC1003-PC1009 PC1011 PC1029 PC1036 PC1039-PC1041 PC1043-PC1046 PC1056-PC1059 PC1062-PC1066 PC1069 PC1070 PC1100 PC1101 PC1103-PC1139 PC1200 PC1201 PC1213 PC1214 PC1221-PC1233 PC1237-PC1250 PC1253 PC1254 PC1277 PC1302 PC1308 PC1313 PC1317 PC1319-PC1342 PC1345 PC1346 PC1355 PC1357 PC1364 PC1383 PC1384 = C_0402
CE76 CH201 CH202 CT147-CT150 CT153 CT155 CT157 CT162 CT164 CT165 CV791 CV797 CV798 CV815 CV816 PC111 PC200 PC207-PC209 PC219-PC222 PC288 PC289 PC311 PC320 PC321 PC323 PC329 PC333 PC335 PC400 PC410 PC411 PC414 PC417 PC419 PC501 PC512 PC513 PC600 PC607 PC610 PC611 PC700 PC705-PC707 PC709 PC713 PC801 PC805 PC812 PC813 PC901 PC906 PC912 PC913 PC1010 PC1012-PC1021 PC1025 PC1027 PC1028 PC1033-PC1035 PC1042 PC1047-PC1049 PC1051 PC1052 PC1055 PC1067 PC1068 PC1071-PC1077 PC1079-PC1083 PC1102 PC1209 PC1220 PC1234 PC1255 PC1261 PC1263-PC1265 PC1269 PC1271 PC1274 PC1276 PC1314 PC1318 PC1347-PC1354 PC1359-PC1363 PC1365-PC1370 PC1372-PC1380 PC1385 PC1386 PC1389-PC1391 PC1394-PC1396 = C_0603
CF1 = C_0603: room: HDD FFS
CF2 = C_0402: room: HDD FFS
CH3 CH100 CH101 CH174 CH175 CH197 CZ47 CZ49 CZ57 CZ82 CZ86 CZ88 = C_0402: room: CPU
CH5-CH36 = C_0201: room: CPU
CH44 CH196 = C_0402: room: RTC
CH45-CH48 CH50-CH53 CH70 CH80 CH82 CH173 CH176 CH179 CH180 CH183 CH186-CH192 CH198 CH199 = C_0402: room: PCH
CH102-CH104 CH111-CH132 CH136 = C_0603: room: CPU_DECAP
CH105-CH110 CH133-CH135 = C_0402: room: CPU_DECAP
CH138 = C_B2: room: CPU_DECAP
CH177 CH178 CH181 CH182 CH184 = C_0603: room: PCH
CI1 CI9 CI10 CI13 = C_0402: room: USB1
CI2-CI8 CI16 CI19 CI20 = C_0402: room: USB2
CI11 = C_0805: room: USB1
CI12 = C_0603: room: USB1
CI17 = C_0805: room: USB2
CI18 = C_0603: room: USB2
CLRP1 = SHORTPADS: User Part Number: PART#; room: PCH
CN1 CN6 = C_0603: room: NGFF WLAN
CN2 CN7-CN9 CN20-CN22 = C_0402: room: NGFF WLAN
CR1-CR3 CR5 CR7-CR11 CR13 CR15 CR16 CR18 = C_0402: room: CARD READER
CR4 CR6 CR12 CR14 CR17 = C_0603: room: CARD READER
CS12-CS14 CS17-CS20 = C_0402: room: HDD
CS15 = C_0603: room: HDD
CT1-CT8 CT17-CT24 CT26 CT29-CT42 CT47 CT50 CT52 CT62-CT68 CT71 CT72 CT74 CT80-CT86 CT93 CT94 CT99-CT103 CT107 CT108 = C_0201: room: THUNBERBOLT
CT25 CT141-CT145 CT151 CT152 CT161 CT163 = C_0201
CT43 CT44 CT53-CT56 CT95-CT98 CT106 CT120-CT123 = C_0402: room: THUNBERBOLT
CT88-CT90 CT105 = C_0603: room: THUNBERBOLT
CV129 CV363 CV570 CV571 CV575 CV576 CV580 CV581 CV591-CV596 CV606-CV611 CV613 CV614 CV619 CV621-CV623 CV636-CV639 CV650 CV651 CV653-CV658 CV660-CV663 CV675 CV676 CV678-CV683 CV685-CV688 CV700 CV701 CV703-CV708 CV710-CV713 CV725 CV726 CV728-CV733 CV735-CV738 CV773 CV776-CV778 CV789 CZ95 = C_0402: room: GPU
CV156 CV158-CV167 CV169 = C_0402: room: EDP
CV157 CV168 = C_0603: room: EDP
CV170-CV177 = C_0201: room: HDMI
CV178 CV180-CV182 = C_0402: room: HDMI
CV179 = C_0603: room: HDMI
CV183 CV184 = C_0402: room: CAMERA
CV185 = C_0603: room: CAMERA
CV531-CV548 CV550-CV552 CV557-CV567 = C_0201: room: GPU
CV572 CV574 CV582-CV590 CV597-CV605 CV612 CV615-CV617 CV652 CV659 CV677 CV684 CV702 CV709 CV727 CV734 = C_0603: room: GPU
CV573 = C_0805: room: GPU
CZ4 CZ6 CZ8 CZ9 CZ11 CZ12 = C_0603: room: 3V_5V_DC_DC
CZ18-CZ20 = C_0402: room: PCH_DC_DC
CZ26 CZ29 CZ31 = C_0402: room: CAMERA_CR_DC_DC
CZ28 = C_0402: room: CPU_DC_DC
CZ37 CZ39 = C_0603: room: HDD_DC_DC
CZ41 CZ43 CZ44 = C_0402: room: EDP_DC_DC
CZ45 CZ46 = C_0402: room: HDD_DC_DC
CZ53 CZ54 = C_0603: room: CPU
D122 = BAS40-04_SOT23-3: room: RTC
DE2 = AZ5125-02SPR7G_SOT23-3: room: PWR LED
DE4 DE5 = PESD5V0U2BT_SOT23-3: room: TOUCH PAD
DE7 DE8 = RB751S40T1G_SOD523-2: room: FAN
DE9 PD101 PD102 = TVNST52302AB0_SOT523-3
DE11 DH1 DT28 DT29 = RB751S40T1G_SOD523-2
DI1 = RB751S40T1G_SOD523-2: room: EDP
DI3 = AZ5125-02SPR7G_SOT23-3: room: EDP
DI7 = AZ1045-04F_DFN2510P10E-10-9: room: USB1
DI8 = AZ5125-02SPR7G_SOT23-3: room: USB1
DI9 = AZ1045-04F_DFN2510P10E-10-9: room: USB2
DI10 = AZ5125-02SPR7G_SOT23-3: room: USB2
DI11 = RB751S40T1G_SOD523-2: room: USB2
DI12 DZ1 = BAT54CW-7-F_SOT323-3
DL1 = AZ5125-02SPR7G_SOT23-3: room: BATTERY LED
DN1 DN2 = RB751S40T1G_SOD523-2: room: NGFF WLAN
DN3 = BAT54CW-7-F_SOT323-3: room: NGFF WLAN
DT10 = PESD24VS2UT_SOT23-3
DT12-DT27 = ESD108-B1-CSP0201_WLL-2-1-2
DV1 DV2 = BAT54CW-7-F_SOT323-3: room: EDP
DV4 DV5 = AZ1045-04F_DFN2510P10E-10-9: room: HDMI
DV7 = BAT54CW-7-F_SOT323-3: room: EDP_DC_DC
DV8 DV9 = BAT54CW-7-F_SOT323-3: room: GPU
DV10 DV11 = RB751S40T1G_SOD523-2: room: GPU
DV12 = IP4223CZ6_SO6-6
FD1-FD4 = FIDUCIAL_C40M80: room: ETY-ROOM
H1 H2 = H_2P3: room: ETY-ROOM
H5 H6 = H_3P2: room: ETY-ROOM
H9 H10 = H_2P5: room: ETY-ROOM
H11 = H_2P1N: room: ETY-ROOM
H12 = H_6P0N: room: ETY-ROOM
H13 H16 = H_3P9: room: ETY-ROOM
H17 = H_2P1X2P5N: room: ETY-ROOM
H18-H25 = EMIST_SUL-12A2M_1P: room: ETY-ROOM
H26-H36 H52 H53 H56-H58 = EMIST_SUL-12A2M_1P
H37 H38 = H_3P0
H39 H40 = H_2P5
H41 H42 = H_2P8
H43 H49 = H_2P3
H45 H46 = H_3P9
H47 = H_6P0N
H48 = H_4P1
H50 = CLIP_C6
H51 H54 H55 = CLIP_C5P5
H59 = H_2P9X2P1N
JAPS = ACES_50506-01841-P01_18P: room: CPU
JAUDIO = E-T_1133K-R30C-01L_30P: room: ETY-ROOM
JCR = T-SOL_156-1001302601_19P_NR-T: room: CARD READER
JDEG1 JLPDE1 = HB_A531015-SCHR21_10P: room: EC5085
JDIMM1 = BELLW_SD-80886-1021_260P-T: room: DIMMA
JDIMM2 = BELLW_SD-80886-1021_260P-T: room: DIMMB
JEDP1 = ACES_59003-04006-001_40P: room: EDP
JFAN1 JFAN2 = ACES_50224-00401-001_4P: room: FAN
JHDD = J-L_UCNR2234B020-0_20P: room: HDD
JHDMI1 = ACON_HMRB9-AK120C_19P: room: HDMI
JKB = E-T_6710K-Y15M-31L_15P: room: ETY-ROOM
JNGFF1 = CONCR_213AAAA32FA_67P: room: NGFF WLAN
JNGFF2 = CONCR_213MAAA32FA_67P-T: room: NGFF SSD
JRTC = E-T_3806K-F02N-03R_2P: room: RTC
JTAG1 = SHORTPADS: User Part Number: PART#; room: EC5085
JTP = ACES_51524-0080N-001_8P: room: TOUCH PAD
JTS = ACES_50208-00601-P01_6P
JUART = ACES_50207-00471-P01_4P-T
JUSB1 = TAIWI_USB019-107CRL-TWD_10P-T: room: USB1
JUSB2 = TAIWI_USB019-107CRL-TWD_10P-T: room: USB2
JUSBC1 = JAE_DX07S024XJ2_24P-T: room: THUNBERBOLT
JXDP = SAMTE_BSH-030-01-L-D-A_60P: room: CPU
LED1-LED5 = LED_LTW-270TLA_2P: room: BATTERY LED
LED6 = LED_HT-F196BP5_2P
LH1 LH2 = MURAT_BLM15PX221SN1D_2P
LI1 = INPAQ_MCM1012B900F06BP_4P: room: EDP
LI2 = INPAQ_MCM1012B900F06BP_4P: room: USB2
LI5 = INPAQ_MCM1012B900F06BP_4P: room: USB1
LN1 = INPAQ_MCM1012B900F06BP_4P: room: NGFF WLAN
LT1 = COILC_XFL4012-601MEC_2P: room: THUNBERBOLT
LT11 PL105-PL108 PL200-PL203 PL300 PL301 PL402 PL403 PL500 PL601 PL701 PL800 PL900 PL1003 PL1004 PL1203 PL1204 PL1303-PL1305 = TAI-T_HCB2012KF-121T50_2P
LT12 LT13 = CHILI_CMMI21T-900Y-N_4P
LT14 = CHILI_PBY160808T-300Y-N_2P
LV2 = CHILI_PBY160808T-300Y-N_2P: room: GPU
LV3 = MURAT_BLM15PX121SN1D_2P: room: GPU
LV14 = MURAT_BLM15PX330SN1D_2P: room: GPU
LV21 = MURAT_BLM18PG300SN1D_2P: room: GPU
LV22 = INPAQ_MCM1012B900F06BP_4P: room: CAMERA
PC307-PC310 PC315-PC319 PC324-PC326 PC336 PC337 PC406 PC409 PC504 PC506 PC508-PC511 PC601 PC602 PC605 PC606 PC710-PC712 PC755 PC804 PC806 PC808-PC811 PC903 PC904 PC908-PC911 PC1001 PC1002 PC1037 PC1038 PC1050 PC1053 PC1054 PC1060 PC1061 PC1211 PC1212 PC1235 PC1236 PC1251 PC1252 PC1300 PC1303-PC1306 PC1309-PC1312 PC1315 PC1316 PC1343 PC1344 PC1356 PC1358 PC1382 PC1388 PC1393 = C_0805
PC312 PC420 PC1210 PC1256 = C_D
PC412 PC413 PC1022-PC1024 = C_B2
PC608 = C_D1
PC1207 PC1208 PC1301 PC1307 = C_D2
PC1262 PC1397 = C_EEFSS0D221R
PD100 = AZ5125-01HPR7G_SOD523-2
PD201-PD203 PD205 PD207 PD211 PD302-PD304 = SDMK0340L-7-F_SOD323-2
PD204 = BAT54CW_SOT323-3
PD301 = SX34H_SMA2
PH1100-PH1104 PR21 PR27 PR100-PR112 PR200-PR214 PR217-PR245 PR247-PR283 PR287 PR290-PR292 PR299 PR303 PR305 PR308 PR311 PR315 PR316 PR318 PR319 PR321 PR323 PR325-PR327 PR399 PR401-PR406 PR410 PR428 PR501 PR504 PR508 PR510 PR512 PR601 PR604 PR605 PR607 PR609 PR610 PR700 PR701 PR704 PR801 PR804 PR806 PR810 PR811 PR813 PR900 PR901 PR904-PR906 PR910 PR913 PR1001-PR1006 PR1009-PR1011 PR1013 PR1016-PR1018 PR1020 PR1022-PR1024 PR1028 PR1100 PR1101 PR1103-PR1117 PR1120-PR1131 PR1133-PR1145 PR1201 PR1203 PR1205 PR1207 PR1209 PR1211-PR1217 PR1224-PR1226 PR1302-PR1304 PR1306 PR1318-PR1321 RD59 RE94-RE96 RE99-RE101 RE110 RE111 RE113-RE115 RE126-RE128 RE132 RE134 RE136 RE137 RE140 RF5 RH539 RH544-RH558 RH561-RH573 RH587 RI26-RI28 RI30 RI31 RI34 RI35 RL1-RL5 RT183 RT189 RT191 RT194 RT199 RT242 RV512-RV519 RV530-RV546 RV548 RV549 RZ71 RZ72 RZ74 RZ75 RZ80 RZ82 RZ84-RZ89 = R_0402
PJP300 PJP601 = JUMP_43X39
PJP400 PJP402 PJP403 PJP500 PJP600 PJP603 PJP701 PJP702 PJP800 PJP900 PJP1200 PJP1300 PJP1301 = JUMP_43X118
PJP602 PJP700 = JUMP_43X79
PJP1205 = JUMP_43X39: room: EC5085
PJP1206 = JUMP_43X39: room: EC23017
PJP1302 PJP1303 = JUMP_43X39: room: PCH
PL104 = MURAT_BLM15AG102SN1D_2P
PL302 = CYNTE_PIMB104T-3R3MS_2P
PL400 PL600 = L_7X7X3_M_2P
PL401 PL700 = PANAS_ETQP3W1R5WFN_2P
PL501 PL801 PL901 = L_5X5X3_M_2P
PL1000-PL1002 PL1200-PL1202 PL1300 PL1301 = L_7X7X4_M_2P
PL1306 = CYNTE_PCMB053T-R47MS_2P
PQ100 = FDV301N-G_SOT23-3
PQ101 QE15 = MMBT3904WH_SOT323-3
PQ103 = L2N7002WT1G_SC70-3
PQ200-PQ203 PQ212-PQ214 PQ303 PQ1301 = AON7409_DFN8-5
PQ204 PQ215-PQ217 = NTR4502PT1G_SOT23-3
PQ205-PQ211 PQ218-PQ220 PQ222 PQ223 PQ225-PQ234 PQ304 = SSM3K7002FU_SC70-3
PQ221 PQ224 = AO3413_SOT23-3
PQ300 PQ301 = SIR472DP-T1-GE3_POWERPAK8-5
PQ302 = SIRA06DP-T1-GE_POWERPAKSO-8-5
PQ400 = MDV1528URH_PDFN33-8-5
PQ401 = MDU1516URH_POWERDFN56-8-5
PQ402 = MDV1524URH_PDFN33-8-5
PQ403 = MDU1512RH_POWERDFN56-8-5
PQ600 = MDV1527URH_POWERDFN33-8-5
PQ601 = MDV1522URH_PDFN33-8-5
PQ1000-PQ1002 = CSD87351Q5D_SON8-7
PQ1300 = AON7934_DFN3X3A8-10
PR113 PR301 PR302 PR306 PR309 PR312 PR314 PR317 PR322 PR324 PR400 PR407-PR409 PR415 PR500 PR503 PR606 PR608 PR705 PR800 PR808 PR809 PR812 PR907 PR912 PR1000 PR1012 PR1015 PR1025 PR1102 PR1118 PR1119 PR1132 PR1310 PR1311 RD58 RE102 RE103 RE107-RE109 RE112 RE116-RE120 RE122 RE125 RE129 RE133 RE138 RE139 RH540-RH543 RH576-RH581 RH586 RI32 RI33 RI36-RI44 RT176-RT178 RT181 RT182 RT184 RT185 RT190 RT195 RT198 RT200 RT201 RT240 RT243 RT244 RT246 RV520-RV529 RV547 RZ76 RZ81 RZ90 RZ91 = R0402_0OHM
PR215 PR216 PR300 = R_1206_4P-D
PR246 PR304 PR313 PR413 PR414 PR502 PR602 PR702 PR802 PR902 PR1008 PR1021 PR1027 PR1200 PR1204 PR1208 PR1300 PR1307 PR1308 = R_1206
PR307 PR320 PR411 PR412 PR600 PR603 PR703 PR1007 PR1014 PR1019 PR1026 PR1202 PR1206 PR1210 PR1301 PR1305 PR1309 RT114 = R_0603
PR310 = R_2512_4P
PR803 PR903 RE93 RE104 RE105 RE121 RE141 RH582-RH585 RN34 RT113 RT241 = R0603_0OHM
PR1218-PR1223 PR1312-PR1317 = R0402_0OHM_NPM
PU200 = INA199A1DCKR_SC70-6
PU201 PU202 = LM393DMR2G_MICRO8
PU203 = RT9069-33GB_SOT23-5
PU204 UZ18 UZ20-UZ23 = MC74VHC1G08DFT2G_SC70-5
PU300 = BQ24777RUYR_WQFN28_4X4
PU400 = TPS51285BRUKR_QFN20_3X3
PU500 PU800 PU900 = SYX196DQNC_QFN10_3X3
PU600 = G5616ARZ1U_TQFN20_3X3
PU700 = TPS51367RVER_QFN28_4P5X3P5
PU1000 = RT8813AGQW_WQFN24_4X4
PU1001 = RT9610BZQW_WDFN8_2X2
PU1100 = ISL95855HRTZ-T_TQFN48_6X6
PU1200-PU1202 PU1300 PU1301 = AOZ5019QI_QFN23_5X3P5
PU1302 = ISL95808HRZ-TS2378_DFN8_2X2
QE2 = DMN65D8LDW-7_SOT363-6: room: TOUCH PAD
QE4 = DMN65D8LDW-7_SOT363-6: room: EC5085
QE5-QE12 = MMBT3904WH_SOT323-3: room: THERMAL
QE13 = L2N7002WT1G_SC-70-3: room: TOUCH PAD
QE17 QZ9 = DMG2301U-7_SOT23-3
QE18 QE19 = DMN65D8LDW-7_SOT363-6
QF1 = DMN65D8LDW-7_SOT363-6: room: HDD FFS
QH4 = DMN65D8LDW-7_SOT363-6: room: PCH
QR1 QV88 QV89 = L2N7002WT1G_SC-70-3
QT1 = DMN65D8LDW-7_SOT363-6: room: THUNBERBOLT
QV9 QV12 = L2N7002WT1G_SC-70-3: room: EDP
QV11 = SI3457BDV-T1-E3_TSOP6: room: EDP
QV13 QV14 = L2N7002WT1G_SC-70-3: room: HDMI
QV21 QZ6 QZ7 = DMN65D8LDW-7_SOT363-6: room: GPU
QV22-QV25 QV39 QV87 QZ8 = L2N7002WT1G_SC-70-3: room: GPU
QV86 = DMG2301U-7_SOT23-3: room: GPU
QX1 = DMN65D8LDW-7_SOT363-6: room: HDMI
RD1-RD3 RD35 = R_0402: room: DIMMA
RD4 RD6 RD39 = R_0402: room: DIMMB
RD5 RD38 RD40 = R0402_0OHM: room: DIMMB
RD7-RD10 = R_0402: room: NGFF SSD
RD28-RD31 = R0402_0OHM: room: DIMMA
RE3 = R_0402: room: PWR LED
RE7 RE9 RE87 = R_0402: room: TOUCH PAD
RE11 RE13 RE14 RE77 RE85 RE86 = R_0402: room: TPM
RE15 = R_0402: room: LID
RE16 RE37 RE39 RE51 = R0402_0OHM: room: EC5085
RE17-RE27 RE30-RE36 RE38 RE41 RE43-RE45 RE48 RE50 RE52 RE54-RE56 RE59-RE65 RE67 RE68 RE70 RE89 RE90 = R_0402: room: EC5085
RE57 RE58 RE66 RE69 = R_0402: room: THERMAL
RE71-RE76 = R_0402: room: EC23017
RE81-RE84 = R_0402: room: FAN
RF1 = R0603_0OHM: room: HDD FFS
RF2-RF4 = R_0402: room: HDD FFS
RH2 RH5 RH6 RH24 RH30 RH57-RH59 RH95 RH97 RH98 RH100 RH145 RH148-RH156 RH158 RH163-RH167 RH183-RH189 RH191 RH192 RH197 RH201 RH203 RH206 RH207 RH209-RH212 RH456 RH466 RH469 RH472 RH474 RH475 RH479-RH485 RH488-RH490 RH492-RH498 RH519 RH525 RH530 RZ50 RZ52 RZ54 RZ59 RZ61 = R_0402: room: CPU
RH8 RH12 RH190 RH198 RH202 RH204 RH465 RH470 RH471 RH473 RH477 RH478 RH491 RZ58 RZ60 = R0402_0OHM: room: CPU
RH67 = R_0402: room: RTC
RH70-RH72 RH74 RH75 RH77 RH78 RH82-RH85 RH88 RH91 RH108-RH111 RH119 RH120 RH130 RH146 RH147 RH168 RH196 RH383 RH401 RH423-RH425 RH428 RH453-RH455 RH458-RH463 RH501-RH506 RH508 RH510-RH513 RH515 RH516 RH518 RH520-RH524 RH527-RH529 RH531 RH533 RH535-RH538 = R_0402: room: PCH
RH96 RH133 RH309 RH487 = R0402_0OHM: room: PCH
RH136 RH137 = R0603_0OHM: room: PCH
RI4-RI8 = R_0402: room: USB1
RI9-RI13 RI15-RI24 = R_0402: room: USB2
RI14 = R0805_0OHM: room: USB2
RI25 = R0402_0OHM: room: USB2
RN1 RN33 = R_0402: room: NGFF WLAN
RP1 RP2 RP4 RP8 RP15 RP22 RP23 = RP_0804_8P4R: room: PCH
RP19 RP20 = RP_0804_8P4R: room: EC5085
RP24 = RP_1206_10P8R: room: BATTERY LED
RPH13 RPH15 RPH32 = RP_0804_8P4R: room: GPU
RPH34 = RP_0804_8P4R
RR1 RR6 RR9 = R_0402: room: CARD READER
RR2-RR5 RR7 RR8 RR10 = R0402_0OHM: room: CARD READER
RT1 RT2 RT5 RT10 = R_0402: room: THUNBERBOLT
RT3 RT4 RT6-RT9 RT12 RT15-RT18 RT21-RT23 RT25 RT33-RT45 RT107 = R_0201: room: THUNBERBOLT
RT46 = R_0603: room: THUNBERBOLT
RT164 RT167-RT171 RT186-RT188 RT192 RT193 RT202 RT207-RT213 RT226-RT233 RT245 = R_0201
RT165 RV511 RZ70 = R0805_0OHM
RV10 RV510 = R0402_0OHM: room: GPU
RV29 RV45 RV50 RV181 RV187 RV208 RV209 RV286 RV290 RV299-RV316 RV318-RV320 RV323-RV332 RV338-RV348 RV352-RV361 RV363 RV365 RV366 RV368-RV374 RV378-RV387 RV389 RV391 RV392 RV394-RV399 RV409 RV410 RV414 RV418 RV479 RV501 RZ8-RZ10 RZ12 = R_0402: room: GPU
RV107 RV109 RV114 RV119 RV120 RV135 = R_0402: room: EDP
RV110 RV113 = R0402_0OHM: room: EDP
RV121-RV125 = R_0402: room: HDMI
RZ11 = R_0603: room: GPU
RZ13 RZ15 = R0603_0OHM: room: 3V_5V_DC_DC
RZ18 = R0603_0OHM: room: PCH_DC_DC
RZ26 RZ28 = R0603_0OHM: room: CAMERA_CR_DC_DC
RZ32 = R_0402: room: CAMERA_CR_DC_DC
RZ34 RZ36 = R0805_0OHM: room: HDD_DC_DC
RZ35 RZ37 = R0603_0OHM: room: EDP_DC_DC
RZ38-RZ40 = R_0402: room: EDP_DC_DC
RZ41 = R_0402: room: PCH_DC_DC
RZ43 = R_0402: room: AUDIO_DC_DC
RZ46 = R_0402: room: HDD_DC_DC
RZ48 RZ53 RZ67 = R0603_0OHM: room: CPU
RZ66 = R0603_0OHM: room: CPU_DC_DC
RZ69 = R0805_0OHM: room: GPU
SW1 = SW_SKRBAAE010_4P: room: PWR LED
SW2 = SW_NTC311-EA1T-A160T_4P: room: BATTERY LED
SW4 = SW_SSAL120100_3P: room: PCH
T2 T4 T8 T17 T18 T20 T91 T92 T94 T104-T108 T120-T124 T127 = TPC12: room: PCH
T11-T13 T174 = TPC12: room: GPU
T39-T53 T57-T71 T73-T90 = TPC12: room: CPU
T176 T182 T185 T187 T191-T200 = TPC12
UC1 = 74AUP1G07GW_TSSOP5: room: CPU
UD2 = NL17SZ14DFT2G_SOT353-5: room: NGFF SSD
UE1 = NPCT650JAAYX_QFN32_5X5: room: TPM
UE2 = TCS20DLR_SOT23F-3: room: LID
UE3 = MEC5085-LZY_DQFN132_11X11: room: EC5085
UE4 = MCP23017T-E-ML_QFN28_6X6: room: EC23017
UE6 = APE8937GN2_DFN8_2X2: room: TOUCH PAD
UF1 = LNG3DMTR_LGA16_3X3: room: HDD FFS
UH1 = SKL-H_BGA_1440P-T: room: CPU
UH2 = SKY-S-PCH_BGA_837P-T: room: PCH
UH7 UH14 = MC74VHC1G08DFT2G_SC70-5: room: PCH
UH8 = W25Q128FVSIQ_SO8: room: PCH
UI1 = TPS2546RTER_QFN16_3X3: room: USB1
UI2 = TPS2546RTER_QFN16_3X3: room: USB2
UI3 = PS8713BTQFN24GTR2_TQFN24_4X4: room: USB2
UI4 UI5 = MC74VHC1G32DFT2G_SC70-5
UN3 = APE8937GN2_DFN8_2X2: room: NGFF WLAN
UR1 = RTS5242-GR_QFN32_4X4: room: CARD READER
UT1 = ALPINE-RIDGE_BGA_337P: room: THUNBERBOLT
UT2 = W25Q80DVSSIG_SO8
UT3 = APE8937GN2_DFN8_2X2
UT4 = TPS65982_BGA_96P
UT5 = W25Q32FVSSIQ_SO8: room: THUNBERBOLT
UV1 = N13M_FCBGA_908P: room: GPU
UV5 UV6 UV9 UV10 = K4G41325FC-HC04_FBGA_170P: room: GPU
UV14 = MC74VHC1G08DFT2G_SC70-5: room: GPU
UV16 = AP2330W-7_SC59-3: room: HDMI
UV17 = PCA9515BDGKR_VSSOP8
UZ1 = EM5209VF_DFN14_3X2: room: 3V_5V_DC_DC
UZ4 = APE8937GN2_DFN8_2X2: room: PCH_DC_DC
UZ5 = APE8937GN2_DFN8_2X2: room: CAMERA_CR_DC_DC
UZ7 = EM5209VF_DFN14_3X2: room: HDD_DC_DC
UZ8 = SY6288C20AAC_SOT23-5: room: EDP_DC_DC
UZ9 = TPS22961DNYR_WSON8: room: CPU
UZ10 = G9141T11U_SOT23-5: room: CPU
UZ11 UZ12 = MC74VHC1G08DFT2G_SC70-5: room: CPU
UZ15 = TPS22961DNYR_WSON8: room: CPU_DC_DC
UZ16 = APE8937GN2_DFN8_2X2: room: CPU
UZ17 = APE8937GN2_DFN8_2X2: room: GPU
UZ19 = MC74VHC1G09DFT2G_SC70-5
YE1 = Y_CM7V-12520_2P: room: EC5085
YH1 = Y_CM31532768DZFT_2P: room: PCH
YH2 = Y_X3G024000DC1H_4P: room: PCH
YT1 = Y_7V25000014_4P: room: THUNBERBOLT
YV1 = Y_5YEA27000102IF50Q3_4P: room: GPU

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50207-00471-P01_4P-T
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0)
  rect 1.194x1.702 smd: 5(-3.7,1.45) 6(1.3,1.45)
ACES_50208-00601-P01_6P
  oval 0.508x0.991 smd: 1(0,0) 2(-0.8,0) 3(-1.6,0) 4(-2.4,0) 5(-3.2,0) 6(-4,0)
  rect 1.194x1.702 smd: 7(-5.3,-1.95) 8(1.3,-1.95)
ACES_50224-00401-001_4P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.194x1.803 smd: 5(4.3,-3.875) 6(-1.3,-3.875)
ACES_50290-00701-001_7P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0)
ACES_50290-01201-P01_12P-T
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0) 12(16.5,0)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_59003-04006-001_40P
  round 0.889 hole 0.889 unplated: (-20.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.499x2.997 smd: 41(-22,2.125) 42(2.5,2.125)
  rect 2.794x1.499 smd: 43(-15.45,4.175) 44(-4.05,4.175)
ACON_HMRB9-AK120C_19P
  round 0.762 hole 0.508: 1(0,0) 2(-0.5,-1.2) 3(-1,0) 4(-1.5,-1.2) 5(-2,0) 6(-2.5,-1.2) 7(-3,0) 8(-3.5,-1.2) 9(-4,0) 10(-4.5,-1.2) 11(-5,0) 12(-5.5,-1.2) 13(-6,0) 14(-6.5,-1.2) 15(-7,0) 16(-7.5,-1.2) 17(-8,0) 18(-8.5,-1.2) 19(-9,0)
  oval 1.6x2.311 hole 0.991x1.702: 20(-11.75,0) 21(-13.5,-7.57) 22(4.5,-7.57) 23(2.75,0)
ALPINE-RIDGE_BGA_337P
  round 0.254 smd: A1(0,0) A23(10.12,0) AA2(0.46,-9.2) AA22(9.66,-9.2) AB2(0.46,-9.66) AB3(0.92,-9.66) AB4(1.38,-9.66) AB5(1.84,-9.66) AB6(2.3,-9.66) AB7(2.76,-9.66) AB8(3.22,-9.66) AB9(3.68,-9.66) AB10(4.14,-9.66) AB11(4.6,-9.66) AB12(5.06,-9.66) AB13(5.52,-9.66) AB14(5.98,-9.66) AB15(6.44,-9.66) AB16(6.9,-9.66) AB17(7.36,-9.66) AB18(7.82,-9.66) AB19(8.28,-9.66) AB20(8.74,-9.66) AB21(9.2,-9.66) AB22(9.66,-9.66) AC1(0,-10.12) AC23(10.12,-10.12) B2(0.46,-0.46) B3(0.92,-0.46) B4(1.38,-0.46) B5(1.84,-0.46) B6(2.3,-0.46) B7(2.76,-0.46) B8(3.22,-0.46) B9(3.68,-0.46) B10(4.14,-0.46) B11(4.6,-0.46) B12(5.06,-0.46) B13(5.52,-0.46) B14(5.98,-0.46) B15(6.44,-0.46) B16(6.9,-0.46) B17(7.36,-0.46) B18(7.82,-0.46) B19(8.28,-0.46) B20(8.74,-0.46) B21(9.2,-0.46) B22(9.66,-0.46) C2(0.46,-0.92) C22(9.66,-0.92) D2(0.46,-1.38) D4(1.16,-1.16) D5(1.81,-1.16) D6(2.46,-1.16) D8(3.11,-1.16) D9(3.76,-1.16) D11(4.41,-1.16) D12(5.06,-1.16) D13(5.71,-1.16) D15(6.36,-1.16) D16(7.01,-1.16) D18(7.66,-1.16) D19(8.31,-1.16) D20(8.96,-1.16) D22(9.66,-1.38) E2(0.46,-1.84) E4(1.16,-1.81) E5(1.81,-1.81) E6(2.46,-1.81) E8(3.11,-1.81) E9(3.76,-1.81) E11(4.41,-1.81) E12(5.06,-1.81) E13(5.71,-1.81) E15(6.36,-1.81) E16(7.01,-1.81) E18(7.66,-1.81) E19(8.31,-1.81) E20(8.96,-1.81) E22(9.66,-1.84) F2(0.46,-2.3) F4(1.16,-2.46) F5(1.81,-2.46) F6(2.46,-2.46) F8(3.11,-2.46) F9(3.76,-2.46) F11(4.41,-2.46) F12(5.06,-2.46) F13(5.71,-2.46) F15(6.36,-2.46) F16(7.01,-2.46) F18(7.66,-2.46) F19(8.31,-2.46) F20(8.96,-2.46) F22(9.66,-2.3) G2(0.46,-2.76) G22(9.66,-2.76) H2(0.46,-3.22) H4(1.16,-3.11) H5(1.81,-3.11) H6(2.46,-3.11) H8(3.11,-3.11) H9(3.76,-3.11) H11(4.41,-3.11) H12(5.06,-3.11) H13(5.71,-3.11) H15(6.36,-3.11) H16(7.01,-3.11) H18(7.66,-3.11) H19(8.31,-3.11) H20(8.96,-3.11) H22(9.66,-3.22) J2(0.46,-3.68) J4(1.16,-3.76) J5(1.81,-3.76) J6(2.46,-3.76) J8(3.11,-3.76) J9(3.76,-3.76) J11(4.41,-3.76) J12(5.06,-3.76) J13(5.71,-3.76) J15(6.36,-3.76) J16(7.01,-3.76) J18(7.66,-3.76) J19(8.31,-3.76) J20(8.96,-3.76) J22(9.66,-3.68) K2(0.46,-4.14) K22(9.66,-4.14) L2(0.46,-4.6) L4(1.16,-4.41) L5(1.81,-4.41) L6(2.46,-4.41) L8(3.11,-4.41) L9(3.76,-4.41) L11(4.41,-4.41) L12(5.06,-4.41) L13(5.71,-4.41) L15(6.36,-4.41) L16(7.01,-4.41) L18(7.66,-4.41) L19(8.31,-4.41) L20(8.96,-4.41) L22(9.66,-4.6) M2(0.46,-5.06) M4(1.16,-5.06) M5(1.81,-5.06) M6(2.46,-5.06) M8(3.11,-5.06) M9(3.76,-5.06) M11(4.41,-5.06) M12(5.06,-5.06) M13(5.71,-5.06) M15(6.36,-5.06) M16(7.01,-5.06) M18(7.66,-5.06) M19(8.31,-5.06) M20(8.96,-5.06) M22(9.66,-5.06) N2(0.46,-5.52) N4(1.16,-5.71) N5(1.81,-5.71) N6(2.46,-5.71) N8(3.11,-5.71) N9(3.76,-5.71) N11(4.41,-5.71) N12(5.06,-5.71) N13(5.71,-5.71) N15(6.36,-5.71) N16(7.01,-5.71) N18(7.66,-5.71) N19(8.31,-5.71) N20(8.96,-5.71) N22(9.66,-5.52) P2(0.46,-5.98) P22(9.66,-5.98) R2(0.46,-6.44) R4(1.16,-6.36) R5(1.81,-6.36) R6(2.46,-6.36) R8(3.11,-6.36) R9(3.76,-6.36) R11(4.41,-6.36) R12(5.06,-6.36) R13(5.71,-6.36) R15(6.36,-6.36) R16(7.01,-6.36) R18(7.66,-6.36) R19(8.31,-6.36) R20(8.96,-6.36) R22(9.66,-6.44) T2(0.46,-6.9) T4(1.16,-7.01) T5(1.81,-7.01) T6(2.46,-7.01) T8(3.11,-7.01) T9(3.76,-7.01) T11(4.41,-7.01) T12(5.06,-7.01) T13(5.71,-7.01) T15(6.36,-7.01) T16(7.01,-7.01) T18(7.66,-7.01) T19(8.31,-7.01) T20(8.96,-7.01) T22(9.66,-6.9) U2(0.46,-7.36) U22(9.66,-7.36) V2(0.46,-7.82) V4(1.16,-7.66) V5(1.81,-7.66) V6(2.46,-7.66) V8(3.11,-7.66) V9(3.76,-7.66) V11(4.41,-7.66) V12(5.06,-7.66) V13(5.71,-7.66) V15(6.36,-7.66) V16(7.01,-7.66) V18(7.66,-7.66) V19(8.31,-7.66) V20(8.96,-7.66) V22(9.66,-7.82) W2(0.46,-8.28) W4(1.16,-8.31) W5(1.81,-8.31) W6(2.46,-8.31) W8(3.11,-8.31) W9(3.76,-8.31) W11(4.41,-8.31) W12(5.06,-8.31) W13(5.71,-8.31) W15(6.36,-8.31) W16(7.01,-8.31) W18(7.66,-8.31) W19(8.31,-8.31) W20(8.96,-8.31) W22(9.66,-8.28) Y2(0.46,-8.74) Y4(1.16,-8.96) Y5(1.81,-8.96) Y6(2.46,-8.96) Y8(3.11,-8.96) Y9(3.76,-8.96) Y11(4.41,-8.96) Y12(5.06,-8.96) Y13(5.71,-8.96) Y15(6.36,-8.96) Y16(7.01,-8.96) Y18(7.66,-8.96) Y19(8.31,-8.96) Y20(8.96,-8.96) Y22(9.66,-8.74)
  oval 0.178x0.33 smd: A2(0.46,0) A3(0.92,0) A4(1.38,0) A5(1.84,0) A6(2.3,0) A7(2.76,0) A8(3.22,0) A9(3.68,0) A10(4.14,0) A11(4.6,0) A12(5.06,0) A13(5.52,0) A14(5.98,0) A15(6.44,0) A16(6.9,0) A17(7.36,0) A18(7.82,0) A19(8.28,0) A20(8.74,0) A21(9.2,0) A22(9.66,0) AC2(0.46,-10.12) AC3(0.92,-10.12) AC4(1.38,-10.12) AC5(1.84,-10.12) AC6(2.3,-10.12) AC7(2.76,-10.12) AC8(3.22,-10.12) AC9(3.68,-10.12) AC10(4.14,-10.12) AC11(4.6,-10.12) AC12(5.06,-10.12) AC13(5.52,-10.12) AC14(5.98,-10.12) AC15(6.44,-10.12) AC16(6.9,-10.12) AC17(7.36,-10.12) AC18(7.82,-10.12) AC19(8.28,-10.12) AC20(8.74,-10.12) AC21(9.2,-10.12) AC22(9.66,-10.12)
  oval 0.33x0.178 smd: AA1(0,-9.2) AA23(10.12,-9.2) AB1(0,-9.66) AB23(10.12,-9.66) B1(0,-0.46) B23(10.12,-0.46) C1(0,-0.92) C23(10.12,-0.92) D1(0,-1.38) D23(10.12,-1.38) E1(0,-1.84) E23(10.12,-1.84) F1(0,-2.3) F23(10.12,-2.3) G1(0,-2.76) G23(10.12,-2.76) H1(0,-3.22) H23(10.12,-3.22) J1(0,-3.68) J23(10.12,-3.68) K1(0,-4.14) K23(10.12,-4.14) L1(0,-4.6) L23(10.12,-4.6) M1(0,-5.06) M23(10.12,-5.06) N1(0,-5.52) N23(10.12,-5.52) P1(0,-5.98) P23(10.12,-5.98) R1(0,-6.44) R23(10.12,-6.44) T1(0,-6.9) T23(10.12,-6.9) U1(0,-7.36) U23(10.12,-7.36) V1(0,-7.82) V23(10.12,-7.82) W1(0,-8.28) W23(10.12,-8.28) Y1(0,-8.74) Y23(10.12,-8.74)
AO3413_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.248)
AON7934_DFN3X3A8-10
  oval 0.457x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.76) 6(1.3,2.76) 7(0.65,2.76) 8(0,2.76)
  rect 2.54x1.041 smd: 9(0.975,1.813)
  rect 2.54x0.559 smd: 10(0.975,0.708)
AOZ5019QI_QFN23_5X3P5
  oval 0.254x0.559 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0)
  rect 2.972x1.524 smd: 6(1.375,1.235)
  custom 0.588x0.588 smd: 7(1.005,2.325)
  rect 1.956x0.686 smd: 8(1.255,4.587)
  oval 0.559x0.254 smd: 9(-0.57,2.825) 10(-0.57,1.825) 11(-0.57,1.325) 12(-0.57,0.825) 13(-0.57,0.325)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.406x1.549 smd: 3(1,0.437)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAS40-04_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54CW_SOT323-3
  oval 0.61x0.559 smd: 1(0,0) 2(-0.65,-1.85) 3(0.65,-1.85)
BELLW_SD-80886-1021_260P-T
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 3.505x4.597 smd: 261(0.425,7.9) 262(-67.175,7.9)
BQ24777RUYR_WQFN28_4X4
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D
  rect 2.388x2.896 smd: 1(0,0) 2(6.1,0)
C_D1
  rect 1.803x2.794 smd: 1(0,0) 2(6.5,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
CHILI_CMMI21T-900Y-N_4P
  rect 0.356x0.889 smd: 1(0,0) 2(0,1.7) 3(0.85,1.7) 4(0.85,0)
CHILI_PBY160808T-300Y-N_2P
  rect 0.559x1.041 smd: 1(0,0) 2(1.3,0)
CLIP_C5P5
  round 5.512 smd: 1(0,0)
CLIP_C6
  round 5.994 smd: 1(0,0)
COILC_XFL4012-601MEC_2P
  rect 0.991x3.404 smd: 1(0,0) 2(2.37,0)
CONCR_213AAAA32FA_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(3.75,-7.55) 9(4,0) 10(4.25,-7.55) 11(4.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
CONCR_213MAAA32FA_67P-T
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(1.75,-7.55) 9(2,0) 10(2.25,-7.55) 11(2.5,0) 12(2.75,-7.55) 13(3,0) 14(3.25,-7.55) 15(3.5,0) 16(3.75,-7.55) 17(4,0) 18(4.25,-7.55) 19(4.5,0) 20(4.75,-7.55) 21(5,0) 22(5.25,-7.55) 23(5.5,0) 24(5.75,-7.55) 25(6,0) 26(6.25,-7.55) 27(6.5,0) 28(6.75,-7.55) 29(7,0) 30(7.25,-7.55) 31(7.5,0) 32(7.75,-7.55) 33(8,0) 34(8.25,-7.55) 35(8.5,0) 36(8.75,-7.55) 37(9,0) 38(9.25,-7.55) 39(9.5,0) 40(9.75,-7.55) 41(10,0) 42(10.25,-7.55) 43(10.5,0) 44(10.75,-7.55) 45(11,0) 46(11.25,-7.55) 47(11.5,0) 48(11.75,-7.55) 49(12,0) 50(12.25,-7.55) 51(12.5,0) 52(12.75,-7.55) 53(13,0) 54(13.25,-7.55) 55(13.5,0) 56(13.75,-7.55) 57(14,0) 58(14.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
CSD87351Q5D_SON8-7
  oval 1.93x0.838 smd: 1(0,0)
  oval 0.66x0.838 smd: 2(1.905,0) 3(3.175,0) 4(3.175,5.39) 5(1.905,5.39) 6(0.635,5.39) 7(-0.635,5.39)
  custom 0.87x0.87 smd: 8(1.27,2.695)
CYNTE_PCMB053T-R47MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PIMB104T-3R3MS_2P
  rect 4.089x4.089 smd: 1(0,0) 2(9.5,0)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_1133K-R30C-01L_30P
  round 0.787 hole 0.787 unplated: (-2,-0.975) (13.2,-0.975)
  oval 0.305x1.346 smd: 1(0,0) 2(0,-5.35) 3(0.8,0) 4(0.8,-5.35) 5(1.6,0) 6(1.6,-5.35) 7(2.4,0) 8(2.4,-5.35) 9(3.2,0) 10(3.2,-5.35) 11(4,0) 12(4,-5.35) 13(4.8,0) 14(4.8,-5.35) 15(5.6,0) 16(5.6,-5.35) 17(6.4,0) 18(6.4,-5.35) 19(7.2,0) 20(7.2,-5.35) 21(8,0) 22(8,-5.35) 23(8.8,0) 24(8.8,-5.35) 25(9.6,0) 26(9.6,-5.35) 27(10.4,0) 28(10.4,-5.35) 29(11.2,0) 30(11.2,-5.35)
  custom 0.298x0.298 smd: 31(-2.1,0.075) 36(13.3,0.075)
  rect 1.803x2.007 smd: 32(-2.1,-2.675) 35(13.3,-2.675)
  rect 1.803x1.194 smd: 33(-2.1,-5.425) 34(13.3,-5.425)
E-T_3806K-F02N-03R_2P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0)
  rect 1.295x3.353 smd: 3(-2.85,-4.875) 4(4.1,-4.875)
E-T_6710K-Y15M-31L_15P
  oval 0.305x0.965 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0)
  rect 0.305x1.143 smd: 16(7.885,-2.965) 17(-0.885,-2.965)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
EMIST_SUL-12A2M_1P
  rect 6.909x1.194 smd: 1(0,0)
ESD108-B1-CSP0201_WLL-2-1-2
  rect 0.279x0.381 smd: 1(0,0) 2(0.38,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G5616ARZ1U_TQFN20_3X3
  oval 0.203x1.016 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,2.975) 12(1.2,2.975) 13(0.8,2.975) 14(0.4,2.975) 15(0,2.975)
  oval 1.016x0.203 smd: 6(2.288,0.688) 7(2.288,1.088) 8(2.288,1.488) 9(2.288,1.888) 10(2.288,2.288) 16(-0.688,2.288) 17(-0.688,1.888) 18(-0.688,1.488) 19(-0.688,1.088) 20(-0.688,0.688)
  rect 1.6x1.6 smd: 21(0.8,1.488)
G9141T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H_2P1N
  round 2.108 hole 2.108 unplated: (0,0)
H_2P1X2P5N
  oval 2.108x2.489 hole 2.108x2.489 unplated: (0,0)
H_2P3
  round 2.819 hole 2.311: 1(0,0)
H_2P5
  round 2.997 hole 2.489: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_2P9X2P1N
  oval 2.896x2.108 hole 2.896x2.108 unplated: (0,0)
H_3P0
  round 3.505 hole 2.997: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P9
  round 4.42 hole 3.912: 1(0,0)
H_4P1
  round 4.597 hole 4.089: 1(0,0)
H_6P0N
  round 5.994 hole 5.994 unplated: (0,0)
HB_A531015-SCHR21_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(6.6,-3.05) 12(-2.1,-3.05)
INA199A1DCKR_SC70-6
  oval 0.406x0.889 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,2.2) 5(0.65,2.2) 6(0,2.2)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
IP4223CZ6_SO6-6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
ISL95808HRZ-TS2378_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.549x0.889 smd: 9(0.75,1.1)
ISL95855HRTZ-T_TQFN48_6X6
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
J-L_UCNR2234B020-0_20P
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0)
  rect 1.194x2.692 smd: 21(-2.4,1.95) 22(11.9,1.95)
  rect 2.311x1.295 smd: 23(0.85,3.9) 24(8.65,3.9)
JAE_DX07S024XJ2_24P-T
  round 0.762 hole 0.762 unplated: (-0.85,-0.66)
  oval 0.94x0.762 hole 0.94x0.762 unplated: (6.35,-0.66)
  oval 1.092x2.108 hole 0.61x1.6: 1(-1.85,-5.06) 2(-1.85,-2.06) 3(7.35,-5.06) 4(7.35,-2.06)
  oval 0.305x1.092 smd: A1(0,0) A2(0.5,0) A3(1,0) A4(1.5,0) A5(2,0) A6(2.5,0) A7(3,0) A8(3.5,0) A9(4,0) A10(4.5,0) A11(5,0) A12(5.5,0)
  round 0.66 hole 0.406: B1(5.55,-1.31) B2(5.15,-2.01) B3(4.35,-2.01) B4(3.95,-1.31) B5(3.55,-2.01) B6(3.15,-1.31) B7(2.35,-1.31) B8(1.95,-2.01) B9(1.55,-1.31) B10(1.15,-2.01) B11(0.35,-2.01) B12(-0.05,-1.31)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
K4G41325FC-HC04_FBGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
