# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMI_CRX_PTX_P2: length 128.1
  IN3 w0.099: v2(182.58,53.53) 182.39,53.72 182.39,54.38 183.19,55.18 183.19,57.26 180.64,59.81 178.21,62.24 176.51,62.24 176.26,62.48 176.26,62.67 v2(176.44,62.85)
  BOTTOM w0.076: v2(176.44,62.85) 176.13,62.54 UH1.D5
  BOTTOM w0.089: 85.87,28.37 85.9,28.34 85.9,26.42 85.79,26.31 85.79,25.54 85.89,25.43 85.89,25.21 85.64,24.95 UH2.C29
  BOTTOM w0.152: v2(182.58,53.53) 182.45,53.4 182.45,52.86 181.8,52.21 179.06,52.21 174.37,47.52 174.37,45.8 169.29,40.73 119.92,40.73 109.34,30.15 93.68,30.15 92.46,31.38 87.67,31.38 85.87,29.58 85.87,28.37
DMI_CRX_PTX_P3: length 131.7
  IN3 w0.099: v2(173.86,64.45) 173.8,64.5 173.8,64.7 173.91,64.8 174.14,64.8 174.32,64.62 174.32,62.01 175.08,61.25 175.08,60.39 175.86,59.61 178.9,59.61 181.76,56.75 181.76,56.24 182.08,55.93 182.08,55.77 181.9,55.6 v2(181.78,55.6)
  BOTTOM w0.076: v2(173.86,64.45) 173.54,64.45 UH1.J8
  BOTTOM w0.089: UH2.A30 84.96,25.75 84.89,25.82 84.89,25.93 84.96,26.01 85.1,26.01 85.17,26.07 85.17,27.06 85.17,27.17 85.17,27.17 85.17,27.39 85.17,27.69 85.09,27.76 85.09,27.85 84.69,28.25 84.66,28.25 84.49,28.42 84.49,28.5 84.45,28.53 84.45,28.54
  BOTTOM w0.152: 84.45,28.54 84.45,30.3 86.92,32.76 93.26,32.76 94.75,31.27 108.53,31.27 119.39,42.13 168.79,42.13 172.98,46.33 172.98,47.71 178.59,53.32 180.39,53.32 182.16,55.09 182.16,55.3 182.06,55.41 182.06,55.52 181.94,55.63 181.81,55.63 v2(181.78,55.6)
DMI_CTX_PRX_N0: length 130
  IN2 w0.107: v2(103.95,32.27) 104.14,32.08 104.14,31.79 103.6,31.25 103.15,31.25 101,29.09 91.2,29.09 89.05,26.94 89.05,23.68 88.51,23.14 88.51,22.28 87.09,20.87 86.22,20.87 86.12,20.96 86.12,21.09 86.3,21.27 v2(86.3,21.29)
  BOTTOM w0.076: UH1.A8 178.08,63.96 178.04,63.92 177.82,63.92 177.77,63.97 177.77,64.07 177.72,64.12 177.72,64.27 177.85,64.4 178.11,64.4 178.2,64.31 178.39,64.31 178.48,64.4 179.29,64.4 179.48,64.21 179.75,64.21 179.8,64.16 179.93,64.16
  BOTTOM w0.152: UH2.L27 86.75,21.02 86.48,21.29 v2(86.3,21.29) ; v2(103.95,32.27) 104.01,32.33 104.01,32.84 104.12,32.94 104.12,33.53 103.44,34.2 103.44,36.75 104.81,38.12 105.57,38.12 107.05,39.59 115.26,39.59 118.93,43.27 168.41,43.27 172.13,46.98 172.13,48 178.23,54.11 179.16,54.11 181.37,56.32 181.37,62.95 180.16,64.16 179.93,64.16
DMI_CTX_PRX_N1: length 124.2
  IN2 w0.107: v2(102.5,32.93) 102.72,32.71 102.72,31.9 100.7,29.88 90.68,29.88 87.89,27.08 87.89,23.35 87.67,23.14 87.34,23.14 87.24,23.24 87.24,23.42 v2(87.33,23.51)
  BOTTOM w0.076: UH1.B6 177.43,63.11 177.39,63.06 177.11,63.06 177.06,63.12 177.06,63.46 177.18,63.59 178.25,63.59 178.41,63.43 178.62,63.43 178.72,63.53 178.9,63.53 178.99,63.45 179.15,63.45
  BOTTOM w0.101: UH2.E24 v2(87.33,23.51)
  BOTTOM w0.152: v2(102.5,32.93) 102.66,33.08 102.66,37.22 105.94,40.51 115.02,40.51 118.72,44.22 161.86,44.22 167.64,50 173,50 177.9,54.9 178.83,54.9 180.39,56.46 180.39,62.28 179.4,63.28 179.23,63.45 179.15,63.45
DMI_CTX_PRX_N2: length 123
  IN2 w0.107: v2(86.29,22.75) 86.29,22.9 86.41,23.02 86.63,23.02 86.91,23.3 86.91,25.42 87.08,25.6 87.08,27.03 90.5,30.45 100.55,30.45 101.64,31.54 101.64,32.15 100.98,32.81 100.98,33.32 101.11,33.45 101.25,33.45 v2(101.45,33.24)
  BOTTOM w0.076: UH1.A5 178.08,62.62 178.2,62.75 178.35,62.75 178.42,62.68 178.42,62.43 178.47,62.38 178.63,62.38 178.69,62.44 178.69,62.65 178.76,62.72 178.89,62.72 179.07,62.54 179.07,62.29 179.08,62.28
  BOTTOM w0.101: UH2.G27 v2(86.29,22.75)
  BOTTOM w0.152: 179.08,62.28 179.44,61.92 179.44,56.62 178.5,55.69 177.57,55.69 172.9,51.01 167.25,51.01 161.34,45.11 118.32,45.11 114.55,41.33 105.53,41.33 100.71,36.52 100.71,33.73 100.84,33.6 100.95,33.49 101.2,33.24 v2(101.45,33.24)
DMI_CTX_PRX_N3: length 125.7
  IN2 w0.107: v2(85.02,20.53) 84.83,20.72 84.63,20.72 84.39,20.95 84.39,22.78 84.05,23.12 84.05,24.74 84.59,25.28 84.98,25.28 85.95,26.26 85.95,27.27 90.12,31.44 100.17,31.44 100.33,31.6 100.33,31.81 v2(100.18,31.96)
  BOTTOM w0.076: UH1.B4 177.05,61.83 176.91,61.83 176.79,61.72 176.79,61.54 176.91,61.43 177.25,61.43 177.31,61.49 177.51,61.49 177.58,61.57 177.58,61.95 177.67,62.04 178.25,62.04 178.53,61.76 178.54,61.74 178.61,61.68
  BOTTOM w0.089: v2(85.02,20.53) 85.31,20.82 UH2.L29
  BOTTOM w0.152: 178.61,61.68 178.61,57.03 178.05,56.47 177.18,56.47 172.67,51.96 166.91,51.96 161,46.06 117.85,46.06 114.09,42.3 105.03,42.3 99.79,37.06 99.79,33.36 100.36,32.79 100.36,32.14 v2(100.18,31.96)
DMI_CTX_PRX_P0: length 129.9
  IN2 w0.107: v2(86.3,20.47) 86.5,20.66 87.17,20.66 88.71,22.2 88.71,23.06 89.25,23.6 89.25,26.86 91.28,28.89 101.08,28.89 103.24,31.05 103.68,31.05 104.34,31.71 104.34,32.15 104.45,32.25 v2(104.55,32.25)
  BOTTOM w0.076: UH1.B8 177.49,64.11 177.49,64.3 177.62,64.42 177.62,64.42 177.76,64.56 179.44,64.56 179.53,64.47 179.89,64.47 179.92,64.49 179.93,64.49
  BOTTOM w0.152: UH2.N27 86.71,20.06 v2(86.3,20.47) ; 179.93,64.49 180.3,64.49 181.7,63.09 181.7,56.18 179.3,53.78 178.37,53.78 172.46,47.87 172.46,46.84 168.55,42.93 119.07,42.93 115.4,39.26 107.19,39.26 105.71,37.79 104.95,37.79 103.77,36.61 103.77,34.34 104.45,33.66 104.45,32.77 104.4,32.72 104.4,32.4 104.54,32.25 v2(104.55,32.25)
DMI_CTX_PRX_P1: length 124.1
  IN2 w0.107: v2(103.09,32.93) 102.93,32.77 102.93,31.81 100.79,29.68 90.77,29.68 88.09,27 88.09,23.26 87.76,22.93 87.51,22.93 v2(87.33,22.75)
  BOTTOM w0.076: 179.63,63.51 179.61,63.53 179.55,63.53 179.32,63.75 177.09,63.75 176.88,63.54 176.88,63.37 UH1.C6
  BOTTOM w0.101: UH2.G24 v2(87.33,22.75)
  BOTTOM w0.152: 179.63,63.51 179.63,63.51 180.72,62.42 180.72,56.32 178.97,54.57 178.04,54.57 173.14,49.67 167.78,49.67 162,43.89 118.86,43.89 115.15,40.18 106.08,40.18 102.99,37.08 102.99,33.03 v2(103.09,32.93)
DMI_CTX_PRX_P2: length 123.1
  IN2 w0.107: v2(101.45,33.83) 101.45,33.83 101.27,33.65 101.02,33.65 100.78,33.41 100.78,32.72 101.44,32.06 101.44,31.63 100.46,30.65 90.42,30.65 86.88,27.12 86.88,25.68 86.7,25.51 86.7,23.39 86.54,23.22 86.39,23.22 86.29,23.32 v2(86.29,23.51)
  BOTTOM w0.076: UH1.B5 177.6,62.48 177.72,62.59 178.1,62.98 178.93,62.98 179.31,62.6
  BOTTOM w0.101: UH2.E26 v2(86.29,23.51)
  BOTTOM w0.152: v2(101.45,33.83) 101.35,33.73 101.18,33.73 101.07,33.84 101.04,33.87 101.04,36.38 105.66,41 114.68,41 118.45,44.78 161.48,44.78 167.38,50.68 173.04,50.68 177.71,55.36 178.64,55.36 179.77,56.49 179.77,62.06 179.31,62.52 179.31,62.6
DMI_CTX_PRX_P3: length 125.8
  IN2 w0.107: v2(85.02,21.29) 85.16,21.15 85.16,21.01 85.07,20.92 84.71,20.92 84.6,21.04 84.6,22.86 84.25,23.21 84.25,24.66 84.67,25.08 85.07,25.08 86.16,26.17 86.16,27.19 90.21,31.24 100.25,31.24 100.53,31.52 100.53,31.73 v2(100.76,31.96)
  BOTTOM w0.076: UH1.D4 176.9,62.1 177.44,62.1 177.54,62.2 178.42,62.2 178.71,61.91 178.72,61.92 178.75,61.95 178.9,61.8 178.9,61.73 178.94,61.69 178.94,61.68
  BOTTOM w0.089: UH2.K29 85.31,21.58 v2(85.02,21.29)
  BOTTOM w0.152: 178.94,61.68 178.94,56.9 178.18,56.14 177.32,56.14 172.81,51.63 167.04,51.63 161.14,45.73 117.98,45.73 114.22,41.97 105.17,41.97 100.12,36.92 100.12,33.49 100.69,32.93 100.69,32.04 v2(100.76,31.96)
DMIC_CLK_CODEC: length 181.3
  TOP w0.14: v3(10.54,9.99) 10.67,10.12 v2(10.67,10.49) 10.67,10.73 10.94,10.99 11.95,10.99 DE9.2 12.14,11.63 11.61,12.16 11.61,13.08 10.99,13.69 10.7,13.69 10.4,13.99 JAUDIO.18
  IN1 w0.099: v2(151.89,9.47) 151.06,9.47 149.42,11.11 145.04,11.11 144.58,11.57 129.73,11.57 128.79,12.5 110.22,12.5 109.41,13.31 108.58,13.31 107.77,12.5 103.07,12.5 102.12,11.55 101.6,11.55 100.95,10.89 98.14,10.89 97.47,11.56 95.34,11.56 94.99,11.91 91.97,11.91 91.39,11.33 88.3,11.33 87.57,10.59 86.93,10.59 86.62,10.91 84.47,10.91 83.58,10.02 79.8,10.02 79.68,9.9 78.25,9.9 78.13,9.79 78.12,9.79 78.11,9.78 75.85,9.78 75.62,10.01 72.15,10.01 71.76,10.4 69.88,10.4 69.8,10.47 68.33,10.47 68.24,10.56 65,10.56 64.04,11.52 61.68,11.52 59.82,9.66 55.3,9.66 v2(54.88,10.08)
  IN2 w0.099: v2(10.67,10.49) 11.05,10.11 11.49,10.11 12.06,10.67 12.06,12.59 15.68,16.2 19.18,16.2 21.15,18.17 21.15,18.93 21.68,19.46 22.54,19.46 22.97,19.89 22.97,20.38 23.9,21.31 26.21,21.31 28.06,23.16 28.06,24.34 29.44,25.72 30.95,25.72 31.59,25.08 33.98,25.08 35.61,26.7 41.42,26.7 42.08,26.04 45.06,26.04 46.65,24.45 50.67,24.45 51.46,23.65 52.84,23.65 55.13,21.36 55.13,19.71 56.66,18.18 56.66,15.65 56.42,15.41 56.42,13.01 54.7,11.29 54.7,10.26 v2(54.88,10.08)
  BOTTOM w0.14: v2(151.89,9.47) 153.21,8.15 RE116.1
DMIC_CLK_CODEC_C: length 5.4
  BOTTOM w0.14: JKB.12 157.77,9.31 157.48,9.03 CE73.1 RE116.2
DMIC_DAT_CODEC: length 177.3
  TOP w0.14: v3(12.57,9.85) 12,9.85 v2(11.3,10.55) 12.51,10.55 DE9.3 12.92,11.18 11.85,12.26 11.85,13.18 11.2,13.83 JAUDIO.20
  IN1 w0.099: v2(55.89,10.23) 56.16,9.96 59.84,9.96 61.6,11.72 67.8,11.72 68.74,10.78 70,10.78 70.17,10.61 72.62,10.61 73.02,10.21 75.71,10.21 75.93,9.98 78.06,9.98 78.27,10.19 78.59,10.19 79.3,10.91 83.88,10.91 84.49,11.51 91.31,11.51 91.89,12.09 95.07,12.09 95.42,11.75 97.55,11.75 98.22,11.08 100.87,11.08 101.54,11.75 102.01,11.75 103.01,12.75 107.73,12.75 108.5,13.51 109.5,13.51 110.27,12.75 128.83,12.75 129.74,11.85 144.59,11.85 144.87,11.57 v2(148.27,11.57)
  IN2 w0.099: v2(55.89,10.23) 55.94,10.28 55.94,12.25 56.62,12.93 56.62,15.33 56.86,15.57 56.86,18.26 55.33,19.8 55.33,21.45 52.92,23.85 51.58,23.85 50.79,24.65 46.73,24.65 45.14,26.24 42.17,26.24 41.5,26.91 35.53,26.91 33.9,25.28 31.75,25.28 31.11,25.92 29.36,25.92 27.66,24.23 27.66,23.04 26.12,21.51 23.44,21.51 20.95,19.02 20.95,18.25 19.14,16.45 15.64,16.45 11.81,12.62 11.81,11.06 v2(11.3,10.55)
  BOTTOM w0.14: v2(148.27,11.57) 148.27,11.56 152.13,11.56 152.24,11.45 RE117.1
DMIC_DAT_CODEC_C: length 6.1
  BOTTOM w0.14: JKB.11 158.27,10.84 157.55,11.56 155.56,11.56 v1(155.47,11.48) 154.81,10.82 CE74.1 153.73,11.45 RE117.2
DOCK_TNY_SMB_CLK: length 333.8
  TOP w0.14: UV17.2 65.32,25.1 65.52,24.89 66.01,24.89 66.75,25.64 66.75,26.43 v2(66.58,26.6) ; v2(296.95,5.76) 296.95,5.62 RE109.1 ; v2(165.94,16.87) v1(165.31,17.5)
  IN2 w0.089: 33.03,34.3 33.02,34.31 33.02,34.32 32.89,34.45 31.25,34.45 30.11,35.6 22.65,35.6 21.76,34.71 20.58,34.71
  IN2 w0.099: 20.58,34.71 20.27,34.71 18.86,33.29 18.86,32.79 18.12,32.05 15.22,32.05 14.47,31.3 13.02,31.3 12.79,31.53 12.79,31.75 v2(12.62,31.91) ; v2(131.35,31.99) 131.35,32 131.35,32.26 131.3,32.31 114.38,32.31 111.47,35.22 100.04,35.22 97.9,33.08 88.87,33.08 84.93,29.14 83.13,29.14 82.76,28.77 74.36,28.77 71.5,25.92 67.05,25.92 66.77,26.19 66.77,26.41 v2(66.58,26.6) 66.77,26.79 66.77,26.91 66.67,27.01 59.98,27.01 58.66,28.33 58.66,28.81 57.95,29.52 48.22,29.52 45.8,31.94 40.94,31.94 38.9,33.98 33.35,33.98 33.03,34.3
  IN3 w0.091: v2(165.94,16.87) 164.08,18.74 133.86,18.74 133.08,19.52 133.08,30.59 131.68,31.99 v2(131.35,31.99)
  IN6 w0.099: v2(279.27,18.51) 278.41,18.51 276.79,16.89 269.36,16.89 266.81,14.34 240.18,14.34 237.5,17.01 237.5,17.64 235.98,19.16 185.8,19.16 184.86,18.22 166.73,18.22 166.13,17.62 166.13,17.06 v2(165.94,16.87)
  BOTTOM w0.14: RT184.1 12.83,32.27 12.83,32.11 v2(12.62,31.91) ; v2(279.27,18.51) 279.27,18.46 280.43,17.31 280.43,9.59 280.63,9.39 280.63,8.33 280.5,8.2 280.5,7.32 281.4,6.42 283.9,6.42 285.22,5.1 289.59,5.1 290.81,6.32 296.39,6.32 v2(296.95,5.76)
DOCK_TNY_SMB_DAT: length 335.2
  TOP w0.14: v2(67.16,26.6) 66.99,26.43 66.99,25.54 66.11,24.65 65.52,24.65 65.32,24.45 UV17.3 ; RE108.1 297.55,5.91 v2(297.55,5.76) ; v2(166.52,16.91) v1(167.11,17.5)
  IN2 w0.089: 33.18,34.44 33.16,34.46 33.15,34.46 32.97,34.64 31.33,34.64 30.19,35.79 22.57,35.79 21.68,34.9 20.66,34.9 20.66,34.9 20.6,34.9 20.59,34.91 20.58,34.91
  IN2 w0.099: 20.58,34.91 20.19,34.91 18.66,33.37 18.66,32.87 18.04,32.25 15.13,32.25 14.38,31.5 13.1,31.5 12.99,31.62 12.99,31.69 v2(13.21,31.91) ; 33.18,34.44 33.44,34.18 38.98,34.18 41.02,32.14 45.89,32.14 48.3,29.72 58.04,29.72 58.86,28.9 58.86,28.41 60.06,27.21 66.75,27.21 66.97,26.99 66.97,26.79 v2(67.16,26.6) 66.97,26.41 66.97,26.27 67.13,26.12 71.42,26.12 74.28,28.98 82.68,28.98 83.04,29.34 84.84,29.34 88.79,33.28 97.82,33.28 99.96,35.42 111.55,35.42 114.46,32.51 131.39,32.51 131.53,32.37 v2(131.88,32.37)
  IN3 w0.091: v2(166.52,16.91) 166.47,16.91 164.45,18.93 133.94,18.93 133.27,19.6 133.27,30.67 131.88,32.07 v2(131.88,32.37)
  IN6 w0.099: v2(279.99,18.58) 279.33,17.92 278.14,17.92 276.89,16.66 269.45,16.66 266.9,14.11 240.08,14.11 237.28,16.92 237.28,17.54 235.88,18.93 185.85,18.93 184.94,18.02 166.82,18.02 166.33,17.53 166.33,17.11 v2(166.52,16.91)
  BOTTOM w0.14: RT185.1 13.08,32.17 13.08,32.04 v2(13.21,31.91) ; v2(279.99,18.58) 279.99,18.09 280.67,17.41 280.67,9.69 280.87,9.49 280.87,8.23 280.74,8.1 280.74,7.42 281.5,6.66 284,6.66 285.32,5.34 289.49,5.34 290.71,6.56 296.75,6.56 v2(297.55,5.76)
EC_PECI: length 4.6
  TOP w0.14: RE48.1 CE39.1 293.68,22.97 v3(293.68,22.04) 294.16,21.56 294.84,21.56 295.27,21.13 UE3.A48
EC_SLP_S0IX#: length 267.9
  TOP w0.089: v2(88.7,2.52) 89.09,2.14 89.63,2.14 89.87,2.38 89.87,3.33 90.58,4.04 90.58,4.68 90.47,4.79 89.42,4.79 89.21,5 89.21,5.51 89.42,5.72 90,5.72 90.34,6.06 90.34,11.18 89.75,11.77 85.64,11.77 85.31,12.1 85.31,14.88 83.55,16.63 81.01,16.63 80.7,16.95 v2(80.7,17.16) 80.7,18.74 80.32,19.12 v1(77.99,19.12) 77.69,19.42 77.02,19.42 RH535.1
  TOP w0.14: UE3.A43 297.77,21.23 297.85,21.3 297.85,21.73 v2(298.27,22.16)
  IN6 w0.089: 101.98,14.21 101.87,14.21 101.18,14.89 98.78,14.89 97.92,15.76 91.83,15.76 90.87,16.72 90.87,18.36 90.31,18.92 90.31,19.07 90.04,19.34 89.18,19.34 88.82,18.98 85.19,18.98 83.73,17.52 81.06,17.52 v2(80.7,17.16)
  IN6 w0.099: v2(298.27,22.16) 297.83,21.71 297.83,21.48 297.59,21.24 296.98,21.24 296.82,21.41 294.45,21.41 293.81,20.76 293.81,19.88 293.11,19.18 291.74,19.18 290.93,20 290.35,20 289.71,20.63 285.17,20.63 284.41,19.87 283.08,19.87 282.38,19.17 281.49,19.17 279.85,17.52 278.31,17.52 277.05,16.26 269.62,16.26 265.88,12.52 263.18,12.52 261.68,11.02 250.73,11.02 249.56,12.19 230.92,12.19 228.35,14.77 223.37,14.77 222.49,13.88 220.69,13.88 220.68,13.9 220.66,13.9 219.85,14.72 186.65,14.72 185.99,14.06 169.18,14.06 168.58,13.47 160.76,13.47 159.92,14.32 128.83,14.32 128.44,14.7 106.32,14.7 105.83,14.21 101.98,14.21
  BOTTOM w0.089: v2(88.7,2.52) 88.7,2.81 88.24,3.28 88.24,3.78 88.06,3.96 88.06,4.43 UH2.BD24
EC_SMB_CK2_PX: length 14.4
  TOP w0.102: RV325.2 212.08,61.77 v2(211.16,61.77)
  TOP w0.14: v2(211.16,61.77) 210.97,61.96 v3(210.97,62.29)
  BOTTOM w0.089: 214.29,62.97 214.35,63.03 214.35,64.16 214.7,64.5 214.7,65.9 UV1.T4
  BOTTOM w0.127: v2(211.16,61.77) 210.56,61.77 210.31,62.01 210.06,62.01 209.89,61.84 209.89,60.99 209.68,60.78 207.63,60.78 QV21.1
  BOTTOM w0.14: 214.29,62.97 214.16,62.84 213.45,62.84 212.97,62.35 211.75,62.35 v2(211.16,61.77)
EC_SMB_DA2_PX: length 16.4
  TOP w0.089: v2(213.11,63.35) 213.41,63.65 v3(213.41,63.78) 213.12,64.07 212.6,64.07 RV326.2
  BOTTOM w0.089: UV1.T3 213.98,65.08 213.38,65.08 213.11,64.81 v2(213.11,63.35) 212.73,62.97
  BOTTOM w0.127: QV21.4 204.99,59.05 204.73,59.32 204.73,60.87 206.59,62.73 208.51,62.73
  BOTTOM w0.14: 212.73,62.97 212.5,62.73 208.51,62.73
EDP_AUXN: length 185.3
  IN1 w0.107: v2(179.15,78.25) 179.15,78.13 179.27,78.01 179.44,78.01 179.56,78.13 179.56,78.6 180.15,79.19 180.15,80.61 181.04,81.5 181.04,89.88 177.72,93.2 171.24,93.2 170.76,93.68 157.71,93.68 156.49,92.47 135.36,92.47 131,88.11 129.92,88.11 129.1,87.28 129.1,81.14 127.4,79.44 127.4,71.99 124.54,69.12 124.54,68.38 120.82,64.66 120.82,63.77 117.92,60.87 117.92,56.38 115.91,54.37 115.91,45.75 111.51,41.35 103.46,41.35 96.82,34.72 87.66,34.72 85.18,32.24 82.23,32.24 79.87,29.88 76,29.88 68.81,22.69 62.63,22.69 61.79,21.85 61.79,21.69 v2(62.09,21.39)
  BOTTOM w0.076: UH1.B26 177.37,78.29 177.15,78.29 177.1,78.24 177.1,78.05 177.23,77.91 178.28,77.91 178.33,77.86 179.38,77.86 179.52,78 179.52,78.18 179.46,78.25 v2(179.15,78.25)
  BOTTOM w0.152: v2(62.09,21.39) 61.89,21.59 61.89,21.69 CV166.1
EDP_AUXN_C: length 1.7
  BOTTOM w0.152: CV166.2 62.04,23.14 62.04,24.13 RV528.1
EDP_AUXN_R: length 8.7
  BOTTOM w0.152: RV528.2 61.99,25.73 v4(61.99,26.55) 61.99,27.05 62.97,28.03 62.97,29.96 64.45,31.44 64.45,31.92 64.55,32.02 JEDP1.15
EDP_AUXP: length 185.3
  IN1 w0.107: v2(61.51,21.39) 61.58,21.47 61.58,21.94 62.54,22.9 68.73,22.9 75.91,30.08 79.79,30.08 82.15,32.44 85.09,32.44 87.57,34.92 96.74,34.92 103.37,41.56 111.42,41.56 115.7,45.84 115.7,54.46 117.72,56.47 117.72,60.96 120.62,63.86 120.62,64.75 124.33,68.46 124.33,69.21 127.2,72.08 127.2,79.53 128.89,81.22 128.89,87.37 129.84,88.31 130.92,88.31 135.28,92.67 156.41,92.67 157.63,93.89 170.84,93.89 171.32,93.4 177.8,93.4 181.24,89.96 181.24,81.41 180.35,80.53 180.35,79.11 179.77,78.52 179.77,78.37 v2(179.94,78.19)
  BOTTOM w0.076: v2(179.94,78.19) 179.78,78.03 179.78,77.89 179.49,77.61 178.33,77.61 178.2,77.73 177.18,77.73 176.93,77.97 176.93,78.07 UH1.C26
  BOTTOM w0.152: v2(61.51,21.39) 61.56,21.44 61.56,21.81 CV167.1
EDP_AUXP_C: length 1.8
  BOTTOM w0.152: RV529.1 61.71,24.08 61.71,23.31 CV167.2
EDP_AUXP_R: length 8.6
  BOTTOM w0.152: JEDP1.16 64.05,31.99 64.12,31.92 64.12,31.58 62.64,30.1 62.64,28.16 v4(62.29,27.82) 61.66,27.19 61.66,25.68 RV529.2
EDP_COMP: length 2.1
  TOP w0.254: v2(176.16,85.84) 176.12,85.88 176.12,86.32 v3(176.18,86.37) 176.2,86.39 RH30.1
  BOTTOM w0.305: v2(176.16,85.84) 176.1,85.78 UH1.D37
EDP_CTRL_EN: length 8.2
  TOP w0.14: v2(292.24,19.64) v3(291.76,19.16) 291.43,19.16 291.16,19.43 RE107.2 ; v2(295.87,18.13) 295.45,18.55 295.03,18.55 294.71,18.88 UE3.B53
  BOTTOM w0.14: v2(295.87,18.13) 295.39,18.61 293.05,18.61 292.24,19.43 v2(292.24,19.64)
EDP_CTRL_EN_C: length 241.6
  TOP w0.14: UV17.5 69.75,23.8 70.36,23.19 71.69,23.19 72.58,24.08 v2(72.58,28.6) ; RE107.1 292.09,21.04 v2(292.1,21.04)
  IN2 w0.099: v2(292.1,21.04) 291.88,20.83 284.31,20.83 282.74,19.25 281.24,19.25 280,18.01 278.31,18.01 277.62,17.32 269.92,17.32 268.76,18.48 264.86,18.48 264.64,18.26 261.51,18.26 259.98,16.72 254.52,16.72 253.07,15.28 247.85,15.28 247.05,16.08 181.1,16.08 180.3,16.88 175.72,16.88 175.32,17.28 172.97,17.28 172.73,17.52 158.19,17.52 154.46,21.25 154.46,23.73 152.99,25.21 145.59,25.21 144.19,26.61 115.15,26.61 112.23,29.52 102.4,29.52 101.08,28.2 94.83,28.2 v2(93.94,27.31)
  IN6 w0.089: v2(93.94,27.31) 93.93,27.31 ; 89.03,28.47 82.93,28.47
  IN6 w0.099: v2(72.58,28.6) 72.71,28.47 82.93,28.47 ; 89.03,28.47 92.77,28.47 93.61,27.63 93.93,27.31
EDP_DISP_UTIL: length 8.1
  BOTTOM w0.076: 177.92,85.38 177.74,85.2 177.74,83.74 UH1.A33
  BOTTOM w0.14: 177.92,85.38 178.28,85.38 180.58,87.68 RH456.1 v3(182.44,88.81)
EDP_HPD: length 65.9
  TOP w0.127: v2(58.48,9.03) 58.48,10.33 59.15,11 59.38,11 59.7,11.33 59.7,11.83 60.99,13.12 60.99,14.57 63.47,17.06 63.47,18.23 64.01,18.77 64.01,19.49 62.95,20.54 62.95,21.13 60.92,23.17 60.92,24.35 ; 58.8,24.95 RV113.1
  TOP w0.14: 60.92,24.35 v3(60.71,24.56) 60.31,24.95 RV114.1 58.8,24.95 ; QV9.3 57.76,24.95 RV113.1
  IN5 w0.089: 75.06,6.89 75.38,6.57 78.5,6.57 78.53,6.59 79.08,6.59 79.36,6.31 81.59,6.31 82.19,5.7 83.08,5.7 83.52,5.26 84.13,5.26 84.55,5.68 85.34,5.68 85.88,5.14 86.56,5.14 87.22,4.49 89.5,4.49 89.78,4.2 94.31,4.2 94.69,3.82 95.82,3.82 96.12,3.52 v2(96.82,3.52)
  IN5 w0.099: v2(58.48,9.03) 58.48,9.06 58.88,9.46 60.99,9.46 62.89,7.55 69,7.55 69.22,7.34 71.33,7.34 71.98,7.98 72.62,7.98 73.08,7.53 73.55,7.53 73.81,7.26 73.81,7.21 74.13,6.89 75.06,6.89
  BOTTOM w0.089: UH2.BD7 96.46,4.45 96.72,4.19 96.72,3.62 v2(96.82,3.52)
EDP_HPD_S: length 12.5
  TOP w0.152: QV9.1 56.9,26.42 57.02,26.3 57.79,26.3 58.22,25.87 RV113.2 58.68,26.88 58.8,27.01 60.6,27.01 v1(61,27.4) 61.59,27.99 v2(61.59,28.3)
  BOTTOM w0.152: JEDP1.23 60.55,32.25 60.35,32.05 60.35,30.6 61.59,29.37 v2(61.59,28.3)
EDP_PANEL_CLK: length 14.5
  TOP w0.14: v2(62.92,31.7) 62.92,30.16 63.72,29.36 64.93,29.36 65.38,28.9 v1(65.38,28.5) 64.82,27.94 RV546.2 ; RV549.1 RV546.2 ; RV546.2 64.82,27.01 65.09,26.74 65.98,26.74 66.3,27.06 67.31,27.06 67.63,26.74 67.63,25.22 67.75,25.1 UV17.7
  BOTTOM w0.14: v2(62.92,31.7) 62.92,32.06 63.05,32.2 JEDP1.18
EDP_PANEL_CLK_PCH: length 35.7
  TOP w0.14: v1(67.79,22.27) 67.43,22.63 v2(67.43,23.72) 66.37,22.66 63.71,22.66 63.04,23.33 RV549.2
  IN2 w0.089: 75.06,10.22 75.29,9.99 77.4,9.99 77.65,10.24 77.65,10.64 76.69,11.6 v2(76.69,11.7)
  IN2 w0.099: v2(67.43,23.72) 68.84,22.32 71.8,22.32 72.73,21.39 72.73,11.93 73.46,11.2 74.08,11.2 75.06,10.22
  BOTTOM w0.089: v2(76.69,11.7) 76.98,11.98 78.06,11.98 UH2.AJ44
EDP_PANEL_DAT: length 22.3
  TOP w0.14: v2(71.12,30.55) 71.71,29.96 71.71,26.3 RV545.2 71.12,25.49 RV548.1 69.79,24.65 69.59,24.45 UV17.6
  IN2 w0.099: v2(71.12,30.55) 70.59,31.08 59.48,31.08 v2(58.85,31.71)
  BOTTOM w0.14: v2(58.85,31.71) 59.05,31.91 JEDP1.26
EDP_PANEL_DAT_PCH: length 19
  TOP w0.14: v2(71.2,23.63) RV548.2
  IN2 w0.089: 75.06,12.04 76.67,10.43 v2(76.69,10.43)
  IN2 w0.099: 75.06,12.04 74.83,12.27 73.65,12.27 72.93,13 72.93,21.9 v2(71.2,23.63)
  BOTTOM w0.089: v2(76.69,10.43) 77.07,10.05 77.79,10.05 78.03,10.29 UH2.AM44
EDP_TXN0: length 176.6
  IN1 w0.107: v2(64,21.39) 63.63,21.76 63.62,21.77 63.62,21.92 63.7,22.01 64.09,22.01 64.7,21.39 64.7,20.96 65.57,20.1 74.19,20.1 76.47,22.38 76.47,24.18 78.14,25.85 78.14,26.75 78.58,27.19 80.7,27.19 83.03,29.52 86.75,29.52 89.17,31.94 98.06,31.94 101.51,35.38 102.48,35.38 105.03,37.93 111.91,37.93 120.48,46.5 120.48,53.88 121.23,54.63 121.23,58.81 128.31,65.88 128.31,69.27 129.86,70.83 129.86,77.38 132.3,79.81 132.3,82.61 133.87,84.18 133.87,86.31 137.25,89.68 170.69,89.68 171.05,89.33 174.25,89.33 174.38,89.2 177.03,89.2 177.49,88.74 177.49,83.83 177.12,83.46 175.35,83.46 173.96,82.08 173.96,81.53 174.49,81.01 175.97,81.01 176.12,80.86 176.12,80.26 175.96,80.1 175.87,80.1 v2(175.77,80.2)
  BOTTOM w0.076: UH1.E29 175.64,80.59 175.77,80.46 v2(175.77,80.2)
  BOTTOM w0.152: v2(64,21.39) 63.79,21.59 63.79,21.69 CV159.1
EDP_TXN0_C: length 1.7
  BOTTOM w0.152: CV159.2 63.92,23.16 63.92,24.1 RV521.1
EDP_TXN0_R: length 8.5
  BOTTOM w0.152: JEDP1.12 66.05,32.02 65.95,31.92 65.95,31.33 64.26,29.64 64.26,26.73 v4(64.1,26.57) 63.91,26.37 63.91,25.71 RV521.2
EDP_TXN1: length 174.2
  IN1 w0.089: v2(175.82,79.39) 175.82,79.11 175.92,79.02 176.02,79.02 176.39,79.39 177.2,79.39 177.72,79.9 177.72,80.34 177.72,80.35
  IN1 w0.107: 177.72,80.35 177.72,82.54 178.41,83.23 178.41,88.97 177.36,90.03 174.71,90.03 174.58,90.15 171.43,90.15 170.51,91.07 158.03,91.07 157.54,90.58 136.43,90.58 133,87.14 133,84.58 131.48,83.06 131.48,80.15 129.05,77.72 129.05,71.2 126.85,69.01 126.85,66.26 119.65,59.06 119.65,46.83 111.79,38.97 103.94,38.97 97.87,32.9 88.94,32.9 86.43,30.39 82.73,30.39 80.35,28 77.24,28 75.19,25.95 75.19,22.44 73.66,20.91 65.91,20.91 65.71,21.11 65.71,21.2 v2(65.9,21.39)
  BOTTOM w0.076: v2(175.82,79.39) 175.48,79.73 UH1.E28
  BOTTOM w0.152: v2(65.9,21.39) 65.76,21.53 65.76,21.75 CV161.1
EDP_TXN1_C: length 1.7
  BOTTOM w0.152: RV523.1 65.83,24.1 65.83,23.16 CV161.2
EDP_TXN1_R: length 8.4
  BOTTOM w0.152: RV523.2 65.84,25.69 v4(65.84,26.6) 65.84,27.35 65.7,27.49 65.7,29.33 67.45,31.09 67.45,31.92 67.55,32.02 JEDP1.9
EDP_TXN2: length 172.4
  IN1 w0.107: v2(179.5,79.87) 179.03,80.34 179.03,80.9 180.26,82.14 180.26,85.46 179.98,85.74 179.98,90 178.43,91.55 176.41,91.55 176.17,91.31 172.1,91.31 170.38,93.04 158.09,93.04 156.86,91.81 135.58,91.81 130.37,86.6 130.37,80.49 128.02,78.14 128.02,71.7 125.16,68.84 125.16,67.36 122.64,64.84 122.64,64 118.58,59.94 118.58,55.96 117.33,54.7 117.33,46.29 111.33,40.3 103.52,40.3 97.24,34.02 88.34,34.02 85.92,31.61 82.48,31.61 80.13,29.25 76.24,29.25 70.17,23.18 70.17,21.44 v2(70.22,21.39)
  BOTTOM w0.076: UH1.B29 177.57,80.45 177.57,80.3 177.77,80.09 178.24,80.09 178.42,80.27 179.09,80.27 v2(179.5,79.87)
  BOTTOM w0.152: CV163.1 70.08,21.75 70.08,21.53 v2(70.22,21.39)
EDP_TXN2_C: length 1.7
  BOTTOM w0.152: CV163.2 70.14,23.16 70.14,24.1 RV525.1
EDP_TXN2_R: length 8.5
  BOTTOM w0.152: JEDP1.6 69.05,32.02 68.95,31.92 68.95,30.63 70.17,29.41 v4(70.17,27.98) 70.17,27.14 69.79,26.76 69.79,26.36 70.13,26.02 70.13,25.71 RV525.2
EDP_TXN3: length 171.1
  IN1 w0.107: v2(178.89,79.13) 179.03,78.99 179.03,78.81 178.91,78.7 178.69,78.7 178.39,78.99 178.39,79.57 178.28,79.68 178.28,80.83 179.21,81.77 179.21,89.8 178.56,90.45 175,90.45 174.81,90.64 171.58,90.64 170.69,91.53 157.9,91.53 157.36,90.99 135.91,90.99 132.4,87.49 132.4,86.33 131.07,85 131.07,80.32 128.63,77.89 128.63,71.41 125.8,68.57 125.8,65.83 119.22,59.25 119.22,47.14 111.5,39.43 103.82,39.43 97.78,33.4 88.58,33.4 86.02,30.83 82.58,30.83 80.17,28.42 76.4,28.42 71.92,23.93 71.92,21.59 v2(72.12,21.39)
  BOTTOM w0.076: v2(178.89,79.13) 179,79.13 179.19,79.32 179.19,79.43 179.11,79.52 178.71,79.52 178.55,79.36 178.41,79.36 178.28,79.49 177.27,79.49 177.11,79.65 177.11,79.78 177.21,79.88 177.35,79.88 UH1.B28
  BOTTOM w0.152: CV165.1 71.98,21.75 71.98,21.53 v2(72.12,21.39)
EDP_TXN3_C: length 1.7
  BOTTOM w0.152: CV165.2 72.04,23.17 72.04,24.09 RV527.1
EDP_TXN3_R: length 8.3
  BOTTOM w0.152: JEDP1.3 70.55,32.08 70.55,32.01 70.45,31.91 70.45,30.54 72.05,28.94 v4(72.05,27.92) 72.05,25.7 RV527.2
EDP_TXP0: length 176.6
  IN1 w0.107: v2(63.41,21.39) 63.41,22 63.62,22.21 64.17,22.21 64.91,21.48 64.91,21.05 65.65,20.3 74.1,20.3 76.26,22.46 76.26,24.26 77.94,25.94 77.94,26.83 78.5,27.39 80.61,27.39 82.95,29.73 86.67,29.73 89.08,32.14 97.98,32.14 101.42,35.58 102.39,35.58 104.95,38.13 111.82,38.13 120.28,46.59 120.28,53.96 121.02,54.71 121.02,58.89 128.1,65.97 128.1,69.36 129.66,70.91 129.66,77.46 132.09,79.89 132.09,82.69 133.67,84.27 133.67,86.39 137.17,89.89 170.78,89.89 171.13,89.53 174.33,89.53 174.46,89.4 177.11,89.4 177.7,88.82 177.7,83.74 177.21,83.26 175.43,83.26 174.17,81.99 174.17,81.62 174.57,81.21 176.05,81.21 176.32,80.94 176.32,80.39 v2(176.5,80.21)
  BOTTOM w0.076: UH1.D29 176.14,80.59 176.5,80.23 v2(176.5,80.21)
  BOTTOM w0.152: CV158.1 63.46,21.81 63.46,21.44 v2(63.41,21.39)
EDP_TXP0_C: length 1.8
  BOTTOM w0.152: RV520.1 63.59,24.1 63.59,23.29 CV158.2
EDP_TXP0_R: length 8.5
  BOTTOM w0.152: RV520.2 63.58,25.69 63.58,26.51 63.93,26.86 v4(63.93,27.89) 63.93,29.78 65.62,31.47 65.62,31.92 65.55,31.99 JEDP1.13
EDP_TXP1: length 174.3
  IN1 w0.089: v2(175.17,79.39) 175.54,79.75 175.97,79.75 176.15,79.57 177.12,79.57 177.53,79.98 177.53,80.32 177.52,80.33 177.52,80.35
  IN1 w0.107: 177.52,80.35 177.52,82.63 178.21,83.32 178.21,88.89 177.28,89.82 174.63,89.82 174.5,89.95 171.34,89.95 170.43,90.86 158.11,90.86 157.63,90.38 136.52,90.38 133.2,87.06 133.2,84.49 131.68,82.98 131.68,80.07 129.25,77.63 129.25,71.12 127.05,68.92 127.05,66.18 119.85,58.98 119.85,46.74 111.88,38.77 104.03,38.77 97.95,32.69 89.02,32.69 86.51,30.18 82.81,30.18 80.43,27.8 77.32,27.8 75.39,25.87 75.39,22.35 73.75,20.71 65.83,20.71 65.51,21.03 65.51,21.2 v2(65.32,21.39)
  BOTTOM w0.076: v2(175.17,79.39) 174.83,79.73 UH1.F28
  BOTTOM w0.152: CV160.1 65.43,21.75 65.43,21.5 v2(65.32,21.39)
EDP_TXP1_C: length 1.8
  BOTTOM w0.152: CV160.2 65.49,23.29 65.49,24.1 RV522.1
EDP_TXP1_R: length 8.4
  BOTTOM w0.152: JEDP1.10 67.05,31.99 67.12,31.92 67.12,31.22 65.37,29.47 v4(65.37,27.96) 65.37,27.35 65.51,27.22 65.51,25.71 RV522.2
EDP_TXP2: length 172.3
  IN1 w0.107: v2(179.46,80.5) 179.27,80.69 179.27,80.86 180.47,82.05 180.47,85.54 180.18,85.83 180.18,90.08 178.51,91.75 176.33,91.75 176.09,91.51 172.19,91.51 170.46,93.24 158,93.24 156.77,92.01 135.49,92.01 130.16,86.68 130.16,80.57 127.82,78.23 127.82,71.78 124.96,68.92 124.96,67.45 122.44,64.93 122.44,64.08 118.38,60.02 118.38,56.04 117.13,54.79 117.13,46.38 111.25,40.5 103.43,40.5 97.16,34.22 88.25,34.22 85.84,31.81 82.4,31.81 80.04,29.45 76.16,29.45 69.97,23.26 69.97,21.72 v2(69.64,21.39)
  BOTTOM w0.076: UH1.A29 177.97,80.7 177.84,80.7 177.75,80.62 177.75,80.36 177.84,80.27 178.19,80.27 178.38,80.46 179.42,80.46 v2(179.46,80.5)
  BOTTOM w0.152: CV162.1 69.75,21.75 69.75,21.5 v2(69.64,21.39)
EDP_TXP2_C: length 1.8
  BOTTOM w0.152: RV524.1 69.81,24.1 69.81,23.29 CV162.2
EDP_TXP2_R: length 8.4
  BOTTOM w0.152: RV524.2 69.8,25.69 69.8,25.88 69.46,26.22 v4(69.46,26.56) 69.46,26.9 69.84,27.28 69.84,29.27 68.62,30.49 68.62,31.92 68.55,31.99 JEDP1.7
EDP_TXP3: length 171.1
  IN1 w0.107: v2(179.54,79.12) 179.14,79.51 178.74,79.51 178.48,79.76 178.48,80.75 179.42,81.68 179.42,89.88 178.65,90.65 175.08,90.65 174.89,90.84 171.67,90.84 170.78,91.73 157.81,91.73 157.28,91.2 135.82,91.2 132.2,87.57 132.2,86.42 130.86,85.08 130.86,80.4 128.43,77.97 128.43,71.49 125.6,68.66 125.6,65.91 119.01,59.33 119.01,47.23 111.42,39.63 103.73,39.63 97.7,33.6 88.5,33.6 85.93,31.03 82.5,31.03 80.08,28.62 76.32,28.62 71.72,24.02 71.72,21.57 v2(71.54,21.39)
  BOTTOM w0.076: v2(179.54,79.12) 179.19,78.77 178.74,78.77 178.2,79.31 177.19,79.31 176.9,79.6 176.9,79.69 UH1.C28
  BOTTOM w0.152: v2(71.54,21.39) 71.65,21.5 71.65,21.75 CV164.1
EDP_TXP3_C: length 1.8
  BOTTOM w0.152: RV526.1 71.71,24.11 71.71,23.28 CV164.2
EDP_TXP3_R: length 8.3
  BOTTOM w0.152: JEDP1.4 70.05,31.99 70.12,31.92 70.12,30.4 71.72,28.8 v4(71.72,26.58) 71.72,25.7 RV526.2
EN_INVPWR: length 304.5
  TOP w0.14: UE3.A25 304.72,15.63 304.9,15.44 v2(305.22,15.44) ; v2(309.77,23.33) 309.77,23.86 v1(309.45,24.18)
  IN1 w0.099: v2(52.12,20.32) 53.16,20.32 53.94,19.54 53.94,18.19 53.38,17.62 53.38,15.09 54.08,14.38 57.46,14.38 58.15,13.69 58.15,12.81 58,12.66 58,11.26 58.5,10.77 59.51,10.77 61.29,12.55 64.49,12.55 65.89,13.95 69.23,13.95 69.88,13.31 69.88,12.39 70.28,11.98 72.53,11.98 72.81,12.27 84.71,12.27 85.67,13.22 91.32,13.22 92.42,14.33 94.88,14.33 95.14,14.07 95.14,13.62 96.25,12.5 98.66,12.5 99.33,11.83 100.56,11.83 101.31,12.58 101.56,12.58 102.86,13.88 105.07,13.88 105.66,14.48 121.73,14.48 122.19,14.02 128.69,14.02 129.77,12.95 152.86,12.95 154.22,11.59 174.57,11.59 175.21,10.94 211.62,10.94 213.12,9.45 218.36,9.45 218.79,9.88 233.17,9.88 234.18,8.88 245.78,8.88 245.83,8.84 248.16,8.84 248.4,9.08 262.22,9.08 262.81,9.66 264.28,9.66 266.63,12.02 267.13,12.02 270.62,15.52 278.37,15.52 279.66,16.81 280.24,16.81 280.38,16.67 283.3,16.67 284.79,18.16 286.11,18.16 286.31,18.37 287.1,18.37 287.34,18.6 291.09,18.6 291.18,18.7 296.12,18.7 296.57,18.25 296.9,18.25 297.23,18.58 297.23,19.57 297.61,19.94 300.84,19.94 301.4,20.51 306.48,20.51 309.3,23.33 v2(309.77,23.33)
  BOTTOM w0.127: v2(52.12,20.32) 52.12,20.89 53.39,22.16 RV135.1 54.23,22.36 53.98,22.61 53.77,22.61 53.3,23.08 52.36,23.08 51.8,23.65 QV12.2
  BOTTOM w0.14: v2(305.22,15.44) 305.22,15.57 305.73,16.07 310.38,16.07 311.04,16.73 311.04,22.06 v2(309.77,23.33)
EN_PD_HV: length 61.9
  TOP w0.14: v2(9.4,13.44) 8.88,12.92 8.88,12.79 8.49,12.41 PU204.1
  IN3 w0.091: v2(16.35,41.86) 15.51,42.71 15.51,44.02 15.69,44.19 15.69,44.37 16.82,45.5 16.82,50.7 19.91,53.78 v2(21.28,53.78)
  IN5 w0.099: v2(9.4,13.44) 9.4,13.82 8.06,15.17 8.06,16.05 7.17,16.94 7.17,19.11 8.33,20.28 14.72,20.28 15.3,20.86 15.3,24.08 16.49,25.26 16.49,25.58 17.88,26.97 17.88,31.06 19.24,32.42 19.24,38.49 16.35,41.38 v2(16.35,41.86)
  BOTTOM w0.14: v2(21.28,53.78) 21.28,53.77 PR234.1 ; v2(16.35,41.86) 16.35,41.65 16.2,41.5 15.04,41.5 14.45,40.9 14.34,40.9 RT178.2
ENVDD: length 7.1
  TOP w0.14: DV7.1 36.39,28.72 37.05,28.06 38.65,28.06 RZ40.1 39.28,29.83 v1(39.45,30) 39.73,30.28 40.23,30.28 40.73,29.78 UZ8.4
ENVDD_PCH: length 300.1
  TOP w0.089: v2(78.78,16.18) 78.5,16.46 v3(78.5,16.95)
  TOP w0.14: DV7.3 35.74,31.08 36.73,32.08 v2(36.73,32.39) ; v2(298.21,9.15) 298.27,9.22 UE3.A7
  IN5 w0.099: v2(61.33,18.78) 61.33,18.78 62.97,17.14 65.56,17.14 65.56,17.14 65.95,17.14 65.96,17.14 66.5,16.6 74.28,16.6 74.36,16.68 77.61,16.68 78.11,16.18 v2(78.78,16.18)
  IN6 w0.089: 101.98,14.01 101.64,14.01 100.94,14.72 98.71,14.72 97.84,15.58 91.76,15.58 90.69,16.64 90.69,18.16 90.23,18.61 85.28,18.61 84.21,17.55 84.21,17.04 83.69,16.51 79.12,16.51 v2(78.78,16.18)
  IN6 w0.099: v2(280.91,17.86) 280.36,17.32 278.6,17.32 277.35,16.06 269.7,16.06 265.88,12.24 263.19,12.24 261.57,10.62 250.84,10.62 249.67,11.8 236.94,11.8 236.49,11.35 235.21,11.35 234.57,11.99 230.84,11.99 228.26,14.56 223.53,14.56 222.63,13.67 220.61,13.67 220.6,13.68 219.83,14.45 186.66,14.45 186.08,13.86 169.26,13.86 168.67,13.27 160.68,13.27 159.83,14.11 128.67,14.11 128.28,14.5 106.4,14.5 105.91,14.01 101.98,14.01 ; v2(61.33,18.78) 61.33,20.75 60.77,21.31 60.77,22.17 60.03,22.91 58.18,22.91 55.45,25.64 46.49,25.64 44.95,27.18 v2(44.95,27.44)
  BOTTOM w0.089: UH2.W42 79.12,16.51 v2(78.78,16.18)
  BOTTOM w0.14: v2(36.73,32.39) 37.01,32.39 37.4,32.77 43.13,32.77 44.98,30.93 44.98,27.47 v2(44.95,27.44) ; v2(280.91,17.86) 280.95,17.83 280.95,9.75 281.15,9.55 281.15,8.56 282.79,6.92 289.17,6.92 289.28,6.81 296.41,6.81 296.93,7.34 298.26,7.34 298.63,7.71 298.63,8.73 v2(298.21,9.15)
FAN1_PWM: length 247.5
  TOP w0.14: v1(101.96,31.9) 101.51,31.9 100.88,32.53 v2(99.78,32.53) 99.42,32.53 RE100.2 ; v2(305.84,15.41) 305.41,14.98 305,14.98 304.86,15.13 UE3.A24
  IN2 w0.099: v2(305.88,27.14) 305.88,26.43 305.32,25.87 299.11,25.87 298.69,25.45 298.01,25.45 296.79,24.22 293.79,24.22 291.72,22.15 291.11,22.15 290.4,21.43 282.41,21.43 280.97,20 279.2,20 278.31,19.11 274.3,19.11 273.47,19.94 268.59,19.94 267.54,18.88 264.7,18.88 264.48,18.66 261.35,18.66 259.81,17.13 254.35,17.13 252.96,15.73 247.96,15.73 246.42,17.28 175.89,17.28 175.41,17.76 173.06,17.76 172.86,17.96 158.75,17.96 157.16,19.55 157.16,24.11 156.61,24.66 154.9,24.66 153.9,25.66 145.71,25.66 144.36,27.01 140.33,27.01 137,30.33 133.8,30.33 133.16,29.69 115.86,29.69 111.74,33.81 102.98,33.81 102.38,34.42 101.1,34.42 99.78,33.1 v2(99.78,32.53)
  IN4 w0.091: v2(305.88,27.14) 305.78,27.03 305.78,24.8 305.18,24.2 304.55,24.2 304.17,23.82 304.17,21.09 304,20.93 304,15.46 304.43,15.04 305.47,15.04 v2(305.84,15.41)
  BOTTOM w0.127: v2(99.78,32.53) 99.16,33.16 99.16,35.07 99.03,35.2 JFAN1.1
FAN1_TACH: length 247.8
  TOP w0.14: UE3.B22 302.59,13.38 v2(302.15,12.94) ; v1(103.06,34.58) 102.48,33.99 v2(102.12,33.99) 102.1,33.99 RE81.2 CE66.1 100.03,34.81 DE7.2
  IN2 w0.099: v2(308.74,27.12) 308.28,26.67 306.57,26.67 305.54,25.63 300.8,25.63 299.44,24.27 297.14,24.27 296.5,23.63 295.07,23.63 293.13,21.69 291.39,21.69 290.94,21.23 282.49,21.23 281.05,19.8 279.28,19.8 278.39,18.91 274.21,18.91 273.39,19.74 268.67,19.74 267.62,18.68 264.78,18.68 264.56,18.46 261.43,18.46 259.89,16.93 254.43,16.93 253,15.49 247.91,15.49 247.09,16.32 181.24,16.32 180.48,17.08 175.81,17.08 175.35,17.53 173,17.53 172.77,17.76 158.35,17.76 155.54,20.57 155.54,24.02 155.19,24.37 154.88,24.37 153.84,25.41 145.67,25.41 144.27,26.81 140.25,26.81 136.92,30.13 133.89,30.13 133.24,29.49 115.74,29.49 111.61,33.61 102.5,33.61 v2(102.12,33.99)
  BOTTOM w0.14: v2(308.74,27.12) 308.52,26.91 308.52,25 308.03,24.51 308.03,19.66 308.24,19.44 308.24,17.9 307.76,17.43 305.04,17.43 303.91,16.3 303.91,14.22 303.09,13.39 302.45,13.39 302.15,13.09 v2(302.15,12.94)
FAN2_PWM: length 48.7
  TOP w0.14: v2(326.09,36.83) 325.22,35.96 321.23,35.96 320.54,36.66 319.11,36.66 v1(318.76,37.02) 318.62,37.16 318.62,39.67 319.13,40.18 v2(319.74,40.18) 319.76,40.15 RE101.2 ; UE3.A23 305.69,14.63 v2(306.45,15.39)
  IN1 w0.099: v2(306.45,15.39) 307.26,16.2 307.28,16.2 307.63,16.56 307.63,17.16 309.11,18.64 313.2,18.64 318.99,24.42 318.99,27.51 323.28,31.8 323.28,33.85 325.6,36.18 325.6,36.34 v2(326.09,36.83)
  BOTTOM w0.14: v2(319.74,40.18) 319.98,40.42 320.32,40.42 320.5,40.24 JFAN2.1
FAN2_TACH: length 41.6
  TOP w0.14: v3(322.37,36.34) 322.37,36.89 322.17,37.08 322.17,37.7 RE83.2 v2(322.2,38.31) CE67.1 322.84,39.06 DE8.2 ; v2(302.95,13.85) 302.97,13.88 UE3.B23
  IN6 w0.099: v2(302.95,13.85) 303.8,13.85 304.67,14.72 306.64,14.72 307.85,15.93 311.8,15.93 312.57,16.7 312.57,17.2 316.36,20.99 316.36,25.1 316.61,25.35 316.61,27.11 320.19,30.69 320.19,34.81 321.08,35.7 321.08,37.19 v2(322.2,38.31)
FB_3V: length 6.1
  TOP w0.14: v3(348.46,24.08) 347.97,23.58 v2(347.97,23.55)
  TOP w0.203: PR403.2 347.83,22.11 347.12,22.11 346.84,21.83 346.84,21.13 346.41,20.7 PU400.4
  TOP w0.254: v2(347.97,23.55) 347.96,23.54 PR401.2 PR403.2
  BOTTOM w0.254: PC401.2 v2(347.97,23.55)
FB_5V: length 4.1
  TOP w0.203: PU400.2 346.53,19.9 346.78,19.65 v2(347.06,19.65) 347.23,19.82 PR404.1
  TOP w0.254: PR404.1 PR402.1
  BOTTOM w0.254: v2(347.06,19.65) 347.23,19.82 PC402.1
FBA_CMD0: length 34.4
  BOTTOM w0.089: 213.94,92.18 213.94,92.02 213.9,91.98 213.9,91.56 214,91.46 214,91.04 213.85,90.89 213.85,89.42 213.68,89.25 213.39,89.25 213.13,89 213.13,88.42 UV1.U30
  BOTTOM w0.17: 213.94,92.18 214.27,92.52 214.27,94.01 215.13,94.87 215.13,96.77 214.27,97.63 v3(211.63,97.63) 211.29,97.63 209.76,99.16 209.76,105.04 211.15,106.43 215.39,106.43 215.67,106.71 217.27,106.71 217.53,106.97 217.66,106.97 218,107.31 218,107.38 218.02,107.4 218.04,107.4 218.26,107.63 218.26,108.75 218.5,108.99 219.12,108.99 UV5.G12
FBA_CMD1: length 30.7
  BOTTOM w0.089: UV1.T31 214.02,89.18 214.02,90.81 214.18,90.97 214.18,91.53 214.12,91.59 214.12,91.89 214.41,92.18
  BOTTOM w0.17: UV5.H10 218.69,107.58 218.34,107.24 218.34,107.17 217.43,106.26 215.8,106.26 215.55,106 211.35,106 210.11,104.76 210.11,99.77 210.24,99.64 210.24,99.35 211.49,98.1 v3(213.45,98.1) 214.47,98.1 215.6,96.97 215.6,94.67 214.74,93.81 214.74,92.52 214.41,92.18
FBA_CMD2: length 33
  TOP w0.17: v2(213.11,87.58) 213.11,90.84 214.64,92.37 v3(214.64,93.67) 214.1,94.22 213.17,94.22 211.47,95.92 211.47,96.96 211.03,97.4 211.03,98.97 210.47,99.54 210.47,104.3 211.18,105.02 212.61,105.02 213.19,105.6 215.17,105.6 215.5,105.28 217.42,105.28 v2(217.77,104.93)
  BOTTOM w0.102: UV1.U29 213.49,87.2 v2(213.11,87.58)
  BOTTOM w0.17: v2(217.77,104.93) 218.08,104.93 219.33,106.18 219.33,107.4 219.12,107.61 219.12,108.12 UV5.H11
FBA_CMD3: length 30.7
  TOP w0.089: v2(218.89,106.49) 218.76,106.49 218.25,107.01 217.13,107.01 216.94,107.2 v2(216.92,107.2)
  BOTTOM w0.089: UV5.K11 216.66,108.13 216.66,107.45 v2(216.92,107.2)
  BOTTOM w0.17: UV1.R34 215.2,91.33 215.69,91.83 215.69,93.42 216.55,94.28 v3(216.55,94.8) 216.55,97.36 214.86,99.05 211.88,99.05 211.17,99.76 211.06,99.76 210.78,100.05 210.78,104.16 211.74,105.11 215.88,105.11 216.13,105.37 217.76,105.37 v2(218.89,106.49)
FBA_CMD4: length 30.1
  TOP w0.089: v2(218.76,107.06) 218.43,107.39 v2(217.48,107.39)
  BOTTOM w0.089: v2(217.48,107.39) 217.11,107.76 UV5.K10
  BOTTOM w0.17: v2(218.76,107.06) 218.76,107 217.58,105.83 216,105.83 215.72,105.55 211.53,105.55 210.44,104.45 210.44,99.93 210.71,99.66 210.71,99.55 211.69,98.58 214.67,98.58 v3(215.38,97.87) 216.08,97.17 216.08,94.47 215.22,93.62 215.22,91.78 214.84,91.4 214.84,90.81 UV1.R33
FBA_CMD5: length 30.9
  BOTTOM w0.17: UV5.L12 215.89,108.96 215.89,107.52 215.26,106.89 210.81,106.89 209.29,105.36 v3(209.29,104.59) 209.29,98.96 211.1,97.15 214.08,97.15 214.65,96.57 214.65,95.38 214.43,95.16 213.31,95.16 212.75,94.6 212.75,91.74 213.07,91.42 213.07,90.08 UV1.U32
FBA_CMD6: length 30.1
  TOP w0.17: v2(216.74,103.36) 217.12,103.74 217.69,103.74 218.5,104.56 218.5,105.29 217.87,105.92 215.92,105.92 215.6,106.24 212.71,106.24 212.28,105.82 210.34,105.82 209.51,104.99 v3(209.51,104.44) 209.51,99.15 210.08,98.58 210.08,97 210.52,96.57 210.52,95.51 213.33,92.7 v2(213.65,92.7)
  BOTTOM w0.089: UV5.K4 217.09,103.02 v2(216.74,103.36) ; 213.61,92.14 213.61,91.59 213.82,91.38 213.82,91.12 213.5,90.79 UV1.U33
  BOTTOM w0.17: 213.61,92.14 213.61,92.67 v2(213.65,92.7)
FBA_CMD7: length 29.9
  TOP w0.17: v2(216.47,104.34) 216.22,104.59 215.21,104.59 214.95,104.85 214.63,104.85 214.48,104.69 214.48,104.19 214.11,103.82 211.67,103.82 211.39,103.54 211.39,99.96 211.98,99.37 211.98,97.79 212.45,97.32 212.45,96.71 v3(213.2,95.97) 214.01,95.16 214.44,95.16 215.01,94.59 216.51,94.59 216.63,94.46 216.63,93.99 216.51,93.86 215.33,93.86 215.2,93.73 215.2,91.77 213.51,90.07 213.51,87.42 213.09,86.99 v2(213.09,86.82)
  BOTTOM w0.089: UV5.K5 216.85,103.76 216.47,104.14 v2(216.47,104.34)
  BOTTOM w0.102: v2(213.09,86.82) 213.5,86.4 UV1.U28
FBA_CMD8: length 31
  TOP w0.17: v2(218.29,102.55) 218.84,102 218.84,100.35 218.57,100.08 218.57,99.55 218.69,99.42 220.03,99.42 220.16,99.3 220.16,98.89 220.03,98.76 218.73,98.76 218.61,98.64 218.61,98.28 218.73,98.15 v3(219.44,98.15) 220.03,98.15 220.16,98.03 220.16,97.6 220.03,97.47 218.72,97.47 218.59,97.35 218.59,96.92 218.72,96.8 219.95,96.8 220.08,96.67 220.08,96.22 219.95,96.09 217.27,96.09 217.15,95.97 217.15,93.45 217.02,93.32 215.81,93.32 215.68,93.19 215.68,91.79 213.84,89.96 213.84,87.33 213.52,87.01 213.52,86.62 213.28,86.38 212.7,86.38 v2(212.26,85.95)
  BOTTOM w0.102: UV1.V28 212.67,86.35 212.27,85.95 v2(212.26,85.95)
  BOTTOM w0.132: v2(218.29,102.55) 217.89,102.95 UV5.J4
FBA_CMD9: length 38.2
  TOP w0.17: v2(212.26,86.77) 211.84,87.19 211.84,87.84 211.54,88.14 211.54,89.14 211.46,89.23 211.46,90.37 210.98,90.85 210.98,93.71 209.57,95.12 209.57,96.18 209.13,96.61 209.13,98.18 208.56,98.76 v3(208.56,100.26) 208.56,105.38 209.94,106.77 212.02,106.77 212.2,106.94 215.85,106.94 216.2,106.59 218.12,106.59 219.94,104.77 219.94,104.06 218.84,102.96 217.84,102.96 v2(217.48,103.32)
  BOTTOM w0.089: v2(217.48,103.32) 217.89,103.73 UV5.J5
  BOTTOM w0.102: v2(212.26,86.77) 212.26,87.08 212.38,87.2 UV1.V29
FBA_CMD10: length 33.2
  TOP w0.17: v2(218.31,103.39) 218.31,103.91 218.83,104.42 218.83,105.43 218.01,106.25 216.05,106.25 215.68,106.62 212.48,106.62 212.15,106.29 210.14,106.29 209.04,105.19 v3(209.04,102.52) 209.04,98.95 209.61,98.38 209.61,96.81 210.05,96.37 210.05,95.32 211.46,93.91 211.46,90.93 211.77,90.62 211.77,89.46 211.84,89.39 211.84,88.27 212.26,87.86 v2(212.26,87.61)
  BOTTOM w0.089: UV5.H4 218.69,103.01 v2(218.31,103.39)
  BOTTOM w0.102: v2(212.26,87.61) 212.7,88.05 UV1.V30
FBA_CMD11: length 24.4
  TOP w0.17: v2(217.05,104.48) 217.15,104.48 217.27,104.6 217.27,104.81 217.15,104.94 215.33,104.94 214.99,105.28 214.17,105.28 214.05,105.15 214.05,104.57 213.92,104.44 213.51,104.44 213.17,104.78 212.83,104.78 212.6,104.56 211.41,104.56 210.95,104.1 210.95,99.73 211.51,99.17 v3(211.51,98.46) 211.51,97.6 211.95,97.16 211.95,96.34 v2(213.61,94.68)
  BOTTOM w0.089: UV5.H5 218.37,104.08 217.21,104.08 217.05,104.24 v2(217.05,104.48)
  BOTTOM w0.17: v2(213.61,94.68) 213.22,94.3 213.22,91.64 213.5,91.36 UV1.U34
FBA_CMD12: length 32.9
  BOTTOM w0.17: UV5.G3 219.08,102.57 219.08,103.88 218.55,104.4 217.71,104.4 217.19,104.92 216.29,104.92 216.05,104.68 211.89,104.68 211.1,103.9 211.1,100.29 211.76,99.64 212.25,99.64 212.36,99.53 215.06,99.53 217.03,97.56 v3(217.03,96.72) 217.03,94.08 216.17,93.22 216.17,91.93 215.64,91.4 215.64,89.57 215.35,89.29 215.12,89.29 214.83,89 214.83,88.72 214.58,88.46 213.89,88.46 UV1.U31
FBA_CMD13: length 27.7
  TOP w0.17: v2(218.26,100.94) 218.26,100.33 218.08,100.15 218.08,98.13 217.91,97.96 216.18,97.96 216.01,97.79 216.01,97.45 216.18,97.28 v3(217.04,97.28) 217.97,97.28 218.09,97.15 218.09,96.69 217.97,96.57 215.8,96.57 215.67,96.44 215.67,95.93 215.8,95.8 216.52,95.8 216.64,95.68 216.64,95.23 216.52,95.11 215.16,95.11 214.99,95.28 214.99,96.54 214.87,96.67 214.52,96.67 214.39,96.54 214.39,95.78 214.26,95.65 v2(214.2,95.65)
  BOTTOM w0.089: v2(218.26,100.94) 217.68,100.94 217.49,100.76 217.49,99.64
  BOTTOM w0.132: v2(218.26,100.94) 218.26,100.98 UV5.J2
  BOTTOM w0.17: UV1.V34 212.27,91.68 212.27,94.86 213.07,95.65 v2(214.2,95.65) ; 217.49,99.64 217.49,99.56 218.24,98.81 RV341.1
FBA_CMD14: length 24.9
  TOP w0.17: v2(213.26,96.61) 212.93,96.94 212.93,97.49 213.06,97.62 v3(214.38,97.62) 215.37,97.62 215.49,97.75 215.49,98.19 215.37,98.32 212.59,98.32 212.46,98.45 212.46,99.58 212.59,99.7 212.95,99.7 213.08,99.58 213.08,99.01 213.23,98.86 217.14,98.86 217.35,99.07 RV339.1 217.85,100.55 217.85,101.36 v2(217.45,101.76)
  BOTTOM w0.089: v2(217.45,101.76) 217.85,102.16 UV5.J3 ; UV1.V33 212.7,90.79 212.38,91.12 212.38,91.12 212.2,91.29 211.97,91.52 211.97,91.85 211.8,92.02
  BOTTOM w0.17: 211.8,92.02 211.8,95.14 v2(213.26,96.61)
FBA_CMD15: length 34.8
  TOP w0.17: v2(216.68,102.58) 216.29,102.96 216.29,103.52 216.83,104.06 217.55,104.06 218.18,104.69 218.18,105.11 217.69,105.6 215.7,105.6 215.37,105.92 212.94,105.92 212.36,105.34 210.68,105.34 209.99,104.65 209.99,99.35 210.56,98.77 210.56,97.2 211,96.77 211,96.55 211,96.55 211,95.72 212.98,93.73 213.88,93.73 214.17,93.45 214.17,92.57 212.65,91.06 v3(212.65,90.62) 212.65,88.87 v2(212.26,88.47)
  BOTTOM w0.089: v2(216.68,102.58) 216.29,102.19 UV5.L3
  BOTTOM w0.102: UV1.Y32 211,89.35 211.4,88.95 211.4,88.81 211.74,88.47 v2(212.26,88.47)
FBA_CMD16: length 38.9
  TOP w0.17: v2(201.06,108.99) 201.06,108.15 201.56,107.64 201.56,107.02 199.88,105.34 195.01,105.34 193.3,103.63 193.3,99.9 197.05,96.15 v3(197.75,96.15) 198.85,96.15 201.27,93.73 207.21,93.73 208.38,92.57 208.38,90.78 208.73,90.43 209.04,90.43 209.79,89.68 v2(209.79,89.24)
  BOTTOM w0.102: v2(209.79,89.24) 210.18,88.85 UV1.AA31
  BOTTOM w0.132: v2(201.06,108.99) 201.43,109.36 UV6.G12
FBA_CMD17: length 41.1
  TOP w0.089: 192.84,99.68 192.86,99.67
  TOP w0.17: v2(200.55,106.8) 200.55,106.54 199.74,105.74 193.74,105.74 192.69,104.69 192.69,99.84 192.84,99.68 ; v2(210.6,86.75) 210.07,87.28 209.63,87.28 209.37,87.53 209.37,88.29 209.39,88.3 209.39,89.63 209.03,89.99 208.34,89.99 207.9,90.43 207.9,92.37 207.02,93.26 201.07,93.26 v3(199.41,94.91) 198.7,95.63 196.9,95.63 192.86,99.67
  BOTTOM w0.089: v2(210.6,86.75) 210.6,86.82 210.2,87.23 UV1.AA29
  BOTTOM w0.132: UV6.H10 200.66,107.5 200.55,107.39 v2(200.55,106.8)
FBA_CMD18: length 42.5
  TOP w0.089: 208.55,87.94 208.55,87.36 208.73,87.18 209.14,87.18 209.45,86.88 v2(209.65,86.88)
  TOP w0.17: 208.55,87.94 208.15,88.34 207.9,88.34 207.52,88.72 207.52,92.06 206.8,92.78 200.88,92.78 198.59,95.07 196.76,95.07 192.22,99.61 192.22,104.91 193.36,106.06 199.52,106.06 v3(199.79,106.33) 199.96,106.5 199.96,106.86 200.46,107.36 v2(201.04,107.36)
  BOTTOM w0.089: v2(209.65,86.88) 210.18,86.35 UV1.AA28
  BOTTOM w0.132: v2(201.04,107.36) 201.04,108.17 UV6.H11
FBA_CMD19: length 35.5
  BOTTOM w0.17: UV6.K11 199.46,108.16 200.02,108.16 200.29,107.88 200.29,107.59 200.03,107.32 200.03,106.42 199.53,105.93 193.59,105.93 193.25,105.6 193.25,105.57 192.82,105.13 192.82,100.54 197.22,96.14 v3(198.54,96.14) 203.69,96.14 206.73,93.09 207.53,93.09 208.08,92.54 208.08,91.86 208.5,91.45 UV1.AC34
FBA_CMD20: length 33.9
  BOTTOM w0.17: UV6.K10 199.06,107.15 198.35,106.43 193.45,106.43 192.34,105.33 192.34,100.35 v3(196.29,96.4) 197.03,95.66 203.49,95.66 206.53,92.62 207.33,92.62 207.61,92.34 207.61,91.9 208.11,91.4 208.11,91.09 208.5,90.7 UV1.AC33
FBA_CMD21: length 38.2
  BOTTOM w0.089: 206.59,91.59 207.08,91.59 207.38,91.29 207.38,91.12 207.57,90.93 207.83,90.93 208.15,90.61 208.15,90.27 208.33,90.09 209.76,90.09 UV1.AA32
  BOTTOM w0.17: 206.59,91.59 206.3,91.88 206.3,92.18 203.34,95.14 196.87,95.14 v3(194.09,97.92) 191.87,100.15 191.87,105.53 193.16,106.82 197.95,106.82 198.66,107.52 198.66,108.96 UV6.L12
FBA_CMD22: length 24.8
  BOTTOM w0.089: 208.89,92.17 209.25,91.81 209.25,91.35 210.15,90.45 UV1.AA33
  BOTTOM w0.17: UV6.K4 199.06,102.8 199.45,102.4 199.45,100.08 199.21,99.84 199.21,99.53 199.04,99.36 198.11,99.36 197.94,99.19 197.94,98.85 198.11,98.68 199.04,98.68 199.21,98.51 199.21,98.2 199.04,98.03 198.1,98.03 197.93,97.86 197.93,97.52 198.1,97.35 199.04,97.35 199.21,97.18 199.21,96.92 199.52,96.61 203.89,96.61 v3(205.33,95.17) 206.93,93.57 207.72,93.57 208.56,92.73 208.56,92.38 208.76,92.17 208.89,92.17
FBA_CMD23: length 32.1
  TOP w0.17: v2(198.91,104.5) 199.59,104.5 201.14,106.05 206.82,106.05 208.09,104.79 208.09,98.56 208.66,97.99 208.66,96.41 209.1,95.98 209.1,94.88 210.5,93.48 v3(210.5,92.19) 210.5,90.75 211.09,90.17 211.09,89.06 211.28,88.87 211.28,88.17 211.01,87.9 211.01,86.38 v2(210.6,85.97)
  BOTTOM w0.089: v2(210.6,85.97) 210.98,86.35 UV1.Y28
  BOTTOM w0.132: UV6.K5 199.06,104.36 v2(198.91,104.5)
FBA_CMD24: length 29.2
  TOP w0.17: v2(200.26,103.33) 200.26,104.63 201.29,105.67 206.53,105.67 207.61,104.59 207.61,98.36 208.18,97.79 208.18,96.22 208.62,95.78 208.62,94.69 v3(209.03,94.27) 210.03,93.28 210.03,90.72 210.72,90.03 210.72,88.92 211.02,88.61 211.02,88.28 210.6,87.86 v2(210.6,87.58)
  BOTTOM w0.102: UV1.Y29 210.99,87.2 v2(210.6,87.58)
  BOTTOM w0.14: v2(200.26,103.33) 200.26,103.32 199.89,102.96 UV6.J4
FBA_CMD25: length 27.8
  BOTTOM w0.089: 210.85,92.18 210.85,92.11 211.5,91.46 211.5,91.04 211.32,90.86 211.32,89.38 UV1.W31
  BOTTOM w0.17: 210.85,92.18 210.85,92.77 210.72,92.9 210.72,93.58 210.53,93.77 210.53,96.38 208.34,98.57 v3(208.34,102.71) 208.34,104.47 206.82,105.99 201.23,105.99 199.86,104.62 UV6.J5
FBA_CMD26: length 30.6
  TOP w0.17: v2(201.06,103.33) 200.79,103.6 200.79,104.59 201.5,105.3 206.23,105.3 207.14,104.39 v3(207.14,101.75) 207.14,99.44 206.8,99.09 206.26,99.09 205.83,98.66 205.83,97.72 205.66,97.56 205.08,97.56 204.93,97.41 204.93,96.99 205.05,96.86 207.08,96.86 207.71,96.24 207.71,96.02 208.15,95.59 208.15,94.49 209.55,93.08 209.55,90.62 210.31,89.86 210.31,88.76 v2(210.62,88.45)
  BOTTOM w0.102: UV1.Y30 211,88.07 v2(210.62,88.45)
  BOTTOM w0.14: v2(201.06,103.33) 200.68,102.96 UV6.H4
FBA_CMD27: length 24.9
  BOTTOM w0.089: 210.37,92.18 210.37,92.01 210.81,91.57 211.13,91.57 211.32,91.38 211.32,91.12 211.06,90.86 210.73,90.86 210.34,91.25 UV1.AA34
  BOTTOM w0.17: 210.37,92.18 210.37,92.58 210.25,92.7 210.25,93.23 209.95,93.54 209.95,96.29 v3(208.75,97.48) 207.86,98.37 207.86,104.25 206.58,105.53 201.88,105.53 200.99,104.64 200.99,104.09 UV6.H5
FBA_CMD28: length 34.6
  TOP w0.17: v2(208.86,91.67) 209.02,91.82 209.02,92.95 207.67,94.29 207.67,95.39 207.23,95.82 207.23,96.04 206.89,96.39 203.14,96.39 202.84,96.68 202.84,97.8 202.97,97.93 203.33,97.93 203.45,97.8 203.45,97.3 203.58,97.18 203.98,97.18 204.1,97.3 204.1,98.76 204.23,98.89 205.39,98.89 206.06,99.56 206.5,99.56 206.63,99.69 206.63,100.95 206.12,101.46 206.12,102.88 206.44,103.2 206.44,104.44 205.94,104.94 v3(203.86,104.94) 201.64,104.94 201.3,104.59 201.3,103.91 201.86,103.35 v2(201.86,102.58)
  BOTTOM w0.102: v2(208.86,91.67) 208.86,91.43 209.72,90.58 209.72,90.47 209.87,90.32 209.87,90.31 210.06,90.12 210.07,90.12 210.14,90.05 210.45,90.05 210.6,89.9 210.6,89.26 211,88.86 UV1.Y31 ; UV6.G3 201.86,102.56 v2(201.86,102.58)
FBA_CMD29: length 27.9
  TOP w0.089: v2(200.24,100.94) 200.28,100.91 RV340.1
  BOTTOM w0.14: UV6.J2 199.86,101.29 200.2,100.94 v2(200.24,100.94)
  BOTTOM w0.17: v2(200.24,100.94) 200.24,100.13 200.98,99.4 203.7,99.4 203.82,99.27 203.82,98.79 203.7,98.67 201.84,98.67 201.72,98.54 201.72,98.11 201.84,97.99 202.37,97.99 202.5,97.86 202.5,97.24 202.62,97.11 203.05,97.11 203.18,97.24 203.18,97.86 203.3,97.99 203.7,97.99 203.82,97.86 203.82,97.21 203.95,97.09 205.26,97.09 205.39,97.21 205.39,97.42 205.52,97.54 205.89,97.54 206.07,97.37 206.07,96.74 206.2,96.62 207.15,96.62 207.28,96.74 207.28,97.46 207.44,97.62 207.73,97.62 207.9,97.46 207.9,97.18 208.03,97.06 208.51,97.06 209.47,96.09 209.47,93.34 209.77,93.04 209.77,92.51 209.9,92.38 209.9,91.86 210.12,91.64 210.44,91.64 210.83,91.25 UV1.Y34
