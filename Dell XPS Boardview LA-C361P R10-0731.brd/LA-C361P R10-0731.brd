# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TBT_JTAG_TDI: length 20.9
  TOP w0.089: v5(29.95,44.87) 30.06,44.87 30.27,45.08 v3(31,45.08) 31.79,45.08 32.7,44.17 33.57,44.17 33.66,44.09
  TOP w0.127: 33.66,44.09 33.66,44.08 RT9.2
  TOP w0.14: T196.1 38.8,36.97 v2(39.88,36.97)
  IN4 w0.089: v5(29.95,44.87) 30.65,44.87 31.88,43.63 31.88,42.03 33.66,40.25
  IN4 w0.091: 33.66,40.25 34.2,39.71 34.84,39.71 37.58,36.97 v2(39.88,36.97)
  BOTTOM w0.089: v5(29.95,44.87) 30.56,44.87 30.85,44.57 UT1.Y4
TBT_JTAG_TDO: length 17.9
  TOP w0.089: v2(29.95,44.26) 30.33,44.64 31.98,44.64 32.62,44 33.25,44 33.66,43.6
  TOP w0.127: 33.66,43.6 RT6.2
  TOP w0.14: T199.1 36.35,37.32 v2(36.35,37.28) 36.35,36.59 v3(36.75,36.19)
  IN5 w0.089: 33.66,40.36 32.53,41.49 32.53,42.92 30.8,44.65 30.34,44.65 29.99,44.3 29.99,44.29 29.97,44.27 29.96,44.27 v2(29.95,44.26)
  IN5 w0.099: v2(36.35,37.28) 36.35,37.66 33.66,40.36
  BOTTOM w0.102: v2(29.95,44.26) 30.26,44.57 UT1.W4
TBT_JTAG_TMS: length 24.2
  TOP w0.089: 33.66,44.91 33.15,44.91 32.92,45.14 32.35,45.14 31.98,45.52 30.46,45.52 30.22,45.27 29.86,45.27 29.31,44.72 v5(29.31,44.26)
  TOP w0.127: 40.18,38.95 v2(40.65,39.42)
  TOP w0.14: T197.1 39.98,38.74 40.18,38.95 ; 33.66,44.91 33.76,44.91 RT8.2
  IN4 w0.091: v2(40.65,39.42) 40.65,39.16 39.24,37.75 37.22,37.75 34.99,39.99 34.19,39.99 32.13,42.05 32.13,44.08 30.98,45.23 29.78,45.23 29.31,44.76 v5(29.31,44.26)
  BOTTOM w0.102: UT1.V4 29.61,44.57 29.31,44.27 v5(29.31,44.26)
TBT_LSRX: length 24.8
  TOP w0.14: v1(11.99,32.95) 11.36,33.57 RT232.1 10.92,33.79 10.45,34.26 10.2,34.26 v2(10.04,34.41)
  IN2 w0.099: v2(10.04,34.41) 10.07,34.38 12.03,34.38 12.56,34.91 17.5,34.91 17.94,35.35 17.94,37.91 20.5,40.48 20.5,43.61 v2(21.15,44.25)
  BOTTOM w0.081: UT4.K4 9.8,35.89 10.05,35.64 10.05,34.42 v2(10.04,34.41)
  BOTTOM w0.089: 20.58,44.22 21.12,44.22 21.15,44.24 v2(21.15,44.25) 21.23,44.17 21.79,44.17 UT1.A4
  BOTTOM w0.14: 20.58,44.22 20.4,44.22 RT45.2
TBT_LSTX: length 26
  IN2 w0.099: v2(21.15,43.64) 21.08,43.71 20.9,43.71 20.71,43.52 20.71,40.39 18.15,37.82 18.15,35.26 17.58,34.7 12.64,34.7 12.11,34.16 10.51,34.16 v2(10.18,33.84)
  BOTTOM w0.081: 10.05,33.01 10.08,33.04 10.08,33.74 v2(10.18,33.84) 10.03,33.84 9.69,34.17 9.69,34.78 9.8,34.89 UT4.L4
  BOTTOM w0.089: UT1.A5 21.39,43.89 v2(21.15,43.64) 20.88,43.91 20.58,43.91
  BOTTOM w0.14: v1(8.68,32.24) 8.82,32.11 9.6,32.11 9.78,32.29 9.78,32.74 ; RT233.1 9.81,32.71 9.78,32.74 ; 9.78,32.74 10.05,33.01 ; 20.58,43.91 20.37,43.91 RT44.2
TBT_ML0_N: length 2.8
  BOTTOM w0.089: 28.49,46.86 28.49,46.43 28.36,46.31 28.36,46.16 28.18,45.97 28.18,45.61 28.24,45.55 28.34,45.55 28.41,45.62 UT1.R1
  BOTTOM w0.14: CV172.2 29,47.56 29,47.35 28.74,47.09 28.72,47.09 28.49,46.86
TBT_ML0_P: length 2.8
  BOTTOM w0.089: UT1.R2 28.64,45.5 28.64,46.19 28.78,46.33 28.78,46.54
  BOTTOM w0.102: 28.78,46.67 28.78,46.54
  BOTTOM w0.14: 28.78,46.67 v4(28.97,46.86) 29.33,47.22 29.33,47.52 CV173.2
TBT_ML1_N: length 2.7
  BOTTOM w0.089: UT1.N1 27.49,45.65 27.41,45.56 27.35,45.56 27.26,45.65 27.26,45.98 27.71,46.43 27.71,47.01 27.83,47.13
  BOTTOM w0.14: 27.83,47.13 27.88,47.18 27.88,47.53 CV174.2
TBT_ML1_P: length 2.7
  BOTTOM w0.089: 28.16,47.13 27.99,46.96 27.99,46.31 27.72,46.05 27.72,45.5 UT1.N2
  BOTTOM w0.14: 28.16,47.13 28.21,47.18 28.21,47.54 CV175.2
TBT_ML2_N: length 2.3
  BOTTOM w0.089: UT1.L1 26.57,45.65 26.5,45.58 26.41,45.58 26.34,45.65 26.34,46.01 26.44,46.11 26.44,46.16 26.68,46.4
  BOTTOM w0.102: 26.68,46.4 26.68,46.81 26.72,46.85 26.72,47.09 26.73,47.09 26.71,47.11 26.71,47.13
  BOTTOM w0.14: CV176.2 26.71,47.33 26.71,47.13
TBT_ML2_P: length 2.4
  BOTTOM w0.089: UT1.L2 26.8,45.5 26.8,46.2 26.9,46.3
  BOTTOM w0.102: 27.04,47.13 27.04,46.87 26.9,46.73 26.9,46.3
  BOTTOM w0.14: CV177.2 27.04,47.25 27.04,47.13
TBT_ML3_N: length 4.8
  BOTTOM w0.089: UT1.J1 25.65,45.65 25.58,45.58 25.49,45.58 25.42,45.65 25.42,45.96 25.95,46.49 25.95,46.97 25.92,47 25.92,47.09 25.9,47.11 25.9,47.13
  BOTTOM w0.14: 25.9,47.13 25.9,48.19 25.76,48.32 25.76,48.66 25.56,48.87 25.56,49.49 CV170.2
TBT_ML3_P: length 4.8
  BOTTOM w0.089: 26.23,47.13 26.23,46.38 25.88,46.03 25.88,45.5 UT1.J2
  BOTTOM w0.14: 26.23,47.13 26.23,48.33 26.09,48.46 26.09,48.8 25.89,49 25.89,49.53 CV171.2
TBT_PCIE_WAKE#: length 369.7
  TOP w0.14: v1(62.5,19.72) 61.7,19.72 v2(60.78,20.63) ; RE120.1 v2(303.61,3.16)
  IN1 w0.099: v2(32.49,48.07) 31.56,47.14 31.56,45.22 32.45,44.33 32.64,44.33 32.97,44 33.14,44 33.29,43.85 33.29,43.39 32.56,42.67 32.56,41.8 33.66,40.71 33.66,37.54 35.23,35.97 35.23,34.71 34.16,33.65 34.16,31.63 33.43,30.9 33.43,27.79 33.67,27.55 34,27.55 34.29,27.84 42.79,27.84 43.75,26.87 43.75,24.75 44.12,24.38 45.22,24.38 45.37,24.53 46.62,25.79 50.24,25.79 51.51,24.52 52.1,24.52 52.93,25.36 57.61,25.36 60.78,22.18 v2(60.78,20.63)
  IN5 w0.099: v2(303.61,3.16) 309.25,3.16 312.83,6.74 315.34,6.74 317.25,8.64 317.25,10.25 315.38,12.11 313.78,12.11 312.24,10.58 308.66,10.58 305.25,7.16 301.13,7.16 300.91,7.37 299.86,7.37 298.93,8.31 298.93,9 296.93,11.01 295.23,11.01 294.72,11.51 292.78,11.51 291.72,10.45 289.18,10.45 288.38,9.64 286.23,9.64 285.45,10.42 285.45,10.97 284.2,12.22 281.49,12.22 281.33,12.38 272.29,12.38 272.25,12.34 266.23,12.34 265.32,13.25 254.23,13.25 251.6,15.88 251.6,16.91 250.1,18.4 221.49,18.4 219.84,20.06 219.84,24.47 218.16,26.15 187.02,26.15 186.85,26.32 182.47,26.32 178.86,22.72 178.86,19.13 174.79,15.06 168.48,15.06 168.41,14.99 161.4,14.99 161.24,15.15 129.01,15.15 128.9,15.25 105.39,15.25 105.24,15.41 101.64,15.41 101.14,15.91 99.6,15.91 98.85,16.66 94.65,16.66 93.68,15.68 91.34,15.68 89.83,14.18 85.66,14.18 85.5,14.33 78.11,14.33 77.81,14.03 70.81,14.03 69.96,14.88 66.08,14.88 65.38,14.18 63.08,14.18 60.1,17.16 60.1,19.95 v2(60.78,20.63)
  BOTTOM w0.089: 31.62,47.13 31.5,47 31.33,47 30.25,45.92 UT1.W1
  BOTTOM w0.14: v2(32.49,48.07) 32.2,47.78 32.18,47.78 31.98,47.58 RT22.2 31.94,47.44 31.62,47.13
TBT_POC_RST#: length 9.7
  TOP w0.089: DT29.2 v2(24.12,44.26)
  TOP w0.14: RT244.2 25.66,49.76 RT202.2 25.5,49.43 v2(25.1,49.03) 25.53,49.03 v1(25.87,48.69)
  IN4 w0.089: v2(24.12,44.26) 24.12,45.71 23.75,46.07 23.75,47.13
  IN4 w0.091: v2(25.1,49.03) 24.46,49.03 23.75,48.32 23.75,47.13
  BOTTOM w0.089: UT1.F4 24.12,44.26 v2(24.12,44.26)
TBT_PWR_EN: length 8.7
  BOTTOM w0.089: UH2.AU43 78.67,8.02 78.42,8.26 77.97,8.26 77.69,8.54 75.06,8.54
  BOTTOM w0.127: RH556.2 71.01,8.43 71.2,8.24 72.8,8.24 72.94,8.1 73.48,8.1
  BOTTOM w0.14: 75.06,8.54 74.96,8.54 74.95,8.55 v1(74.38,8.55) 74.32,8.55 73.89,8.11 73.49,8.11 73.48,8.1
TBT_RBIAS: length 1.4
  TOP w0.089: v2(24.76,42.94) 25.42,42.27 RT10.1
  BOTTOM w0.102: UT1.H6 24.76,42.95 v2(24.76,42.94)
TBT_ROM_CLK: length 33
  IN1 w0.089: v2(33.26,45.31) 33.44,45.31 33.66,45.09
  IN1 w0.099: v2(37.72,28.56) 37.42,28.56 35.33,30.66 35.33,33.6 37.77,36.04 37.77,37.61 34.8,40.58 34.8,42.66 34.05,43.42 34.05,44.7 33.66,45.09
  BOTTOM w0.089: v2(33.26,45.31) 32.97,45.02 32.97,44.61 32.73,44.37 32.46,44.37 32.26,44.57 31.85,44.57 UT1.AB4
  BOTTOM w0.14: v1(44.58,28.51) 44.58,29.68 43.49,30.77 42.13,30.77 41.91,30.55 RT231.1 41.75,29.85 UT2.6 39.51,29.85 38.21,28.56 v2(37.72,28.56)
TBT_ROM_CLK_R: length 28.1
  TOP w0.14: v2(34.47,26.73) v1(33.07,26.73)
  IN3 w0.091: v2(18.2,24.38) 18.52,24.06 26.64,24.06 28.88,26.31 31.19,26.31 31.2,26.32 31.58,26.32 31.99,26.73 v2(34.47,26.73)
  BOTTOM w0.14: v2(34.47,26.73) 36.99,26.73 39.48,29.22 41.02,29.22 41.24,29.43 RT231.2 ; v2(18.2,24.38) RT210.1
TBT_ROM_CS#: length 29.2
  IN1 w0.089: 33.46,42.75 33.46,43.92 33.21,44.18 33.11,44.18 32.61,44.68 v2(32.61,44.77)
  IN1 w0.099: 33.46,42.75 34.2,42.01 34.2,40.33 37.17,37.36 37.17,36.37 34.62,33.82 34.62,31.67 33.79,30.84 33.79,29.63 34.78,28.65 v2(34.78,28.58)
  BOTTOM w0.089: UT1.AC3 32.57,44.81 v2(32.61,44.77)
  BOTTOM w0.14: RT18.2 31.91,30.7 32.04,30.58 33.82,30.58 34.78,29.62 v2(34.78,28.58) 34.78,28.24 33.85,27.31 UT2.1 32.14,27.31 RT230.1
TBT_ROM_CS#_R: length 35.5
  IN3 w0.091: v2(12.5,36.43) 11.26,35.19 11.26,33.56 11.9,32.92 11.9,31.27 13.02,30.15 13.02,28.03 14.69,26.36 14.69,25.81 15.68,24.81 17.19,24.81 18.28,25.91 21.67,25.91 21.99,25.6 27.25,25.6 28.61,26.96 28.61,27.26 28.94,27.59 31.2,27.59 v2(31.6,27.19)
  BOTTOM w0.14: RT230.2 31.03,27.78 31.34,27.46 31.4,27.46 31.6,27.27 v2(31.6,27.19) 31.6,26.81 v1(31.23,26.44) ; RT213.1 12.85,36.08 v2(12.5,36.43)
TBT_ROM_DI: length 32.9
  IN1 w0.089: v2(33.27,45.87) 32.89,45.5 32.89,45.09 33.06,44.93 33.51,44.93
  IN1 w0.099: v2(35.66,28.53) 35.66,29.12 35.13,29.65 35.13,33.68 37.57,36.12 37.57,37.53 34.6,40.5 34.6,42.58 33.85,43.33 33.85,44.58 33.51,44.93
  BOTTOM w0.076: UT1.AB3 31.85,45.03 32.23,45.03 32.33,45.13 32.75,45.13 32.89,45.27 32.89,45.5 v2(33.27,45.87)
  BOTTOM w0.14: v1(44.06,30.8) 43.72,31.15 42.38,31.15 42.19,31.34 RT228.1 41.53,31.34 41.31,31.12 UT2.5 38.87,29.78 36.92,29.78 v2(35.66,28.53)
TBT_ROM_DI_R: length 28.2
  IN3 w0.091: v2(34.47,27.31) 32.3,27.31 31.5,26.51 28.74,26.51 27.44,25.21 22.18,25.21 21.3,24.33 20.03,24.33 19.72,24.65 v2(19.72,24.64)
  BOTTOM w0.14: v2(34.47,27.31) 34.95,27.31 35.23,27.59 35.23,28.74 37.57,31.09 37.57,31.48 38.02,31.92 RT228.2 42.66,31.92 v1(42.96,32.23) ; v2(19.72,24.64) 19.55,24.48 RT211.1
TBT_ROM_DO: length 27.7
  IN1 w0.099: v2(33.33,44.54) 33.65,44.21 33.65,42.96 34.4,42.21 34.4,40.42 37.37,37.45 37.37,36.21 34.82,33.66 34.82,29.51 35.24,29.09 35.24,28.46 34.93,28.14 34.63,28.14 v2(34.19,28.58)
  BOTTOM w0.089: UT1.AC4 32.23,44.35 32.41,44.17 32.96,44.17 v2(33.33,44.54) 33.66,44.54
  BOTTOM w0.14: RT16.2 30.35,30.16 31.28,29.23 RT229.1 31.8,29.09 32.31,28.58 UT2.2 v2(34.19,28.58) ; 33.66,44.54 33.68,44.54 v1(34.16,45.02)
TBT_ROM_DO_R: length 41
  TOP w0.14: v2(31.01,27.18) 31.01,27.65 v3(30.59,28.08)
  IN3 w0.091: v2(12.37,37.14) 11.97,37.55 11.62,37.55 11.07,36.99 11.07,33.42 11.67,32.81 11.67,31.21 12.82,30.06 12.82,26.11 14.31,24.62 17.58,24.62 18.06,25.1 20.55,25.1 20.98,25.53 21.52,25.53 21.65,25.4 27.35,25.4 28.67,26.71 30.54,26.71 v2(31.01,27.18)
  BOTTOM w0.14: RT212.1 16.38,36.33 16.02,36.69 15.47,36.69 15.41,36.63 12.87,36.63 12.45,37.06 12.45,37.07 v2(12.37,37.14) ; RT229.2 30.59,28.99 30.59,27.6 v2(31.01,27.18)
TBT_ROM_HOLD#: length 3.2
  BOTTOM w0.14: UT2.7 41.29,28.58 41.38,28.67 RT15.2 42.18,28.98 v3(42.8,29.6)
TBT_ROM_WP#: length 24.4
  TOP w0.089: v2(29.98,46.43) 29.75,46.43 29.36,46.82 29.36,47.13
  TOP w0.14: v3(29.31,47.64) 29.36,47.59 29.36,47.13
  IN1 w0.089: 32.07,44.33 29.98,46.42 v2(29.98,46.43)
  IN1 w0.099: v2(31.78,30.13) 33.76,32.11 33.76,33.81 34.83,34.88 34.83,35.64 33.23,37.24 33.23,40.57 32.2,41.6 32.2,44.2 32.07,44.33
  BOTTOM w0.076: v2(29.98,46.43) 29.79,46.24 UT1.V1
  BOTTOM w0.14: 31.78,30.13 31.63,29.98 31.24,29.98 30.99,30.23 RT17.2 ; 31.78,30.13 31.92,29.98 32.03,29.98 32.16,29.85 UT2.3 ; 31.78,30.13 v2(31.78,30.13)
TBT_RSENSE: length 1.7
  TOP w0.089: RT10.2 25.68,42.94 v2(25.41,42.94)
  BOTTOM w0.102: UT1.J6 25.71,43.27 25.41,42.98 v2(25.41,42.94)
TBT_SRC_CFG1: length 3.1
  TOP w0.14: RT107.2 33.02,46.72 v2(33.06,46.68)
  BOTTOM w0.089: UT1.AA1 31.17,45.9 31.47,46.19 32.23,46.19 32.46,46.43 32.81,46.43 v2(33.06,46.68)
TBT_TEST_EN: length 3.5
  TOP w0.14: v3(25.99,47.08) 25.72,47.34 RT3.2 25.15,47.23 24.74,46.82 v2(24.26,46.82)
  BOTTOM w0.102: v2(24.26,46.82) 24.12,46.82 23.75,46.45 23.75,46.11 23.81,46.05 UT1.E1
TBT_TEST_PWRG: length 2.5
  BOTTOM w0.089: 33.66,43.44 33.34,43.44 33.14,43.24 32.72,43.24 32.28,43.67 31.85,43.67 31.64,43.89 UT1.AB5
  BOTTOM w0.127: 33.66,43.44 RT4.2
TBT_TMU_CLK_OUT: length 2.8
  BOTTOM w0.089: UT1.V2 30.02,45.5 30.02,45.96 31.19,47.13
  BOTTOM w0.127: RT37.2 31.31,47.24 31.19,47.13
TBT_USB2_D+: length 21.1
  IN2 w0.099: v2(24.11,37.09) 23.98,37.09 23.76,37.31 23.76,37.57 23.69,37.65 23.69,37.77 23.14,38.32 21.31,38.32 20.31,37.32 20.31,36.22 18.17,34.08 12.91,34.08 12.11,33.27 9.92,33.27 9.65,33.55 9.65,33.89 9.58,33.96 9.58,34.26 v2(9.09,34.74)
  BOTTOM w0.081: UT4.L5 9.23,35.49 9.15,35.49 9.07,35.42 9.07,35.2 9.23,35.04 9.23,34.88 v2(9.09,34.74)
  BOTTOM w0.102: UT1.E20 23.78,36.91 23.97,37.09 24.11,37.09 v2(24.11,37.09)
TBT_USB2_D-: length 21.1
  IN2 w0.099: v2(9.09,34.15) 9.44,33.8 9.44,33.46 9.84,33.06 12.19,33.06 13,33.87 18.26,33.87 20.52,36.13 20.52,37.23 21.4,38.11 23.05,38.11 23.48,37.68 23.48,37.56 23.55,37.49 23.55,37.18 v2(23.46,37.09)
  BOTTOM w0.081: v2(9.09,34.15) 9.48,34.53 9.48,35.2 9.55,35.28 9.55,35.67 UT4.K5
  BOTTOM w0.089: UT1.D20 v2(23.46,37.09)
TBT_USB3_RX0_N: length 49.7
  TOP w0.097: v2(10.19,69.97) arc(10.26,70.14) 10.44,70.21 12.59,70.21 arc(13.69,69.99) 14.62,69.37 19.71,64.29 arc(20.83,62.61) 21.22,60.62 21.22,55.88 arc(21.09,55.21) 20.71,54.64 20.64,54.57 arc(20.39,54.2) 20.3,53.76 20.3,50.21 arc(20.28,50.07) 20.2,49.96 arc(20.11,49.83) 20.08,49.66 20.08,36.53 arc(20.22,36.2) 20.55,36.06 20.91,36.06 arc(21.03,35.99) v2(21.05,35.85)
  BOTTOM w0.097: UT1.A21 22.07,36.53 arc(22.19,36.41) 22.07,36.29 21.85,36.29 21.84,36.29 arc(21.81,36.29) 21.77,36.28 arc(21.77,36.27) 21.76,36.27 arc(21.75,36.26) 21.73,36.24 21.68,36.19 21.66,36.17 arc(21.51,36.07) 21.34,36.04 21.33,36.04 arc(21.16,35.99) v2(21.05,35.85) ; v2(10.19,69.97) arc(10.12,70.14) 9.95,70.21 9.66,70.21 arc(9.47,70.12) DT21.1 9.19,70.13 arc(9.11,70.19) 9,70.21 8.81,70.21 arc(8.7,70.19) 8.61,70.12 8.46,69.97 arc(8.39,69.87) 8.36,69.75 8.36,69.47 arc(8.31,69.22) 8.17,69.01 7.07,67.91 arc(6.86,67.77) 6.61,67.72 6.31,67.72 arc(6.03,67.64) JUSBC1.B10
TBT_USB3_RX0_P: length 49.7
  TOP w0.097: v2(10.19,70.64) 10.33,70.5 arc(10.45,70.42) 10.58,70.4 12.59,70.4 arc(13.76,70.16) 14.75,69.5 19.84,64.42 arc(21,62.68) 21.41,60.62 21.41,55.88 arc(21.26,55.14) 20.84,54.51 20.77,54.44 arc(20.56,54.13) 20.49,53.76 20.49,50.21 arc(20.45,50) 20.33,49.83 arc(20.28,49.76) 20.26,49.66 20.26,36.53 arc(20.35,36.33) 20.55,36.24 20.77,36.24 arc(20.85,36.26) 20.92,36.3 v2(21.05,36.44)
  BOTTOM w0.097: UT1.B21 22.27,36.69 arc(22.2,36.74) 22.12,36.75 21.85,36.75 arc(21.8,36.75) 21.76,36.72 21.7,36.66 arc(21.68,36.62) 21.67,36.57 21.67,36.5 arc(21.66,36.45) 21.63,36.4 21.55,36.33 21.52,36.3 arc(21.44,36.24) 21.33,36.22 arc(21.16,36.28) v2(21.05,36.44) ; v2(10.19,70.64) arc(10.12,70.47) 9.95,70.4 9.78,70.4 arc(9.7,70.41) 9.62,70.46 DT20.1 9.18,70.47 arc(9.1,70.41) 9,70.39 8.81,70.39 arc(8.63,70.36) 8.48,70.26 8.32,70.1 arc(8.22,69.94) 8.18,69.75 8.18,69.47 arc(8.14,69.3) 8.04,69.15 6.94,68.04 arc(6.79,67.94) 6.61,67.91 6.31,67.91 arc(6.03,67.99) JUSBC1.B11
TBT_USB3_RX1_N: length 39.6
  TOP w0.097: v2(17.28,38.64) 17.22,38.7 arc(17.15,38.8) 17.13,38.91 17.13,39.06 arc(17.15,39.13) 17.19,39.2 arc(17.29,39.35) 17.33,39.54 17.33,44.15 arc(17.4,44.49) 17.59,44.77 17.66,44.84 arc(17.84,45.12) 17.91,45.45 17.91,59.42 arc(17.74,60.3) 17.24,61.04 15.72,62.56 arc(14.5,63.38) 13.05,63.67 11.65,63.67 arc(11.46,63.7) 11.3,63.81 DT18.1 10.95,63.7 arc(10.91,63.68) 10.86,63.67 10.22,63.67 arc(10.14,63.68) 10.07,63.73 10.01,63.79 arc(9.88,63.87) 9.73,63.9 8.81,63.9 arc(8.72,63.92) 8.64,63.97 8.62,63.99 arc(8.55,64.04) 8.45,64.06 JUSBC1.A10
  BOTTOM w0.097: v2(17.28,38.64) 17.27,38.64 arc(17.13,38.69) 17.08,38.83 17.08,38.92 arc(17.09,38.98) 17.12,39.03 17.42,39.33 arc(17.52,39.39) 17.63,39.42 20.75,39.42 arc(20.78,39.41) 20.81,39.39 20.84,39.36 arc(20.95,39.28) 21.09,39.26 21.39,39.26 arc(21.51,39.23) 21.62,39.16 arc(21.73,39.09) 21.85,39.06 22.05,39.06 arc(22.19,39.09) 22.32,39.18 UT1.B15
TBT_USB3_RX1_P: length 39.6
  TOP w0.097: JUSBC1.A11 8.45,63.56 arc(8.55,63.58) 8.62,63.63 8.64,63.65 arc(8.72,63.7) 8.81,63.72 9.73,63.72 arc(9.81,63.7) 9.88,63.65 9.94,63.6 arc(10.07,63.51) 10.22,63.48 10.8,63.48 arc(10.86,63.47) 10.91,63.44 DT19.1 11.44,63.43 arc(11.5,63.47) 11.57,63.48 13.05,63.48 arc(14.43,63.21) 15.59,62.43 17.11,60.91 arc(17.56,60.23) 17.72,59.42 17.72,45.45 arc(17.67,45.19) 17.53,44.97 17.46,44.9 arc(17.23,44.56) 17.14,44.15 17.14,39.54 arc(17.12,39.42) 17.06,39.33 arc(16.98,39.2) 16.95,39.06 16.95,38.97 arc(16.88,38.76) v2(16.69,38.64)
  BOTTOM w0.097: v2(16.69,38.64) 16.7,38.64 arc(16.84,38.69) 16.89,38.83 16.89,38.92 arc(16.92,39.05) 16.99,39.16 17.29,39.46 arc(17.45,39.57) 17.63,39.6 20.75,39.6 arc(20.85,39.58) 20.94,39.52 20.97,39.49 arc(21.03,39.46) 21.09,39.44 21.45,39.44 arc(21.53,39.45) 21.6,39.47 21.68,39.51 arc(21.73,39.52) 21.79,39.53 22.01,39.53 arc(22.13,39.41) 22.01,39.29 UT1.A15
TBT_USB3_TX0_N: length 42.8
  TOP w0.097: JUSBC1.A3 8.4,67.56 arc(8.54,67.59) 8.66,67.66 arc(8.69,67.69) 8.73,67.71 arc(8.76,67.72) 8.78,67.72 8.96,67.72 arc(9.1,67.74) 9.22,67.82 9.36,67.96 arc(9.85,68.29) 10.43,68.4 10.89,68.4 arc(11.09,68.32) DT13.1 11.18,68.14 arc(11.26,68.33) 11.46,68.42 12.59,68.42 arc(14.26,68.08) 15.67,67.14 arc(17.79,63.96) 18.54,60.21 18.54,58.7 arc(18.71,57.82) 19.21,57.07 19.46,56.83 arc(19.52,56.73) 19.54,56.62 19.54,54.87 arc(19.49,54.62) 19.35,54.4 18.87,53.92 arc(18.62,53.55) 18.53,53.11 18.53,45.16 arc(18.44,44.71) 18.19,44.33 arc(18.02,44.07) 17.95,43.75 17.95,40 arc(18.02,39.68) 18.2,39.41 19.04,38.57 arc(19.22,38.29) 19.29,37.97 19.29,37.26 arc(19.26,37.12) 19.18,37 19.05,36.87 arc(19.01,36.84) 18.95,36.83 18.77,36.83 arc(18.69,36.86) 18.66,36.94 v2(18.66,37.08)
  BOTTOM w0.097: v2(18.66,37.08) 18.66,36.97 arc(18.7,36.87) 18.8,36.82 19.21,36.82 arc(19.3,36.86) 19.34,36.96 CT40.2
TBT_USB3_TX0_N_C: length 3.3
  BOTTOM w0.097: CT40.1 19.93,37 arc(19.97,36.89) 20.08,36.85 20.18,36.85 arc(20.19,36.85) 20.19,36.85 arc(20.23,36.86) 20.26,36.88 20.28,36.9 arc(20.31,36.95) 20.32,37.01 20.32,37.17 arc(20.35,37.31) 20.43,37.42 20.63,37.62 arc(20.77,37.71) 20.93,37.75 21.37,37.75 arc(21.43,37.74) 21.49,37.72 arc(21.5,37.71) 21.51,37.71 arc(21.6,37.68) 21.69,37.67 22.08,37.67 arc(22.2,37.65) 22.31,37.57 UT1.B19
TBT_USB3_TX0_P: length 42.8
  TOP w0.097: JUSBC1.A2 8.4,68.06 arc(8.54,68.03) 8.66,67.95 arc(8.72,67.92) 8.78,67.9 8.96,67.9 arc(9.03,67.92) 9.09,67.96 9.23,68.09 arc(9.78,68.46) 10.43,68.59 10.76,68.59 arc(10.97,68.63) 11.14,68.75 DT12.1 arc(11.37,68.65) 11.61,68.6 12.59,68.6 arc(14.33,68.26) 15.8,67.27 arc(17.97,64.03) 18.73,60.21 18.73,58.7 arc(18.89,57.89) 19.34,57.2 19.59,56.96 arc(19.69,56.8) 19.73,56.62 19.73,54.87 arc(19.67,54.55) 19.48,54.27 19,53.79 arc(18.79,53.48) 18.72,53.11 18.72,45.16 arc(18.62,44.64) 18.32,44.2 arc(18.19,44) 18.14,43.75 18.14,40 arc(18.19,39.75) 18.33,39.54 19.17,38.7 arc(19.4,38.36) 19.47,37.97 19.47,37.26 arc(19.43,37.05) 19.31,36.87 19.18,36.74 arc(19.13,36.7) 19.08,36.67 18.91,36.6 arc(18.78,36.53) v2(18.66,36.43)
  BOTTOM w0.097: CT39.2 arc(19.22,36.59) 19.06,36.64 18.98,36.64 arc(18.79,36.58) v2(18.66,36.43)
TBT_USB3_TX0_P_C: length 3.3
  BOTTOM w0.097: UT1.A19 22,37.45 arc(22.11,37.33) 22,37.22 21.8,37.22 arc(21.68,37.26) 21.6,37.36 21.57,37.43 arc(21.54,37.48) 21.49,37.51 21.44,37.54 arc(21.42,37.54) 21.4,37.55 arc(21.39,37.56) 21.37,37.56 20.93,37.56 arc(20.84,37.54) 20.76,37.49 20.56,37.29 arc(20.52,37.23) 20.51,37.17 20.51,37.01 arc(20.48,36.88) 20.41,36.77 20.39,36.75 arc(20.31,36.69) 20.22,36.67 arc(20.2,36.66) 20.18,36.66 20.08,36.66 arc(19.97,36.62) 19.93,36.51 CT39.1
TBT_USB3_TX1_N: length 42.9
  TOP w0.097: v2(17.27,36.9) 17.18,36.81 arc(17.07,36.74) 16.94,36.71 16.79,36.71 arc(16.53,36.76) 16.31,36.91 15.9,37.32 arc(15.66,37.69) 15.57,38.13 15.57,43.46 arc(15.64,43.82) 15.85,44.12 16.62,44.9 arc(16.99,45.45) 17.12,46.11 17.12,58.82 arc(17.03,59.28) 16.77,59.67 16.4,60.04 arc(16.11,60.24) 15.76,60.3 10.34,60.3 arc(10.19,60.34) 10.06,60.42 9.87,60.61 arc(9.83,60.68) 9.81,60.76 9.81,60.93 arc(9.88,61.09) v2(10.03,61.15)
  BOTTOM w0.097: JUSBC1.B3 6.1,63.96 arc(6.15,63.93) 6.2,63.92 6.68,63.92 arc(6.94,63.87) 7.16,63.72 7.53,63.34 7.53,63.34 arc(7.69,63.24) 7.87,63.21 8.84,63.21 arc(9.07,63.16) 9.26,63.03 9.66,62.63 9.69,62.61 arc(9.78,62.46) 9.82,62.3 9.82,62.28 arc(9.89,62.03) DT26.1 arc(9.89,61.77) 9.81,61.57 9.81,61.38 arc(9.87,61.22) v2(10.03,61.15) ; v2(17.27,36.9) 17.4,36.76 arc(17.49,36.71) 17.59,36.69 17.68,36.69 arc(17.74,36.7) 17.79,36.73 arc(17.83,36.78) 17.84,36.84 17.84,37.64 arc(17.91,37.99) 18.11,38.29 18.25,38.43 arc(18.47,38.58) 18.74,38.63 19.28,38.63 arc(19.46,38.68) CT38.2
TBT_USB3_TX1_N_C: length 2.4
  BOTTOM w0.097: UT1.B17 22.3,38.5 22.29,38.51 arc(22.2,38.57) 22.1,38.59 20.63,38.59 arc(20.42,38.63) 20.23,38.76 CT38.1
TBT_USB3_TX1_P: length 42.9
  TOP w0.097: v2(17.27,36.34) arc(17.06,36.48) 16.82,36.53 16.79,36.53 arc(16.46,36.59) 16.18,36.78 15.77,37.19 arc(15.49,37.62) 15.38,38.13 15.38,43.46 arc(15.47,43.89) 15.71,44.26 16.49,45.03 arc(16.82,45.52) 16.93,46.11 16.93,58.82 arc(16.86,59.21) 16.63,59.54 16.27,59.91 arc(16.03,60.06) 15.76,60.12 10.34,60.12 arc(10.12,60.16) 9.92,60.29 9.74,60.48 arc(9.66,60.6) 9.62,60.74 9.62,60.93 arc(9.56,61.09) v2(9.4,61.15)
  BOTTOM w0.097: JUSBC1.B2 6.07,63.63 arc(6.18,63.71) 6.31,63.73 6.68,63.73 arc(6.87,63.69) 7.03,63.59 7.4,63.21 arc(7.61,63.07) 7.87,63.02 8.84,63.02 arc(9,62.99) 9.13,62.9 9.56,62.47 arc(9.61,62.39) 9.63,62.3 9.63,62.28 arc(9.55,62.02) DT27.1 arc(9.54,61.77) 9.62,61.57 9.62,61.36 arc(9.55,61.21) v2(9.4,61.15) ; v2(17.27,36.34) 17.31,36.38 arc(17.44,36.47) 17.59,36.5 17.68,36.5 arc(17.81,36.53) 17.92,36.6 arc(18,36.71) 18.03,36.84 18.03,37.64 arc(18.08,37.92) 18.24,38.16 18.38,38.3 arc(18.54,38.41) 18.74,38.45 19.28,38.45 arc(19.47,38.39) CT37.2
TBT_USB3_TX1_P_C: length 2.4
  BOTTOM w0.097: UT1.A17 22.04,38.37 arc(22.08,38.35) 22.1,38.31 22.1,38.25 arc(22.07,38.17) 21.98,38.14 21.79,38.14 arc(21.69,38.18) 21.65,38.27 arc(21.62,38.37) 21.52,38.41 20.49,38.41 arc(20.36,38.38) 20.25,38.31 CT37.1
TBTA_AUX_N: length 28.6
  TOP w0.14: v2(12.78,35.37) 12.96,35.55 12.96,35.87 13.33,36.25 14.27,36.25 15.33,35.19 18.04,35.19 18.33,34.89 21.93,34.89 22.44,34.38 32.45,34.38 33.42,35.35 33.86,35.78 v4(33.86,36.88) 33.86,37.62 34.27,38.03 34.27,38.39 34.22,38.44 34.02,38.44 CT42.2
  BOTTOM w0.081: UT4.J2 11.05,36.17 11.45,36.17 12.26,35.37 v2(12.78,35.37)
TBTA_AUX_N_C: length 4.6
  TOP w0.089: CT42.1 32.74,38.99 31.83,38.99 31.29,39.52 31.01,39.52 30.81,39.32 30.34,39.32 v2(29.96,39.69)
  BOTTOM w0.102: v2(29.96,39.69) UT1.W15
TBTA_AUX_P: length 29.3
  TOP w0.14: CT41.2 34.11,38.77 34.35,38.77 34.6,38.53 34.6,37.89 34.19,37.49 34.19,35.65 32.59,34.04 22.31,34.04 21.79,34.56 18.2,34.56 17.9,34.86 15.19,34.86 14.13,35.92 13.47,35.92 13.29,35.74 13.29,35.57 v2(13.48,35.38)
  BOTTOM w0.081: 11.94,36.03 11.82,36.14 11.77,36.14 11.5,36.42 UT4.J1
  BOTTOM w0.14: 11.94,36.03 12.19,35.77 13.08,35.77 v2(13.48,35.38)
TBTA_AUX_P_C: length 3.5
  TOP w0.089: v2(30.61,39.69) 31.36,39.69 31.9,39.16 32.81,39.16 33.04,38.93 CT41.1
  BOTTOM w0.102: v2(30.61,39.69) UT1.Y15
TBTA_CC1: length 57.1
  TOP w0.254: JUSBC1.A5 8.97,66.56 9.35,66.95 DT14.1 9.74,66.67 9.54,66.47 v2(9.54,66.43)
  TOP w0.508: CT160.1 7.11,34.2 v2(6.78,34.53)
  IN6 w0.508: v2(6.78,34.53) 8.05,35.8 10.48,35.8 11.04,36.35 11.04,39.82 10.53,40.32 8.73,40.32 8.36,40.69 8.36,41.82 9.04,42.5 11.38,42.5 11.73,42.85 14.89,42.85 18.07,46.02 18.07,54.64 17.53,55.18 17.53,59.55 13.45,63.62 8.66,63.62 8.21,64.08 8.21,65.09 v2(9.54,66.43)
  BOTTOM w0.254: v2(6.78,34.53) 6.78,34.86 7.3,35.38 UT4.L9 UT4.K9
TBTA_CC2: length 60.5
  TOP w0.254: v2(5.47,59.58) 6.17,59.58 DT25.1
  TOP w0.508: CT159.1 6.15,33.82 v2(6.15,34.36)
  IN1 w0.508: JUSBC1.B5 5.57,65.29 4.76,65.29 4.38,64.91 4.38,61.61 4.36,61.59 4.36,60.83 4.38,60.81 4.38,60.67 v2(5.47,59.58)
  IN6 w0.508: v2(6.15,34.36) 5.66,34.36 5.28,34.73 5.28,36.13 3.94,37.48 3.94,43.01 4.82,43.9 6.39,43.9 7.18,43.11 11.13,43.11 11.47,43.46 14.63,43.46 16.75,45.57 16.75,59.23 16.4,59.58 v2(9.49,59.58) v2(5.47,59.58)
  BOTTOM w0.254: UT4.K10 UT4.L10 6.8,35.41 6.35,34.96 6.35,34.71 6.35,34.71 6.35,34.56 v2(6.15,34.36)
TBTA_DEBUG1: length 2.8
  BOTTOM w0.081: UT4.L2 10.88,35.34 10.88,34.84 11.51,34.21
  BOTTOM w0.14: RT184.2 11.96,34.04 11.68,34.04 11.51,34.21
TBTA_DEBUG2: length 4.2
  BOTTOM w0.081: UT4.K2 11.05,35.67 11.05,35.31 11.05,35.31 11.05,35.01 11.73,34.33 12.07,34.33
  BOTTOM w0.14: 12.07,34.33 12.42,33.98 13.09,33.98 13.46,33.61 RT185.2
TBTA_DEBUG3_LSTX: length 2.9
  BOTTOM w0.081: RT233.2 10.71,33.3 10.86,33.45 RT187.2 11.05,33.88 v1(10.75,34.18) 10.56,34.37 10.56,35.07 10.3,35.32 UT4.L3
TBTA_DEBUG4_LSRX: length 7.2
  TOP w0.14: v2(10.69,32.16) 10.69,32.45 10.92,32.68 RT232.2
  BOTTOM w0.081: 11.51,33.63 11.24,33.9 11.24,34.21 10.72,34.72 10.72,35.14 10.55,35.31 10.55,35.67 UT4.K3
  BOTTOM w0.14: v2(10.69,32.16) 11.08,31.77 11.6,31.77 12.07,32.24 12.07,33.23 11.85,33.45 RT188.2 11.51,33.63
TBTA_HPD: length 57
  TOP w0.14: RT43.2 20.97,33.89 21.23,34.15 v2(21.35,34.15)
  IN2 w0.099: v2(17.1,28.09) 17.13,28.11 17.13,28.9 16.68,29.36 16.68,30.43 17.4,31.15 18.34,31.15 v2(21.35,34.15)
  IN3 w0.089: v2(26.7,44.24) 26.7,44.73 25.68,45.76 23.09,45.76 21.93,44.6 21.36,44.6 21.25,44.71 20.58,44.71 ; 20.58,40.26 21.63,39.21 21.63,36.86 22.2,36.29 22.2,35.56 21.35,34.71 21.35,34.3
  IN3 w0.091: v2(21.35,34.15) 21.35,34.15 21.35,34.3 ; v2(7.23,43.94) 7.23,43.39 8.28,42.34 11.32,42.34 11.85,42.87 14.65,42.87 15.37,42.15 15.37,41.33 15.75,40.95 15.75,37.28 16.75,36.28 16.75,28.43 v2(17.1,28.09) ; 20.58,40.26 18.5,42.34 18.5,43.88 19.32,44.71 20.58,44.71
  BOTTOM w0.089: v2(26.7,44.24) 26.73,44.24 27.03,44.54 UT1.M4
  BOTTOM w0.14: v2(7.23,43.94) 7.66,43.51 RT181.2
TBTA_I2C_C_N: length 12.5
  TOP w0.14: v2(10.23,73.07) 10.37,72.93 11.01,72.93 DT23.1 11.34,72.93 11.69,72.93 11.93,73.18 LT13.3
  IN2 w0.099: v2(10.23,73.07) 10.04,72.88 9.04,72.88 7.56,71.41 7.56,70.05 7.95,69.66 7.95,66.44 7.42,65.92 6.84,65.92 JUSBC1.B7
TBTA_I2C_C_P: length 12.5
  TOP w0.14: LT13.2 11.96,72.33 11.69,72.6 11.34,72.6 DT24.1 11.01,72.6 10.34,72.6 v2(10.23,72.48)
  IN2 w0.099: JUSBC1.B6 6.84,65.7 7.51,65.7 8.16,66.36 8.16,69.75 7.77,70.14 7.77,71.32 9.13,72.67 10.04,72.67 v2(10.23,72.48)
TBTA_I2C_D_N: length 67.2
  TOP w0.14: LT13.4 13.93,72.83 14.06,72.71 14.79,72.71 15.45,73.37 15.45,73.98 14.9,74.53 v4(13.59,74.53) 13.07,74.53 12.83,74.29 v2(12.83,73.95)
  IN2 w0.099: v2(12.83,73.95) 12.83,74.32 13.06,74.55 14.17,74.55 14.81,73.91 14.81,70.86 13.51,69.56 13.51,63.68 16.71,60.47 16.71,54.83 16.45,54.57 16.45,45.56 14.71,43.81 11.65,43.81 11.13,43.3 8.98,43.3 7.94,42.26 7.09,42.26 4.01,39.18 4.01,36.66 5.29,35.38 5.29,34.35 7.32,32.32 8.24,32.32 8.48,32.55 8.48,32.71 v2(8.77,33.01)
  BOTTOM w0.081: v2(8.77,33.01) 8.59,33.2 8.59,33.33 8.19,33.73 8.19,33.78 7.97,34.01 7.97,34.67 8.17,34.87 8.17,35.08 8.3,35.21 UT4.L7
TBTA_I2C_D_P: length 67.2
  TOP w0.14: v2(12.83,74.89) 12.85,74.86 15.04,74.86 v4(15.44,74.46) 15.78,74.12 15.78,73.24 14.92,72.38 13.98,72.38 LT13.1
  IN2 w0.099: v2(12.83,74.89) 12.96,74.76 14.25,74.76 15.02,73.99 15.02,70.77 13.72,69.47 13.72,63.76 16.92,60.56 16.92,54.74 16.66,54.48 16.66,45.47 14.8,43.6 11.73,43.6 11.22,43.09 9.07,43.09 8.03,42.04 7.17,42.04 4.22,39.09 4.22,36.75 5.5,35.47 5.5,34.44 7.41,32.53 8.15,32.53 8.27,32.64 8.27,32.93 v2(8.19,33.01)
  BOTTOM w0.081: v2(8.19,33.01) 8.32,33.14 8.32,33.22 7.92,33.62 7.92,33.67 7.7,33.89 7.7,34.78 7.9,34.98 7.9,35.1 8.05,35.25 8.05,35.67 UT4.K7
TBTA_I2C_INT#: length 20.4
  IN2 w0.099: v2(19.07,43.79) 18.5,43.21 18.5,42.13 17.11,40.74 15.98,40.74 14.19,38.95 v2(14.19,38.85)
  IN3 w0.089: 20.58,43.21 21.49,43.21 21.75,43.47 21.75,43.84 23.16,45.24 24.39,45.24 v2(25.39,44.25)
  IN3 w0.091: 20.58,43.21 19.65,43.21 v2(19.07,43.79)
  BOTTOM w0.081: 12.74,39.67 12.7,39.71 11.7,39.71 11.41,39.42 UT4.C1
  BOTTOM w0.089: v2(25.39,44.25) 25.44,44.25 25.73,44.54 UT1.J4
  BOTTOM w0.14: 12.74,39.67 12.87,39.54 RT167.2 13.03,39.67 13.29,39.92 13.89,39.92 14.19,39.62 v2(14.19,38.85)
TBTA_LDO_BMC: length 2.4
  TOP w0.14: v2(11.84,38.43) 11.96,38.43 CT144.1 12.57,37.82 12.57,37.73 v3(13.13,37.17)
  BOTTOM w0.081: UT4.E1 11.82,38.42 v2(11.84,38.43)
TBTA_PD_SBU1: length 3
  BOTTOM w0.081: UT4.K8 7.55,35.67 7.55,35.19 7.3,34.95 7.3,34.51 6.99,34.2 6.99,34.18
  BOTTOM w0.14: 6.99,34.18 6.92,34.12 6.92,33.75 RT176.1
TBTA_PD_SBU2: length 2.4
  BOTTOM w0.081: 7.16,33.71 7.16,34.09 7.47,34.4 7.47,34.86 7.71,35.1 7.71,35.33 UT4.L8
  BOTTOM w0.14: RT177.1 7.16,33.71
TBTA_RESET_N: length 32.9
  TOP w0.089: v2(25.41,43.58) 25.4,43.57 DT29.1
  IN2 w0.089: v2(25.41,43.58) 24.24,43.58 23.75,44.07 23.75,44.53 23.89,44.67 23.89,45.16
  IN2 w0.099: v2(5.73,37.78) 6.1,37.41 6.1,37.35 7.46,35.99 9.3,35.99 9.82,35.47 12.02,35.47 12.55,36 13.4,36 14.47,37.08 14.47,37.97 15.94,39.44 17.12,39.44 19.89,42.21 19.89,43.88 20.48,44.47 20.48,46.6 21.43,47.55 22.8,47.55 23.29,47.05 23.29,45.75 23.89,45.16
  BOTTOM w0.081: UT4.F11 5.87,37.92 v2(5.73,37.78)
TBTA_SBU1: length 52.3
  TOP w0.14: v2(9.46,65.19) DT17.1 9.37,64.65 8.97,65.06 JUSBC1.A8
  IN6 w0.099: v2(6.74,31.85) 6.95,32.05 6.95,32.3 7.14,32.49 8.11,32.49 8.39,32.22 9.51,32.22 10.68,33.38 10.68,34.85 11.81,35.98 12.69,35.98 12.94,36.23 12.94,40.22 14.1,41.38 17.02,41.38 18.32,42.68 18.32,44.85 18.88,45.41 18.88,54.39 19.34,54.85 19.34,56.4 18.46,57.28 18.46,59.77 12.53,65.69 9.97,65.69 v2(9.46,65.19)
  BOTTOM w0.14: v2(6.74,31.85) 6.83,31.94 6.83,32.24 RT176.2
TBTA_SBU2: length 65.2
  TOP w0.14: JUSBC1.B8 5.82,66.58 4.93,66.58 4.49,67.02 4.49,70.79 5.28,71.58 DT22.1 v2(5.53,72.22)
  IN6 w0.099: v2(7.33,31.85) 7.16,32.02 7.16,32.22 7.23,32.28 8.02,32.28 8.3,32.01 9.6,32.01 10.89,33.29 10.89,34.76 11.9,35.77 12.78,35.77 13.15,36.14 13.15,40.13 14.19,41.17 17.11,41.17 18.53,42.59 18.53,44.76 19.09,45.32 19.09,54.31 19.55,54.76 19.55,56.49 18.67,57.37 18.67,59.85 12.62,65.9 11.56,65.9 10.44,67.02 9.97,67.02 9.11,67.88 8.83,67.88 8.08,68.62 8.08,69.57 7.33,70.33 7.33,71.35 6.45,72.22 v2(5.53,72.22)
  BOTTOM w0.14: v2(7.33,31.85) 7.19,31.99 7.19,32.22 RT177.2
TBTA_USB2_D_N_C: length 4.9
  TOP w0.14: JUSBC1.A7 8.32,65.56 8.41,65.65 10.07,65.65 v4(10.31,65.89) 10.56,66.14 11,66.14 DT16.1 11.35,66.14 11.69,66.14 11.97,65.85 LT12.2
TBTA_USB2_D_N_R: length 47.2
  TOP w0.14: LT12.1 14.2,66.13 14.57,66.13 14.91,65.79 14.91,65.06 v2(14.78,64.93)
  IN2 w0.099: v2(8.51,33.94) 8.47,33.98 8,33.98 7.42,34.56 7.42,34.85 7.11,35.17 6.7,35.17 4.84,37.02 4.84,38.5 6.89,40.55 7.78,40.55 8.14,40.91 8.14,41.27 9.35,42.48 11.51,42.48 12.02,42.99 15.05,42.99 17.68,45.63 17.68,46.59 17.94,46.85 17.94,48.41 17.68,48.67 17.68,60.72 14.97,63.43 14.97,64.75 v2(14.78,64.93)
  BOTTOM w0.081: v2(8.51,33.94) 8.51,33.97 8.74,34.2 8.74,34.71 8.68,34.77 8.68,34.96 8.79,35.07 8.83,35.07 8.91,35.15 8.91,35.31 UT4.L6
TBTA_USB2_D_P_C: length 4.8
  TOP w0.14: JUSBC1.A6 8.31,66.06 8.39,65.98 v4(9.03,65.98) 9.93,65.98 10.42,66.47 11.02,66.47 DT15.1 11.33,66.47 11.69,66.47 11.92,66.7 LT12.3
TBTA_USB2_D_P_R: length 47.3
  TOP w0.14: LT12.4 14.15,66.47 14.7,66.47 15.24,65.93 15.24,65.06 v2(15.37,64.93)
  IN2 w0.099: v2(8.38,34.53) 8.38,34.39 8.19,34.19 8.09,34.19 7.64,34.65 7.64,34.94 7.2,35.38 6.78,35.38 5.05,37.11 5.05,38.41 6.98,40.34 7.87,40.34 8.35,40.82 8.35,41.19 9.43,42.27 11.59,42.27 12.11,42.78 15.13,42.78 17.89,45.54 17.89,46.5 18.15,46.76 18.15,48.5 17.89,48.76 17.89,60.81 15.18,63.52 15.18,64.74 v2(15.37,64.93)
  BOTTOM w0.081: UT4.K6 8.55,35.67 8.55,35.22 8.43,35.1 8.43,34.58 v2(8.38,34.53)
TBTA_VBUS_L:
  vias: v1(4.55,35)
THERMAL_ALERT#: length 8.2
  TOP w0.14: v2(216.09,59.5) 215.94,59.34 215.94,58.38 216.39,57.92 RPH34.3
  BOTTOM w0.14: UV1.M2 217.7,64.44 217.23,63.98 217.23,62.92 216.62,62.32 216.62,60.52 v3(216.28,60.18) 216.09,59.99 v2(216.09,59.5)
THERMATRIP2#: length 6.8
  TOP w0.14: UE3.B34 303.85,19.38 303.92,19.45 303.92,20.02 304.67,20.77 v3(305.43,20.77) 306.3,19.9 CE52.1 RE66.2 307.8,19.44 QE10.1
THERMATRIP3#: length 118.3
  TOP w0.14: QV88.1 v2(209.74,49.82) 209.74,47.78 v1(210.12,47.4) ; RE25.1 295.01,7.55 295.01,8.34 v2(295.28,8.61) 295.47,8.61 295.85,8.99 295.85,9.48 295.77,9.56 UE3.A2
  IN3 w0.091: v2(209.74,49.82) 209.84,49.72 211.33,49.72 229.69,31.36 251.56,31.36 252.52,30.4 253.23,30.4 261.5,22.13 263.42,22.13 263.72,22.43 266.19,22.43 267.37,23.61 v2(275.85,23.61)
  BOTTOM w0.14: v2(275.85,23.61) 276.31,24.08 276.77,24.08 279.22,21.63 281.3,21.63 282.44,20.49 282.44,18.37 282.06,17.99 282.06,15.06 283.1,14.03 283.1,11.38 282.56,10.84 282.56,10.26 284.93,7.89 289.59,7.89 289.7,7.77 295.09,7.77 295.28,7.96 v2(295.28,8.61)
THERMATRIP_GPU#: length 25
  TOP w0.14: v2(206.62,50.15) 207.58,50.15 207.83,49.9 QV88.3 ; v2(217.31,59.5) 217.43,59.38 217.43,59.06 217.29,58.92 RPH34.1
  IN6 w0.099: v2(206.62,50.15) 206.62,51.51 208,52.89 208,53.73 208.67,54.41 208.67,57.43 208.95,57.7 210.6,59.36 214.89,59.36 215.19,59.05 216.87,59.05 v2(217.31,59.5)
  BOTTOM w0.14: UV1.M1 217.7,62.86 216.96,62.11 216.96,59.85 v2(217.31,59.5)
THERMDA: length 0.7
  BOTTOM w0.089: UT1.AB23 31.63,35.46 31.7,35.39 31.87,35.39 UT1.AC23
THSEL_STRAP: length 11.4
  TOP w0.14: v2(302.92,16.59) 303.2,16.88 UE3.B29 ; v2(309.83,16.99) 309.83,16.54 309.42,16.14 RE57.1 309.07,15.5 v3(308.28,14.72)
  IN6 w0.099: v2(302.92,16.59) 303.43,16.59 304.24,17.39 309.43,17.39 v2(309.83,16.99)
TMDS_L_TX0N: length 9.6
  TOP w0.14: JHDMI1.3 12.11,80.09 12.53,80.09 12.76,80.33 12.76,81.5 13.46,82.2 14.42,82.2 14.5,82.29 DV5.6 DV5.5 16.49,82.29 16.57,82.2 16.71,82.2 17.04,82.53 17.49,82.53 RV539.1 18.08,82.53 18.83,82.53 RV532.2
TMDS_L_TX0P: length 9.6
  TOP w0.14: JHDMI1.1 12.1,79.76 12.66,79.76 13.09,80.2 13.09,81.37 13.6,81.87 14.42,81.87 14.5,81.79 DV5.7 DV5.4 16.49,81.79 16.57,81.87 16.85,81.87 17.18,82.2 17.49,82.2 RV539.2 18.07,82.2 18.81,82.2 RV533.2
TMDS_L_TX1N: length 13.5
  TOP w0.076: JHDMI1.6 10.57,81.58 10.71,81.44 11.09,81.44 11.28,81.25 11.28,80.68 11.2,80.6 11.2,80.32 11.28,80.25 11.28,79.71 11.2,79.64 11.2,79.11 11.29,79.02 11.29,79
  TOP w0.14: RV534.2 18.81,80.54 18.1,80.54 RV540.1 17.48,80.56 16.99,80.56 16.85,80.7 16.57,80.7 16.49,80.79 DV5.2 DV5.8 14.5,80.79 14.42,80.7 14.14,80.7 13.81,80.37 13.81,79.6 12.83,78.62 11.41,78.62 11.29,78.74 11.29,79
TMDS_L_TX1P: length 13.5
  TOP w0.076: 10.96,79 10.96,79.02 11.05,79.11 11.05,79.7 11.13,79.78 11.13,80.18 11.05,80.26 11.05,80.67 11.13,80.74 11.13,81.19 11.03,81.29 10.93,81.29 JHDMI1.4
  TOP w0.14: 10.96,79 10.96,78.61 11.28,78.29 12.96,78.29 14.14,79.47 14.14,80.23 14.28,80.37 14.42,80.37 14.5,80.29 DV5.9 DV5.1 16.49,80.29 16.57,80.37 16.71,80.37 16.86,80.23 17.5,80.23 RV540.2 18.05,80.21 18.83,80.21 RV535.2
TMDS_L_TX2N: length 8.6
  TOP w0.14: RV536.2 18.83,84.62 18.08,84.62 RV541.1 17.49,84.63 16.99,84.63 16.85,84.77 16.57,84.77 16.49,84.85 DV4.7 DV4.4 14.5,84.85 14.42,84.77 14.02,84.77 12.35,83.09 12.11,83.09 JHDMI1.9
TMDS_L_TX2P: length 8.7
  TOP w0.14: JHDMI1.7 12.1,82.76 12.48,82.76 14.16,84.44 14.42,84.44 14.5,84.35 DV4.5 DV4.6 16.49,84.35 16.57,84.44 16.71,84.44 16.85,84.3 17.49,84.3 RV541.2 18.07,84.29 18.81,84.29 RV537.2
TMDS_L_TXCN: length 16.6
  TOP w0.076: 10.96,88.82 10.96,88.81 10.97,88.8 11.02,88.8 11.05,88.78 11.05,88.19 11.1,88.13 11.1,87.64 11.02,87.56 11.02,87.26 11.1,87.18 11.1,86.72 11.05,86.67 11.05,86.27 11.1,86.22 11.1,85.61 11.05,85.55 11.05,85.2 11.1,85.15 11.1,84.66 11.02,84.58 10.92,84.58 JHDMI1.12
  TOP w0.14: RV530.2 18.83,86.4 18.08,86.4 RV538.1 17.49,86.41 16.85,86.41 16.71,86.27 16.57,86.27 16.49,86.35 DV4.9 DV4.1 14.5,86.35 14.42,86.27 13.37,86.27 12.68,86.96 12.68,88.86 12.02,89.52 11.38,89.52 10.96,89.1 10.96,88.82
TMDS_L_TXCP: length 16.6
  TOP w0.076: JHDMI1.10 10.57,84.29 10.71,84.43 11.08,84.43 11.25,84.6 11.25,85.21 11.2,85.27 11.2,85.49 11.25,85.54 11.25,86.28 11.2,86.33 11.2,86.61 11.25,86.66 11.25,87.24 11.18,87.32 11.18,87.5 11.25,87.58 11.25,88.19 11.2,88.25 11.2,88.72 11.29,88.8 11.29,88.82
  TOP w0.14: RV531.2 18.81,86.07 18.07,86.07 RV538.2 17.49,86.08 16.99,86.08 16.85,85.94 16.57,85.94 16.49,85.85 DV4.8 DV4.2 14.5,85.85 14.42,85.94 13.23,85.94 12.35,86.83 12.35,88.72 11.88,89.19 11.52,89.19 11.29,88.96 11.29,88.82
TMDS_TX0N: length 42.1
  TOP w0.14: RV532.1 20.29,82.53 21.05,82.53 v2(21.21,82.69) 21.42,82.47 21.62,82.47 RV517.1
  IN6 w0.099: v2(21.21,82.69) 21.63,82.26 22.51,82.26 23.12,81.66 23.12,66.64 24.21,65.54 24.21,63.39 26.66,60.95 26.66,55.3 27.8,54.16 27.8,51.28 28.11,50.97 28.11,48.9 28.66,48.35 29.12,48.35 29.24,48.48 29.24,48.54 28.9,48.87 v2(28.9,48.88)
  BOTTOM w0.14: CV172.1 29.03,48.38 29.03,48.75 v2(28.9,48.88)
TMDS_TX0P: length 42.1
  TOP w0.14: RV533.1 20.3,82.2 21.06,82.2 v2(21.21,82.05) 21.3,82.14 21.61,82.14 RV516.1
  IN6 w0.099: v2(21.21,82.05) 21.21,82.05 22.43,82.05 22.91,81.57 22.91,66.55 24,65.45 24,63.3 26.45,60.86 26.45,55.21 27.59,54.07 27.59,51.19 27.9,50.88 27.9,48.81 28.58,48.14 29.2,48.14 29.49,48.42 v2(29.49,48.88)
  BOTTOM w0.14: CV173.1 29.36,48.35 29.36,48.75 v2(29.49,48.88)
TMDS_TX1N: length 38.9
  TOP w0.14: RV515.1 21.62,80.64 21.3,80.64 v2(21.21,80.73) 21.06,80.58 20.27,80.58 RV534.1
  IN6 w0.099: v2(21.21,80.73) 21.49,80.45 21.79,80.45 22.15,80.09 22.15,64.84 22.15,64.3 24.72,61.73 24.72,57.99 25.44,57.27 25.44,55.29 26.98,53.75 26.98,50.94 27.27,50.66 27.27,50.31 27.15,50.19 v2(27.15,49.86)
  BOTTOM w0.14: CV174.1 27.95,48.44 27.95,49.98 27.67,50.26 27.29,50.26 27.15,50.12 v2(27.15,49.86)
TMDS_TX1P: length 38.9
  TOP w0.14: RV535.1 20.32,80.25 21.11,80.25 v2(21.21,80.15) 21.37,80.31 21.61,80.31 RV514.1
  IN6 w0.099: v2(26.76,50.29) 26.95,50.29 27.06,50.39 27.06,50.57 26.77,50.85 26.77,53.66 25.36,55.08 25.36,55.08 25.23,55.2 25.23,57.18 24.51,57.9 24.51,61.64 21.94,64.21 21.94,64.75 21.94,80 21.71,80.23 21.3,80.23 v2(21.21,80.15)
  BOTTOM w0.14: CV175.1 28.28,48.29 28.28,50.12 27.8,50.59 27.16,50.59 26.85,50.29 26.76,50.29 v2(26.76,50.29)
TMDS_TX2N: length 43.4
  TOP w0.14: RV536.1 20.29,84.63 21.06,84.63 v2(21.18,84.75) 21.28,84.84 RV513.1
  IN6 w0.099: v2(26.62,48.62) 26.78,48.78 26.78,49.3 25.68,50.4 25.68,52.07 25.88,52.26 25.88,52.61 25.7,52.78 24.16,52.78 23.32,53.62 23.32,54.17 22.07,55.42 22.07,61.53 21.11,62.49 21.11,78.56 20.38,79.29 20.38,84.54 20.58,84.75 v2(21.18,84.75)
  BOTTOM w0.14: v2(26.62,48.62) 26.73,48.5 26.73,48.12 CV176.1
TMDS_TX2P: length 43.5
  TOP w0.14: RV512.1 21.41,83.96 v2(21.21,84.16) 21.07,84.29 20.3,84.29 RV537.1
  IN6 w0.099: v2(21.21,84.16) 20.98,84.16 20.91,84.23 20.91,84.45 20.82,84.54 20.67,84.54 20.59,84.46 20.59,79.38 21.32,78.65 21.32,62.58 22.28,61.62 22.28,55.51 23.53,54.25 23.53,53.7 24.24,52.99 25.79,52.99 26.09,52.7 26.09,52.17 25.89,51.98 25.89,50.49 26.99,49.39 26.99,48.84 v2(27.21,48.62)
  BOTTOM w0.14: v2(27.21,48.62) 27.06,48.47 27.06,48.1 CV177.1
TMDS_TXCN: length 43.9
  TOP w0.14: RV519.1 21.64,86.37 21.41,86.37 v2(21.26,86.51) 21.15,86.4 20.29,86.4 RV530.1
  IN6 w0.099: v2(24.79,51.55) 24.65,51.69 24.15,51.69 23.88,51.97 22.19,51.97 21.67,52.49 21.67,53.23 21.96,53.52 21.96,54.34 21.25,55.05 21.25,61.07 20.28,62.04 20.28,78.23 19.56,78.95 19.56,85.48 20.51,86.43 21.18,86.43 v2(21.26,86.51)
  BOTTOM w0.14: v2(24.79,51.55) 24.91,51.67 24.98,51.67 25.56,51.09 25.56,50.36 CV170.1
TMDS_TXCP: length 43.9
  TOP w0.14: RV518.1 21.59,86.04 21.37,86.04 v2(21.26,85.93) 21.12,86.07 20.3,86.07 RV531.1
  IN6 w0.099: v2(21.26,85.93) 20.97,86.22 20.6,86.22 19.77,85.39 19.77,79.04 20.49,78.32 20.49,62.12 21.46,61.16 21.46,55.14 22.17,54.43 22.17,53.43 21.89,53.14 21.89,52.57 22.28,52.18 23.96,52.18 24.24,51.9 24.56,51.9 v2(24.79,52.14)
  BOTTOM w0.14: v2(24.79,52.14) 24.93,52 25.11,52 25.62,51.49 25.89,51.23 25.89,50.33 CV171.1
TOUCH_SCREEN_PD#: length 44
  TOP w0.089: v3(77.14,13.39) 76.67,12.92 v2(76.67,12.9)
  IN2 w0.099: v2(58.02,28.59) 58.02,28.4 61.31,25.11 73.53,25.11 75.18,23.45 75.18,21.57 73.81,20.2 73.81,14.87 75.06,13.63 75.94,13.63 v2(76.67,12.9)
  BOTTOM w0.089: v2(76.67,12.9) 76.67,13.23 76.82,13.38 77.76,13.38 78.09,13.71 UH2.AE44
  BOTTOM w0.127: 74.58,13.45 73.08,13.45 RH510.1 ; v2(58.02,28.59) 58.02,27.79 56.12,25.89
  BOTTOM w0.14: 56.12,25.89 55.77,25.54 DI1.1 ; 74.58,13.45 75.12,12.9 75.3,12.9 75.46,13.06 76.11,13.06 76.26,12.9 v2(76.67,12.9)
TOUCHPAD_INTR#: length 35
  TOP w0.089: v2(87.25,6.86) v1(88.36,5.75) 88.64,5.46 DH1.2
  TOP w0.127: v2(69.89,6.8) 69.78,6.92 69.09,6.92 67.82,8.19 67.31,8.19 v2(66.9,8.59)
  IN5 w0.089: 75.06,8.22 75.71,8.22 76.51,7.42 76.51,7.14 76.72,6.92 77.87,6.92 78.54,7.59 78.99,7.59 79.22,7.36 80.22,7.36 80.84,6.74 82.1,6.74 82.56,7.2 82.56,7.28 82.77,7.5 83.07,7.5 83.75,6.82 85.08,6.82 85.34,6.56 86.94,6.56 v2(87.25,6.86)
  IN5 w0.099: v2(66.9,8.59) 67.32,9.01 68.9,9.01 69.36,8.55 71.54,8.55 71.65,8.66 73.03,8.66 73.48,8.22 75.06,8.22
  BOTTOM w0.089: v2(87.25,6.86) 87.25,6.64 87.47,6.42 87.87,6.42 88.24,6.05 88.24,5.7 88.25,5.69 88.25,5.69 88.46,5.48 88.46,5.48 88.62,5.32 UH2.BC23
  BOTTOM w0.14: v2(69.89,6.8) 69.7,6.61 69.7,5.47 RH547.1
TP_PW_EN: length 60.9
  TOP w0.127: v2(223.01,6.64) UE6.3
  TOP w0.14: RZ32.2 224.99,8.01 224.59,8.01 v3(224.49,7.91) 224.32,7.74 224.32,7.34 223.79,6.8 223.47,6.8 223.31,6.64 v2(223.01,6.64) ; UE4.24 274.12,14.76 v2(273,13.64)
  IN3 w0.091: v2(223.01,6.64) 223.74,6.64 226.25,9.15 231.04,9.15 231.85,9.96 242.73,9.96 242.84,10.08 243.28,10.51 252.85,10.51 254.12,11.79 259.19,11.79 259.58,12.18 262.01,12.18 262.62,12.79 267.23,12.79 269.27,14.83 272.53,14.83 273,14.36 v2(273,13.64)
TPM_GPIO4: length 4.4
  TOP w0.14: RE134.2 v1(154.61,13.81)
  TOP w0.254: RE134.2 RE126.2 154.61,10.77 153.93,10.09 UE1.13
TPM_LPM#: length 10.2
  TOP w0.14: UE1.3 157.84,6.43 RE127.1 158.29,5.8 158.62,5.47 159.51,5.47 160.76,4.23 161.79,4.23 162.14,3.88 162.83,3.88 163.34,4.39 QE17.1 164.85,4.39 v1(165.38,4.92)
TPM_PIRQ#: length 78.8
  TOP w0.127: UE1.18 151.28,8.43 150.69,9.03 150.69,10.57 v2(150.91,10.79)
  TOP w0.14: v2(150.91,10.79) 150.91,11.13 150.67,11.36 RE86.2 149.91,11.5 150.23,11.82 v1(151.13,11.82)
  IN6 w0.089: v2(81.69,9.41) 82.09,9.8 82.73,9.8 83.09,10.17 85.47,10.17 85.92,9.72 88,9.72 88.19,9.91 88.9,9.91 89.05,9.76 91.15,9.76 92.19,10.8 94.98,10.8 95.58,11.4 97.65,11.4 98.12,10.93 99.07,10.93 99.3,11.16 101.98,11.16
  IN6 w0.099: 101.98,11.16 102.41,11.16 102.9,11.65 107.13,11.65 107.8,10.98 112.83,10.98 113.5,11.65 125.94,11.65 126.37,12.08 149.04,12.08 150.33,10.79 v2(150.91,10.79)
  BOTTOM w0.089: UH2.AN38 81.31,9.84 v2(81.69,9.41)
TPM_VDD: length 1.3
  TOP w0.14: 158.13,11.96 v1(158.13,13.29)
U2_BOOT1: length 0.8
  TOP w0.14: v1(169.58,105.34) 169.38,105.14 v2(169.38,104.6)
U2_BOOT2: length 3.4
  BOTTOM w0.14: v3(169.25,114) 168.61,113.36 168.61,112.15 169.43,111.32 PR1019.1
U2_LGATE1: length 12.9
  TOP w0.14: v2(182.31,111.01) v1(182.89,111.01)
  IN6 w1.016: 172.1,106.69 172.78,106.69 172.98,106.88 175.85,106.88 176.53,107.56 176.53,110.44 177.23,111.13 180.72,111.13 180.85,111.01
  vias: v2(170.69,106.93) v2(171.28,106.93) v2(181.67,111.01)
U2_LGATE2: length 16.9
  TOP w0.14: v2(182.44,118.44) v1(182.44,119.21)
  IN6 w1.016: 172.14,109.02 172.47,109.34 172.47,112.09 174.12,113.74 180.09,113.74 181.04,114.69 181.04,117.74 181.2,117.9
  vias: v2(171.18,109.22) v2(171.18,108.63) v2(181.8,118.44)
U2_LGATE3: length 16.3
  TOP w0.14: v2(182.18,103.51) v1(183.14,103.51)
  IN6 w1.016: 180.28,103.26 179.83,103.7 177.1,103.7 176.17,102.78 176.17,95.16 175.46,94.44 174.06,94.44 173.57,94.93
  vias: v2(172.72,95.39) v2(172.71,94.8) v2(181.55,103.51)
U2_PHASE1: length 15.5
  TOP w0.14: v2(166.75,113.29) v1(166.75,112.35)
  IN1 w1.016: 172.34,110.44 172.34,106.43 171.9,105.99
  IN4 w0.254: v2(170.8,105.74) 170.8,106 170.14,106.66 170.14,107.84 166.75,111.22 v2(166.75,113.29)
  BOTTOM w0.254: PR1023.1 v2(166.75,113.29)
  vias: v2(170.21,105.74) v2(173.93,111.01) v2(174.56,111.01)
U2_PHASE2: length 19.7
  TOP w0.14: v2(174.24,118.88) 173.62,118.88 v1(173.46,119.05)
  IN4 w0.254: v2(165.86,113.29) 165.86,113.55 166.18,113.86 168.53,113.86 170.5,111.9 v2(170.5,110.63)
  IN6 w1.016: 170.75,111.43 170.75,114.01 172.58,115.83 175.39,115.83 176.05,116.49 176.05,117.95 175.55,118.45
  BOTTOM w0.254: PR1022.1 v2(165.86,113.29)
  vias: v2(171.13,110.63) v2(174.69,118.44)
U2_PHASE3: length 19.2
  TOP w0.14: v2(164.97,113.29) v1(164.97,113.99)
  IN4 w0.254: v2(164.97,113.29) 164.97,113.77 165.51,114.31 168.8,114.31 171.83,111.27 171.83,106.63 172.66,105.8 172.66,104.01 173.09,103.58 v2(173.86,103.58)
  BOTTOM w0.254: PR1020.1 v2(164.97,113.29)
  vias: v2(172.15,99.58) v2(172.72,99.39) v2(174.5,103.58)
U2_PWM3: length 14.7
  TOP w0.14: v2(170.82,107.52) 170.82,107.87 v1(170.55,108.14)
  IN2 w0.254: v2(173.95,97.18) 173.95,100.05 172.29,101.71 172.29,106.66 171.44,107.52 v2(170.82,107.52)
  BOTTOM w0.254: PU1001.5 173.78,97 v2(173.95,97.18) ; PU1000.22 170.34,107.4 170.46,107.52 v2(170.82,107.52)
U2_UGATE1: length 9.3
  TOP w0.127: v2(168.59,104.16) 169.2,103.55 v1(169.48,103.55)
  IN1 w1.016: 174.45,108.29 173.8,107.64 173.8,105.67 171.77,103.64 169.33,103.64
  vias: v2(168.59,104.77) v2(174.44,109.74) v2(174.44,109.1)
U2_UGATE2: length 8.3
  TOP w0.14: v2(174.16,117.17) v1(173.29,117.17)
  IN6 w1.016: 169.27,112.07 169.27,114.34 172.23,117.29 173.23,117.29
  vias: v2(168.48,111.25) v2(168.48,110.67) v2(174.75,117.17)
U2_UGATE3: length 0.8
  TOP w0.14: v1(173.04,98.76) 173.36,99.08 v2(173.36,99.39)
  vias: v2(173.17,99.96) v2(173.86,102.62) v2(174.5,102.62)
UART2_RXD: length 82.7
  TOP w0.152: RH562.2 66.97,12.29 66.88,12.29 66.79,12.38 66.79,13.32 v2(66.99,13.52)
  IN2 w0.089: 75.24,8.92 75.25,8.93 75.27,8.93 75.31,8.97 75.47,8.97 75.48,8.96 76.91,8.96 76.94,8.98
  IN2 w0.107: v2(66.99,13.52) 66.79,13.32 66.79,11.94 69.35,9.38 70.3,9.38 70.54,9.14 72.09,9.14 73.05,8.17 74.5,8.17 75.24,8.92 ; 76.94,8.98 v2(77.27,9.31)
  IN3 w0.099: v2(66.99,13.52) 66.72,13.79 66.72,14.01 66.58,14.15 66.58,20.6 68.33,22.35 73.21,22.35 73.61,22.75 73.61,23.09 v2(73.76,23.24)
  BOTTOM w0.089: UH2.AR45 77.36,9.16 77.27,9.25 v2(77.27,9.31)
  BOTTOM w0.152: v2(73.76,23.24) 73.62,23.37 73.62,26.78 77.06,30.22 83.07,30.22 89.74,36.89 94.82,36.89 96.78,38.85 100.33,38.85 105.36,43.87 105.36,49.73 104.78,50.31 104.23,50.31 103.99,50.55 JUART.3
UART2_TXD: length 86.8
  TOP w0.152: RH561.2 66.74,11.96 66.74,11.96 66.46,12.24 66.46,13.38 v2(66.37,13.47)
  IN2 w0.089: 75.39,8.77 80.11,8.77 v2(80.76,9.42)
  IN2 w0.107: v2(66.37,13.47) 66.57,13.27 66.57,11.87 69.27,9.18 70.21,9.18 70.45,8.94 72,8.94 72.97,7.97 74.59,7.97 75.39,8.77
  IN3 w0.099: v2(66.37,13.47) 66.53,13.63 66.53,13.93 66.39,14.07 66.39,20.68 68.26,22.54 73.13,22.54 73.42,22.83 73.42,22.99 v2(73.17,23.24)
  BOTTOM w0.089: UH2.AR39 80.36,9.02 v2(80.76,9.42)
  BOTTOM w0.152: JUART.2 103.98,49.75 104.22,49.98 104.64,49.98 105.03,49.59 105.03,44.01 100.19,39.18 96.64,39.18 94.68,37.22 89.6,37.22 82.93,30.55 76.93,30.55 73.29,26.92 73.29,23.36 v2(73.17,23.24)
UARTT0_TX: length 281.7
  TOP w0.14: v2(312.52,7.88) v1(312.01,7.37)
  IN6 w0.099: v2(79.95,6.99) 80.59,6.35 81.38,6.35 82.04,5.7 82.04,4.62 82.29,4.37 86.48,4.37 86.7,4.14 87.83,4.14 88.49,4.8 90.96,4.8 91.69,5.53 92.14,5.53 92.25,5.42 95.34,5.42 96.12,6.21 97.1,6.21 97.66,6.77 99.01,6.77 99.57,7.33 101.42,7.33 102.88,8.79 104.17,8.79 105.25,7.71 106.75,7.71 107.14,8.1 109.37,8.1 110.45,9.17 117.65,9.17 118.31,9.83 126.62,9.83 127.39,9.06 134.31,9.06 135.33,10.08 146.25,10.08 149.62,6.7 156.56,6.7 157.84,7.99 169.64,7.99 171.43,9.79 174.17,9.79 174.63,9.34 186.66,9.34 187.96,10.64 199.3,10.64 200.15,9.79 210.62,9.79 213.24,7.18 226.44,7.18 227.94,5.68 245.12,5.68 246.11,6.66 246.4,6.66 256.47,6.66 257.18,7.37 262.33,7.37 262.76,6.94 271.39,6.94 272.14,6.19 282.9,6.19 283.99,7.27 305.94,7.27 306.47,7.81 306.47,8.45 306.9,8.88 311.53,8.88 v2(312.52,7.88)
  BOTTOM w0.089: v2(79.95,6.99) 79.4,7.54 79.17,7.54 78.94,7.77 78.77,7.77 78.75,7.78 78.37,7.78 UH2.AV44
  BOTTOM w0.14: JDEG1.9 307.11,31.86 307.33,32.08 311.5,32.08 314.1,29.49 314.1,27.29 311.84,25.03 311.84,19.07 312.73,18.18 312.73,8.35 312.52,8.15 v2(312.52,7.88)
UG_3V: length 12.5
  TOP w0.14: v2(342.71,22.81) v3(341.73,22.81)
  IN1 w1.016: 342.08,23.63 341.69,24.01 337.5,24.01 335.66,22.17 331.47,22.17
  vias: v2(330.2,22.42) v2(330.2,21.79) v2(343.16,22.42)
UG_5V: length 25.8
  TOP w0.14: v2(342.49,18.55) v1(341.42,18.55)
  IN1 w1.016: 343.92,17.41 344.17,17.15 345.57,17.15 347.83,14.89 347.83,11.6 345.63,9.41 339.79,9.41 337.76,11.44 333.06,11.44
  vias: v2(331.92,10.87) v2(331.92,10.23) v2(343.09,18.55)
UPD_GPU_SMBCLK: length 486.6
  TOP w0.14: v2(295.97,19.15) 296.02,19.2 UE3.B49 ; v2(14.52,41.95) 14.52,41.12 RT201.1 12.83,40.7 12.83,41.18 12.38,41.62 11.77,41.62 QT1.4 ; RE95.1 295.48,32.46 295.21,32.18 295.21,31.35 295.35,31.21 295.59,31.21 295.73,31.07 295.73,30.76 295.61,30.63 295.33,30.63 295.21,30.5 295.21,30.22 295.49,29.93 295.49,27.99 295.35,27.85 294.72,27.85 294.58,27.71 294.58,27.47 294.7,27.34 295.5,27.34 295.63,27.21 295.63,26.97 295.5,26.84 v3(294.02,26.84) 293.69,26.84 293.56,26.72 293.56,25.83 293.69,25.7 293.99,25.7 294.12,25.83 294.12,26.26 294.25,26.39 294.48,26.39 294.6,26.26 294.6,25.83 294.73,25.7 295.04,25.7 295.16,25.83 295.16,26.08 295.35,26.27 v2(295.81,26.27)
  IN1 w0.099: v2(209.4,61.2) 209.4,59.22 208.08,57.9 208.08,49.62 212.65,45.05 224.74,45.05 224.87,45.18 224.87,46.06 224.99,46.19 225.21,46.19 225.32,46.07 225.32,45.18 225.45,45.05 225.67,45.05 225.8,45.18 225.8,46.09 225.9,46.19 226.11,46.19 226.21,46.09 226.21,45.14 226.31,45.04 226.51,45.04 226.61,45.14 226.61,46.09 226.7,46.19 226.92,46.19 227.01,46.09 227.01,45.13 227.11,45.03 227.31,45.03 227.41,45.13 227.41,46.09 227.51,46.19 227.71,46.19 227.81,46.09 227.81,45.13 227.91,45.03 228.12,45.03 228.22,45.13 228.22,46.08 228.33,46.19 228.5,46.19 228.61,46.08 228.61,45.13 228.71,45.03 228.91,45.03 229.01,45.13 229.01,46.06 229.12,46.18 229.29,46.18 229.4,46.06 229.4,45.13 229.5,45.03 229.7,45.03 229.8,45.13 229.8,46.08 229.92,46.19 230.11,46.19 230.24,46.06 230.24,45.16 230.37,45.03 233.49,45.03 247.71,30.8 251.61,30.8 261.76,20.66 267.08,20.66 269.36,22.94 281.3,22.94 281.87,23.51 286.44,23.51 286.74,23.21 288.1,23.21 290.85,25.97 295.5,25.97 v2(295.81,26.27) ; v2(290.02,19.2) 290.29,18.93 293.47,18.93 294.11,19.57 295.85,19.57 296.06,19.35 296.06,19.24 v2(295.97,19.15)
  IN3 w0.091: v2(14.52,41.95) 14.52,41.64 15.36,40.79 15.36,37.12 16.37,36.12 16.37,27.02 15.82,26.47 v2(15.82,25.65)
  IN6 w0.099: v2(290.02,19.2) 289.55,19.67 285.26,19.67 284.71,19.12 283.49,19.12 281.28,16.91 278.77,16.91 277.49,15.64 272.6,15.64 272.5,15.54 272.5,14.84 272.39,14.73 272.22,14.73 272.11,14.84 272.11,15.54 272.01,15.64 271.81,15.64 271.71,15.54 271.71,14.36 271.6,14.25 271.43,14.25 271.32,14.36 271.32,15.54 271.22,15.64 271.02,15.64 270.92,15.54 270.92,14.37 270.8,14.26 270.64,14.26 270.52,14.37 270.52,15.54 270.42,15.64 269.86,15.64 265.95,11.73 263.25,11.73 261.72,10.21 250.67,10.21 249.5,11.39 237.11,11.39 236.66,10.94 235.06,10.94 234.56,11.43 231,11.43 230.83,11.43 228.86,13.4 224.78,13.4 224.62,13.24 215.85,13.24 215.69,13.4 201.08,13.4 200.58,13.9 186.68,13.9 186.22,13.44 169.4,13.44 168.83,12.87 160.51,12.87 159.68,13.7 125.15,13.7 124.9,13.45 101.52,13.45 101.42,13.56 99.06,13.56 98.36,14.26 96.36,14.26 96.12,14.5 92.15,14.5 91.64,13.99 85.84,13.99 85.4,14.44 78.35,14.44 78.05,14.14 74.56,14.14 72.2,16.5 69.06,16.5 67.31,18.25 67.31,18.5 v2(67.04,18.77) 67.27,19 67.27,19.66 66.41,20.51 65.25,20.51 64.4,21.37 64.4,21.65 61.7,24.35 58.18,24.35 55.55,26.98 50.08,26.98 49.53,27.54 45.82,27.54 43.81,29.56 35,29.56 34.46,29.02 33.97,29.02 32.71,27.76 22.16,27.76 21.49,27.09 18.64,27.09 17.63,26.07 16.25,26.07 v2(15.82,25.65)
  BOTTOM w0.127: v2(209.4,61.2) 207.3,61.2 206.45,60.35 QV21.6
  BOTTOM w0.14: v2(295.81,26.27) 295.78,26.27 295.83,26.22 295.84,26.22 296.79,25.26 296.79,23.25 296.07,22.53 296.07,19.25 v2(295.97,19.15) ; v2(67.04,18.77) 67.04,18.77 QE18.3
