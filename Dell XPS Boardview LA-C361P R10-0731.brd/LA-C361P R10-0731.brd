# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_5085: length 63.9
  TOP w0.254: RP20.6 310.71,27.24 v2(310.44,26.97) 310.21,27.2 RP20.5 ; RP20.8 311.71,27.24 v2(311.47,27) 311.21,27.25 RP20.7
  TOP w0.305: CE20.1 291.53,14.63 UE3.A58 ; v2(296.25,11.46) 296.02,11.24 UE3.B3 ; UE3.A41 298.77,21.29 298.81,21.32 298.81,23.02 CE27.1 ; UE3.A22 306.36,14.13 CE18.1 ; 304.59,22.27 304.59,21.71 303.02,20.15 UE3.B35 ; CE25.1 306.19,15.95 304.97,15.95 304.79,16.13 UE3.A26 ; UE3.A52 293.17,17.63 293.07,17.73 291.22,17.73 CE28.1 ; 300.27,9.06 UE3.A11
  TOP w0.508: v2(299.4,22.41) 299.4,22.64 299.09,22.96 CE27.1 ; v2(294.48,8.24) 294.22,7.98 CE26.1 ; RE94.2 298.64,32.3 v2(298.26,32.69) 297.42,32.69 RE95.2 ; CE28.1 291.16,17.79 v2(291.67,18.3) ; RE21.2 295.38,5.04 294.83,5.58 v2(294.83,5.8) 294.83,6.02 295.11,6.3 RE25.2 RE20.2 ; RE23.2 289.66,20.11 289.32,19.77 v2(289.32,19.21) ; CE20.1 CE21.1 v2(289.64,14.94) ; v2(306.38,12.58) CE19.1 CE18.1 ; v2(302.05,4.55) 301.78,4.28 RE19.2 ; v2(301.61,8.17) 301.61,7.57 CE24.1 301.42,7.37 RE67.1 300.56,7.95 300.27,8.23 300.27,9.06 ; v2(294.4,25) 294.4,24.89 294.9,24.4 RE22.2 ; RE99.2 299.09,26.78 298.96,26.91 298.96,26.93 v2(298.5,27.39) 298.02,26.91 RE59.1 ; RE41.1 v2(308.92,10.98) ; RE65.1 RE63.1 309.53,27.28 v2(309.53,27.12) ; RE18.1 RE17.1 289.98,16.77 289.64,17.12 v2(289.56,17.12) ; RE60.1 312.99,26.87 v1(312.24,26.12) v2(310.44,26.12) ; CE25.1 306.38,16.35 v2(306.77,16.75) ; RE66.1 307.57,18.75 v2(307.57,18.37) ; RE64.1 v2(307.02,27.07)
  IN1 w0.508: v2(298.26,32.69) 298.45,32.5 298.45,27.44 v2(298.5,27.39)
  IN2 w0.508: v2(298.5,27.39) 298.17,27.39 296.85,26.07 296.47,26.07 295.4,25 v2(294.4,25)
  IN3 w0.508: v2(302.05,4.55) 302.05,6.55 301.94,6.65 301.94,7.84 v2(301.61,8.17)
  vias: v2(286.89,6.45) v2(287.48,6.45) v2(305.25,23.31) v2(305.25,22.61)
+3VALW_23017: length 20.8
  TOP w0.457: CE55.1 278.53,9.32 UE4.5
  TOP w0.508: 277.7,7.95 277.7,6.23 277.23,5.76 v1(275.72,5.76) 273.93,5.76 272.83,6.86 272.83,9.61 271.54,10.91 271.54,14.58 RE72.1 RE71.1 ; RE76.1 283.54,17.51 v2(283.67,17.64) ; RE73.1 v2(283.54,13.08)
  vias: v2(277.85,9.22) v2(277.85,8.58)
+3VALWP: length 41.3
  TOP w0.254: PR401.1 v2(348.87,23.57)
  BOTTOM w0.254: v2(325.95,24.33) 325.95,25.79 328.49,28.33 329.95,28.33 330.58,28.96 335.66,28.96 339.04,32.34 346.06,32.34 349.57,28.84 349.57,25.98 ; 349.57,25.98 349.57,24.27 v2(348.87,23.57) 348.88,23.55 PC401.1 ; 349.57,25.98 347.08,25.98 345.5,24.41 PR428.1
  vias: v1(327.89,26.77)
+3VLP: length 144.5
  TOP w0.127: v2(313.27,31.07) 313.27,30.54 v1(313.49,30.32)
  TOP w0.508: v2(329.14,78.47) 329.43,78.47 329.78,78.11 D122.2 ; RE43.2 287.26,16.72 v2(286.68,17.31)
  IN3 w0.508: v2(349.57,22.55) 349.57,23.85 348.18,25.23 348.18,29.86 345.08,32.97 340.16,32.97 338.61,31.41 323.19,31.41 320.71,28.94 316.51,28.94 314.38,31.07 v2(313.27,31.07)
  IN4 w0.508: v2(313.27,31.07) 312.15,31.07 311.33,31.9 305.42,31.9 303.86,30.34 299.7,30.34 297.16,27.81 297.16,25.88 v2(296.3,25.02)
  IN6 w0.508: v2(313.27,31.07) 313.64,31.44 313.64,33.63 314.17,34.16 314.17,37.33 317.36,40.51 317.36,42.48 318.61,43.73 320.35,43.73 322.48,45.87 322.48,50.67 325.3,53.49 325.3,54.31 326.8,55.82 326.8,59.73 327.97,60.9 327.97,69.99 326.71,71.26 326.71,75.41 329.14,77.84 v2(329.14,78.47)
  BOTTOM w0.254: PR400.1 349,21.98 v2(349.57,22.55)
  BOTTOM w0.508: v2(286.68,17.31) 286.01,17.97 286.01,20.48 288.96,23.43 289.79,23.43 290.25,23.88 295.16,23.88 v2(296.3,25.02)
+3VS: length 699.3
  TOP w0.254: PR1114.1 113.92,112.66 v2(113.86,112.72)
  TOP w0.381: v2(111.01,6.79) 111,6.79 110.68,6.47 UH14.5 ; v2(63.07,3.26) 63.07,3.12 62.56,2.61 RH572.2
  TOP w0.508: v2(76.9,21.57) 75.81,20.48 RH535.2 ; RH525.1 121.36,54.23 121.76,53.83 v2(122.04,53.83) ; RE100.1 98.08,32.57 98.69,31.96 v2(98.91,31.96) ; RF1.1 v2(234.29,50.11) ; RE83.1 321.57,36.94 v2(321.82,36.69) ; v2(113.58,48.8) 113.35,48.8 113.06,48.51 113.06,47.84 113.65,47.24 113.65,40.5 110.83,37.68 103.66,37.68 v2(102.12,36.14) 101.7,35.72 RE81.1 ; RD4.1 248.51,18.79 248.15,19.16 245.83,19.16 244.35,17.67 244.35,14.99 ; RF3.1 v2(231.08,51.49) ; RE101.1 v2(319.71,39.24) ; v2(82.3,18.55) 82.08,18.33 82.08,18.09 RH527.2 ; RV121.1 v2(17.4,78.94) ; v2(249.71,52.78) 249.35,53.13 PR704.1 ; v2(41.37,23.65) 39.67,23.65 QZ9.3 39.19,23.17 CZ43.1 ; v2(348.76,40.85) 348.76,40.36 344.03,35.63 344.03,34.13 342.49,32.6 339.33,32.6 338.63,33.3 337.94,33.3 336.93,34.31 335.32,34.31 334.52,33.51 334.52,32.22 334.05,31.75 326.4,31.75 325.77,32.38 325.77,35.12 v2(326.01,35.37) ; RH518.2 94.45,11.88 94.79,12.23 v2(94.79,12.64) ; v2(154.01,16.9) 154.01,17.53 152.99,18.56 RD3.1 ; v2(94.08,13.75) 93.96,13.88 93.96,13.94 93.71,14.18 CH188.1 ; v2(161.67,11.15) 161.67,11.44 161.23,11.88 160.15,11.88 160.12,11.86 160.11,11.86 159.82,11.57 RE129.1 ; RH85.2 106.66,6.35 v2(107.11,6.8) ; RD5.1 249.77,24.6 v2(250,24.84) ; RE52.1 v2(309.25,13.28)
  IN1 w0.381: 109.42,5.86 109.42,2.52 109.12,2.22 106.86,2.22 106.39,1.75 v2(105.67,1.75)
  IN1 w0.508: v2(41.37,23.65) 42.22,22.8 45.87,22.8 46.02,22.96 46.14,23.07 47.8,23.07 48.79,24.06 49.35,24.06 50.39,23.02 53.68,23.02 54.59,23.93 56.78,23.93 v2(59.03,21.68) 58.7,21.68 58.37,21.34 58.37,19.77 59.03,19.11 59.82,19.11 60.87,18.06 63.36,18.06 63.97,18.67 66.25,18.67 66.78,18.14 68.81,18.14 v2(69.34,18.68) ; v2(326.01,35.37) 326.01,32.52 324.42,30.93 322.99,30.93 320.16,28.1 320.16,24.37 311.69,15.91 310.3,15.91 309.96,15.57 309.96,14.37 309.25,13.66 v2(309.25,13.28) ; v2(234.29,50.11) 234.29,46.94 235.98,45.25 240.07,45.25 241.01,44.31 245.71,44.31 v2(249.71,48.31) v2(249.71,52.78) ; v2(63.07,3.26) 63.88,4.07 63.88,5.1 v2(64.87,6.09) 64.32,6.64 62.01,6.64 61.7,6.33 61.22,6.33 61.06,6.18 59.56,6.18 v2(59.53,6.22) ; v2(113.58,48.8) 113.62,48.8 113.65,48.84 113.65,53.52 117.03,56.89 117.03,62.2 122.58,67.76 122.58,68.46 125.93,71.81 125.93,84.53 123.25,87.21 123.25,93 v2(124.16,93.91)
  IN1 w1.016: 251.19,25.22 250.7,25.71 250.7,27.92 248.68,29.94 247.36,29.94 233.13,44.17 212.08,44.17 207.09,49.16 206.16,49.16 204.57,50.75
  IN2 w0.508: v2(113.58,48.8) 113.6,48.83 116.07,48.83 121.07,53.83 v2(122.04,53.83) ; v2(113.86,112.72) 113.86,103.54 114.97,102.42 114.97,101.66 114.57,101.25 114.57,100.21 115.19,99.59 115.19,96.8 115.72,96.26 117.36,96.26 117.96,95.67 120.02,95.67 120.3,95.94 121.57,95.94 123.6,93.91 v2(124.16,93.91)
  IN3 w0.508: v2(41.37,23.65) 41.37,24.22 38.88,26.7 37.77,26.7 36.42,28.06 36.42,28.68 35.9,29.2 35.78,29.2 34.91,30.07 33.17,30.07 32.22,29.12 29.63,29.12 27.92,27.41 27.92,27.11 27.45,26.64 24.49,26.64 23.89,27.24 23.89,27.64 22.83,28.7 21.21,28.7 19.78,30.13 19.78,37.85 17.73,39.91 v2(16.35,39.91) 16.33,39.91 17.25,40.82 17.25,44.63 18.49,45.87 18.49,48.5 19.46,49.48 22.03,49.48 23.37,50.81 23.37,51.94 24.43,53 25.39,53 25.76,53.36 25.76,54.49 25.17,55.08 25.17,57.44 24.51,58.1 24.51,61.91 23.48,62.94 22.54,62.94 20.95,64.53 20.95,65.47 18.96,67.46 18.96,75.82 17.4,77.38 v2(17.4,78.94) 17.4,79.33 16.5,80.24 16.5,87.65 v2(17.6,88.75) 16.52,89.83 v2(16.52,91.96) ; v2(233.67,60.32) 233.27,59.93 v2(233.19,59.93) 230.26,59.93 229.26,58.92 229.26,58.43 227.72,56.89 226.63,56.89 226.16,56.42 226.16,50.63 226.86,49.94 229.81,49.94 231.08,51.2 v2(231.08,51.49) 232.91,51.49 v2(234.29,50.11) ; v2(172.76,27.75) 170.35,25.34 170.35,18.36 170.66,18.04 v2(170.66,16.86)
  IN4 w0.508: v2(170.66,16.86) 170.66,17.83 170.18,18.31 155.43,18.31 v2(154.01,16.9)
  IN4 w1.524: 299.01,31.66 298.98,31.63 298.83,31.63 298.17,30.97 296.5,30.97 296.11,30.59 296.09,30.59 295.38,29.88 295.38,29.07 294.39,28.08 294.39,27.34 291.64,24.6 289.69,24.6 288.33,23.24 278.87,23.24 277.83,22.2 275.46,22.2 270.94,17.67 266.93,17.67 266.84,17.76 261.71,17.76 260.1,19.38 260.1,23.14 258.17,25.07 252.93,25.07
  IN5 w0.381: v2(82.3,18.55) 82.3,18.26 82.49,18.07 83.41,18.07 84.28,18.93 85.64,18.93 86.32,19.62 86.74,19.62 88.65,21.52 88.65,22.23 91.67,25.26 95.31,25.26 96.22,26.16 96.22,29.27 v2(98.91,31.96) 98.91,32.93 v2(102.12,36.14)
  IN5 w0.508: v2(102.68,6.82) 102.71,6.79 v2(103.46,6.79) 103.46,7.13 103.73,7.41 105.69,7.41 106.3,6.8 v2(107.11,6.8) 108.4,6.8 109.87,8.28 v2(110.95,8.28) 111.01,8.21 v2(111.01,6.79)
  IN6 w0.508: v2(252.72,23.78) 252.72,25.57 253.43,26.29 253.43,29.69 250.99,32.13 250.99,47.02 v2(249.71,48.31)
  BOTTOM w0.152: v2(94.08,13.75) 94.07,13.77 94.04,13.77 UH2.AD13
  BOTTOM w0.254: v2(59.53,6.22) 59.11,6.64 59.11,6.88 57.98,8.01 57.98,9.31 58.37,9.71 RH587.2
  BOTTOM w0.305: 249.18,26.35 249.18,25.24 249.58,24.84 v2(250,24.84) ; v2(161.67,11.15) 161.77,11.06 JKB.4 ; JDIMM1.255 172.89,27.37 172.89,27.63 v2(172.76,27.75)
  BOTTOM w0.381: RZ38.2 348.49,42.68 348.76,42.41 348.76,41.73 348.76,41.73 ; QV14.2 18.16,87.18 RV122.2 ; CD47.1 254.89,6.25 UD2.5 ; RH91.1 v2(105.67,1.75) ; QX1.5 17.02,92.21 16.77,91.96 v2(16.52,91.96) 16.26,91.96 16,92.21 QX1.2 ; v2(63.07,3.26) 63.07,2.9 62.76,2.6 62.31,2.6 61.52,3.39 RH569.2
  BOTTOM w0.508: PR609.1 294.23,26.3 294.74,26.81 294.77,26.81 295,27.03 295,29.37 294.97,29.37 294.97,30.16 294.98,30.16 294.98,32.03 296.13,33.18 297.42,33.18 297.82,33.57 301.77,33.57 302.21,33.13 v2(302.21,31.74) ; 69.34,19.49 70.05,20.2 RH511.2 ; 69.34,19.49 69.34,19.57 68.46,20.46 RE136.1 67.69,20.25 QE18.5 ; 69.34,19.49 v2(69.34,18.68) ; RH512.2 69.47,14.17 v2(69.28,14.36) 68.54,14.36 67.74,15.15 RE137.1 67.69,16.7 QE18.2 ; CD47.1 254.89,6.55 255.36,7.02 v2(255.36,8.15) ; v2(59.03,21.68) 59.12,21.76 DV12.5 ; v2(69.29,11.88) RH551.1 ; v2(124.16,93.91) 123.95,93.91 123.57,94.28 RH5.1 ; RZ28.1 347.73,37.35 348.76,38.38 v2(348.76,40.85) 348.76,41.73 ; RD10.1 v2(256.27,2.87) ; RH510.2 71.87,13.07 71.4,12.6 v2(71.4,12.49) ; v2(17.6,88.75) 18.16,88.2 QV14.2
  vias: v1(72.52,18.84) v2(71.58,1.76) v2(72.26,1.76) v2(72.8,7.22) v2(73.38,7.12) v2(73.47,13.03) v2(172.89,9.37) v2(173.2,8.85) v2(173.53,9.37) v2(200.25,54.9) v2(245.45,15.58) v2(246.04,15.58) v2(246.67,15.58) v2(252.69,23.16) v2(302.18,31.05) v2(302.72,31.38) v2(309.94,37.79) v2(309.94,37.16) v2(326.01,36.06)
+3VS_CAM: length 89.3
  TOP w0.127: v1(92.14,35.75) 92.67,36.28 v2(92.83,36.28)
  TOP w0.508: RZ37.2 45.89,25.9 CZ44.1 46.94,25.83 53.49,25.83 v2(54.12,26.45)
  IN1 w0.508: v2(54.12,26.45) 54.12,26.02 54.32,25.82 58.49,25.82 59.53,24.77 67.06,24.77 71.76,29.48 72.78,29.48 74.11,30.81 79.45,30.81 81.76,33.13 84.76,33.13 87.73,36.1 92.36,36.1 92.36,36.1 92.65,36.1 v2(92.83,36.28)
  IN6 w0.508: v2(60.83,31.7) 60.83,31.95 61.47,32.58 89.13,32.58 v2(92.83,36.28)
  BOTTOM w0.254: JEDP1.22 61.05,31.91 v2(60.83,31.7)
+3VS_CR: length 13.6
  TOP w0.127: v1(326.38,34.27) 326.73,34.63 v2(326.92,34.63)
  BOTTOM w0.203: UR1.27 336.61,36.68 ; 330.47,34.92 330.84,34.92 331.39,35.48 UR1.11
  BOTTOM w0.381: 336.61,36.68 336.9,36.39 337.73,36.39 337.74,36.38
  BOTTOM w0.508: v2(342.52,35.82) 342.52,33.99 341.62,33.09 RR1.1 RR9.2 ; 330.47,34.92 330.2,34.65 CR1.1 328.36,34.65 CR4.1
  vias: v2(326.85,35.24) v2(343.02,36.23)
+3VS_FFS: length 6.8
  TOP w0.305: 232.12,54.06 231.76,54.42 UF1.14 ; UF1.1 CF2.1 ; UF1.7 227.86,54.92 227.23,54.29 v1(227.23,54.06) 227.23,53.91 227.54,53.59 v2(227.7,53.59) 227.94,53.59 228.11,53.75 228.11,54.25 228.27,54.42 UF1.8
  TOP w0.508: CF2.1 230.7,57.59 v2(230.39,57.29)
  vias: v2(232.44,53.91) v2(232.96,53.63)
+3VS_TP: length 119.7
  TOP w0.381: QE2.2 QE2.5
  TOP w0.508: 227.27,13.85 228.28,13.85 229.43,12.71 229.43,10.68 224.28,5.53 221.62,5.53 220.27,6.88 v2(220.27,8.64) ; RE26.1 RE24.1 301.88,24.82 v2(301.87,24.84)
  IN3 w0.508: v2(291.46,22.79) 290.42,21.75 282.22,21.75 279.6,19.14 278.75,19.14 278.31,18.69 278.31,18.22 276.01,15.92 268.82,15.92 266.78,13.88 261,13.88 260.89,13.77 256.95,13.77 256.73,13.55 254.08,13.55 252.37,11.83 243.06,11.83 242.29,11.06 231.41,11.06 230.59,10.25 221.92,10.25 220.32,8.64 v2(220.27,8.64)
  IN6 w0.508: v2(301.87,24.84) 301.84,24.86 301.84,25.12 301.36,25.6 300.56,25.6 299.38,26.78 297.97,26.78 297.41,26.22 297.41,24.95 296.62,24.17 294.93,24.17 294.3,23.54 292.21,23.54 v2(291.46,22.79)
  BOTTOM w0.305: 216.78,10.46 216.66,10.58 216.66,12.74 JTP.8
  BOTTOM w0.508: 216.78,10.46 217.32,9.91 219,9.91 v2(220.27,8.64)
  vias: v1(219.05,13.85)
+3VS_TPM: length 24.5
  TOP w0.254: v2(153.43,10.78) UE1.14 ; CE12.1 150.14,6 150.79,6 151.22,6.43 UE1.22
  TOP w0.508: CE12.1 149.8,4.83 CE14.1 150.05,3.53 v2(149.75,3.22) ; RE128.1 156.13,12.2 RE134.1 155.53,13.99 155.13,14.39 152.46,14.39 151.96,13.88 v3(151.96,13.48) 151.96,11.25 152.1,11.11 152.1,10.53 151.55,9.98 v2(151.51,9.98) ; v2(160.08,3.76) 160.41,3.43 QE17.3 ; v2(148.94,9.59) 148.94,10.35 149.14,10.55 RE86.1 148.97,11.53 RE121.2 ; v2(153.54,3.68) 153.83,3.68 154.23,3.28 RE77.1 ; v2(159.9,7.18) 159.65,6.93 RE14.1 ; CE13.1 153.62,11.27 153.43,11.08 v2(153.43,10.78)
+3VS_TPM_VSB: length 7.5
  TOP w0.254: 157.33,5.43 UE1.1
  TOP w0.508: v2(158.24,4.2) CE11.1 157.99,5.22 157.54,5.22 157.33,5.43
  BOTTOM w0.508: RE141.2 v3(154.88,5.09) 157.35,5.09 v2(158.24,4.2)
+3VS_TS: length 10.9
  BOTTOM w0.762: RZ26.2 339.52,45.47 CZ29.1 v1(339.35,48.24) 339.35,48.68 338,50.03 334.36,50.03 JTS.1
+3VS_WLAN:
  vias: v1(333.15,99.02) v2(333.5,95.22) v2(333.57,94.5)
+5V_CHGUSB_1: length 4.9
  TOP w0.14: 332.72,69.81 332.51,70.01 330.15,70.01 v1(329.62,69.48)
  BOTTOM w0.254: UI2.12 330.57,65.91 330.77,66.11 331.34,66.11
  vias: v2(331.84,68.06) v2(331.83,67.47) v2(331.83,66.89) v2(331.83,66.3)
+5V_CHGUSB_2:
  vias: v1(23.47,107.73) v2(20.88,105.86) v2(21.46,105.86) v2(22.1,105.86) v2(22.73,105.86) v2(23.79,93.32) v2(24.03,92.78) v2(24.02,92.17) v2(24.45,93.23)
+5VALW: length 374.6
  TOP w0.203: v2(315.79,34.81) 315.51,34.53 314.72,34.53 314.64,34.61 UZ1.4 ; UZ7.4 v2(241.59,2.7)
  TOP w0.254: UN3.4 338.55,102.04 338.76,102.26 v2(338.76,102.59) ; CZ11.1 55.88,5.93 56.08,5.72 UZ4.4 ; UZ17.4 233.3,61.34 v2(233.44,61.2) ; v2(223.97,8.64) 223.97,8.24 223.51,7.78 UE6.4 ; v2(135.54,68.59) 135.15,68.2 UZ16.4 ; UT3.4 15.49,29.48 v2(15.4,29.39)
  TOP w0.305: UZ15.3 180.67,85.01 180.59,85.09 CZ97.1
  TOP w0.356: RP24.5 v2(343.2,104.5) ; RP24.10 v2(339.9,101.9)
  TOP w0.432: LED5.2 v2(348.19,91.79) ; LED2.2 v2(348.08,102.59) ; LED4.2 v2(348.15,95.39) ; LED1.2 v2(348.19,106.19) ; LED3.2 v2(348.17,98.99)
  TOP w0.508: v2(288.8,27.25) 288.04,26.49 v1(288.04,26.12) v2(288.04,25.41) 288.21,25.23 PR603.1 ; UZ10.1 181.11,8.39 CZ54.1 v2(180.91,6.57) ; PR104.2 40.63,32.71 v2(40.63,33.28) ; CZ97.1 v2(180.59,86.6) ; v2(56.58,7.12) 56.39,7.12 55.88,6.61 CZ11.1 ; RE3.1 v2(324.92,115.5) ; v2(105.22,51.35) 105.22,49.79 v2(104.37,48.94)
  IN1 w0.508: v2(135.54,68.59) 135.54,68.85 136.28,69.59 137.75,69.59 138.29,70.14 138.29,73.42 137.85,73.87 137.85,86.04 138.62,86.81 138.62,88.43 139.26,89.06 170.53,89.06 v2(171.22,88.38)
  IN2 w0.508: v2(288.8,27.25) 288.8,27.57 290.29,29.06 290.29,32.27 290.75,32.73 296.43,32.73 297,33.31 300.05,33.31 300.31,33.05 308.23,33.05 308.93,33.75 314.26,33.75
  IN3 w0.508: v2(315.79,34.81) 316.18,34.41 v2(321.59,34.41) ; v2(199.71,57.24) 199.71,56.82 200.69,55.84 203.37,55.84 205.11,57.57 205.11,59.32 206.56,60.77 208.92,60.77 209.31,60.38 220.07,60.38 220.4,60.05 222.63,60.05 223.04,60.46 226.66,60.46 229.48,63.28 235.01,63.28 235.62,62.67 235.62,60.56 235.22,60.16 234.7,60.16 234.61,60.24 234.61,60.24 234.25,60.6 234.25,60.6 233.65,61.2 v2(233.44,61.2) 230.56,61.2 228.4,59.04 228.4,58.7 227.41,57.7 226.28,57.7 225.38,56.8 225.38,53.86 224.94,53.42 224.94,50.99 226.6,49.33 232.5,49.33 233.76,48.07 v2(243.38,48.07)
  IN4 w0.508: 26.68,31.87 27.08,31.48 27.46,31.48 29.72,29.21 33.9,29.21 35.51,30.82 35.51,32.7 37.39,34.58 39.33,34.58 v2(40.63,33.28) ; v2(171.22,88.38) 171.22,88.56 173.06,90.41 176.75,90.41 177.85,89.3 177.85,86.48 178.46,85.87 179.87,85.87 v2(180.59,86.6)
  IN5 w0.508: v2(199.71,57.24) 197.87,57.24 196.78,58.33 196.78,60.17 195.38,61.57 195.38,62.95 193.94,64.39 193.94,81.23 193.08,82.09 183.44,82.09 181.74,83.79 181.74,85.45 v2(180.59,86.6)
  BOTTOM w0.203: v2(288.8,27.25) 288.67,27.38 PU600.12
  BOTTOM w0.254: CZ86.1 181.69,86.27 182.5,86.27 UZ9.3 ; UZ5.4 344.37,41.74 v2(344.81,42.17)
  BOTTOM w0.305: v2(162.73,9) 162.91,9 163.27,9.35 JKB.1
  BOTTOM w0.508: v2(199.71,57.24) 199.25,57.69 RV181.1 ; v2(288.04,25.41) PC607.2 ; v2(254.61,12.2) 254.12,12.7 254.12,30.74 254.51,31.14 254.51,37.77 244.21,48.07 v2(243.38,48.07) ; v2(135.54,68.59) 132.22,68.59 130.57,66.94 127.57,66.94 125.35,64.72 124.93,64.72 121.1,60.89 121.1,56 120.89,55.78 120.89,53.5 120.08,52.69 111.48,52.69 110.15,51.35 v2(105.22,51.35) ; v2(180.59,86.6) 180.64,86.65 CZ86.1 ; v2(104.37,48.94) 104.36,48.95 JUART.1
  vias: v1(239.29,2.78) v1(316.7,3.74) v2(2.34,34.41) v2(2.41,35.63) v2(2.4,35.04) v2(2.92,34.45) v2(3.01,35.65) v2(2.99,35.06) v2(15.73,18.45) v2(16.31,18.71) v2(23.92,89.38) v2(23.89,88.76) v2(23.89,88.17) v2(23.89,87.55) v2(239.65,2.29) v2(240.11,2.75) v2(314.96,33.64) v2(315.55,33.63) v2(316.15,33.63) v2(318.14,5.66) v2(318.14,5.03) v2(318.14,4.39) v2(318.77,5.66) v2(318.77,5.03) v2(318.77,4.39) v2(319.41,5.66) v2(319.41,5.03) v2(319.41,4.39) v2(320.04,5.66) v2(320.04,5.03) v2(320.04,4.39) v2(320.68,5.66) v2(320.68,5.03) v2(320.68,4.39) v2(330.82,61.45) v2(330.84,60.84) v2(331.05,62.48) v2(331.64,62.48)
+5VALWP: length 68.1
  TOP w0.102: v1(320.07,7.36) 323.19,7.36 323.53,7.02
  TOP w0.508: PR402.2 v2(349.56,18.93)
  BOTTOM w0.254: v2(324.61,4.39) 324.61,4.26 326.14,2.74 341.95,2.74 345.95,6.74 345.95,7.69 349.7,11.44 349.7,15.82 348.98,16.53 348.98,18.36 v2(349.56,18.93) 349.56,19.08 PC402.2
  BOTTOM w0.508: v2(328.22,5.98) 328.21,5.99 328.21,9.06 329.44,10.3 329.44,16.14 333.25,19.95 v2(341.89,19.95)
+5VS: length 468.6
  TOP w0.508: RE84.1 321.37,40.34 v2(321.37,40.97) 320.8,41.54 RE105.1 ; v2(59.09,20.02) 60.45,21.38 60.45,22.23 58.97,23.72 57.44,23.72 56.25,24.92 QV9.2 ; RF2.1 v2(227.39,51.57) ; v2(161.1,16.86) 161.1,15.25 164.47,11.88 v2(164.47,10.59) ; v2(117.55,112.92) 118.45,113.83 v2(137.05,113.83) ; v2(103.34,32.3) 103.34,32.29 102.31,31.26 98.14,31.26 97.03,32.37 RE104.1 ; v2(112.78,94.05) 113.77,94.05 PC1364.2 ; 95.19,36.84 95.19,37.15 103.06,45.02 103.06,54.99 103.53,55.46 103.53,68.94 103.93,69.34 104.83,69.34 105.17,69.68 v2(105.17,69.94)
  IN1 w0.254: 139.45,113.88 140.36,114.79 143.82,114.79 145.42,116.39 151.82,116.39 152.43,117 153.96,117 v2(153.99,116.98)
  IN1 w0.508: v2(112.78,94.05) 113.11,94.05 113.77,94.71 113.77,98.22 115.05,99.5 115.05,110.43 v2(117.55,112.92) ; v2(105.17,69.94) 104.55,70.56 104.43,70.56 103.91,71.08 103.91,71.51 104.29,71.89 104.29,72.5 104.01,72.78 v2(103.7,72.78) 103.56,72.92 103.56,73.74 104.28,74.46 104.28,76.38 103.87,76.78 v2(103.87,78.01) ; v2(306.11,34.02) 304.01,34.02 303.61,33.62 297.91,33.62 296.24,31.95 296.24,31.46 295.56,30.77 295.56,28.14 294.25,26.83 290.82,26.83 287.81,23.82 286.99,23.82 286.45,24.35 281.86,24.35 281.51,24 277.87,24 277.42,24.44 268.91,24.44 265.79,21.33 261.94,21.33 251.86,31.41 248.05,31.41 227.89,51.57 v2(227.39,51.57) ; 137.03,114.58 137.03,119.38 137.83,120.18 152.88,120.18 v2(154.94,118.12) 155.98,119.16 162.66,119.16 164.21,117.61 164.21,111.21 166.19,109.23 166.19,103.36 167.08,102.47 168.07,102.47 168.89,101.66 168.89,100.64 169.88,99.65 169.88,96.83 170.75,95.96 171.69,95.96 v2(172.06,95.59)
  IN2 w0.508: v2(173.36,110.56) 172.92,110.99 172.92,111.43 170.06,114.29 165.52,114.29 164.11,115.7 164.11,117.92 163.21,118.82 155.64,118.82 v2(154.94,118.12)
  IN3 w0.508: v2(112.78,94.05) 112.78,92.8 111.95,91.97 110.3,91.97 109.83,92.44 106.57,92.44 105.27,91.14 105.27,82.84 103.87,81.44 v2(103.87,78.01)
  IN6 w1.016: 28.96,12.77 28.11,13.62 28.11,17.83 28.94,18.67 31.48,18.67 33.09,20.27 40.51,20.27 41.34,19.44 48.01,19.44
  IN6 w1.524: 261.43,21.65 261.43,23.89 262.62,25.08 268.76,25.08 271.77,22.07 277.84,22.07 279.08,23.31 279.96,23.31 279.96,23.32 281.04,23.32 281.7,23.98 286.43,23.98 287.1,23.31 288.32,23.31 288.99,23.98 288.99,23.98 289.52,24.51 290.05,25.04 291.78,25.04 293.45,26.7 293.62,26.7 294.27,27.36 294.27,28.03 295.38,29.14 295.38,29.83 296.55,31 298.67,31 300.6,32.93 304.9,32.93 305.87,33.89
  BOTTOM w0.254: PU1201.2 138.62,114.88 138.3,114.56 138.3,114.4 PC1227.2 ; 105.7,78.35 105.82,78.47 105.82,78.56 106.17,78.91 PU1300.12 ; v2(139.48,113.22) 139.72,113.46 PU1201.12 ; PU1202.2 156.66,117.86 156.27,118.25 156.25,118.25 156.25,118.26 156.16,118.35 155.8,118.35 PC1249.2 ; v2(153.99,116.98) 154.33,116.63 PU1202.12 ; v2(112.78,94.05) 112.91,94.18 PU1302.6 ; PU1001.8 172.28,96.11 172.06,95.89 v2(172.06,95.59) ; v2(103.87,78.01) 103.51,78.37 103.51,79.38 103.84,79.71 PC1302.2 104.22,79.71 105.09,80.58 PU1300.2 ; PU1200.2 137.7,108.46 PC1200.2 ; PC1336.2 104.85,70.62 105.41,71.18 PU1301.12 ; PU1200.12 139.66,107.16 140,106.82 140.35,106.82 140.57,106.61 v2(141.05,106.61) ; PU1301.2 103.88,72.96 v2(103.7,72.78)
  BOTTOM w0.305: JKB.2 162.77,10.84 163.01,11.08 163.97,11.08 v2(164.47,10.59)
  BOTTOM w0.508: PC1336.2 104.6,70.51 v2(105.17,69.94) ; 105.7,78.35 105.35,78.01 v2(103.87,78.01) ; v2(173.36,110.56) 173.36,109.86 PR1014.2 ; v2(306.11,34.02) 306.11,34.8 307.38,36.06 312.34,36.06 315.39,39.11 317.45,39.11 319.41,41.07 321.27,41.07 v2(321.37,40.97) ; v2(137.05,113.83) PC1227.2 ; PR1101.1 117.54,112.91 v2(117.55,112.92) ; v2(136.93,108.37) PC1200.2 ; PC1249.2 155.27,118.45 v2(154.94,118.12)
  vias: v1(94.04,33.99) v2(18.13,89.14) v2(18.72,88.95) v2(29.85,12.52) v2(30.48,12.52) v2(49.09,19.69) v2(49.67,19.69) v2(242.05,16.86) v2(242.66,16.86) v2(306.81,34.38)
+5VS_HDD:
  vias: v1(239.44,10.26) v2(237.63,9.43) v2(238.23,9.44) v2(238.81,9.44)
+VBUS_1: length 14.8
  TOP w0.127: v2(2.44,28.1) v1(3.47,28.1)
  TOP w0.305: JUSBC1.A9 8.75,64.56 v2(8.81,64.63) ; JUSBC1.A4 8.76,67.06 v2(8.84,67.14)
  TOP w0.381: PR248.1 24,26.98 24.3,27.28 v2(24.84,27.28)
  IN2 w0.508: v2(17.17,24.04) 17.17,24.39 17.91,25.13 17.91,25.7 19.73,27.52 21.31,27.52 21.97,28.18 23.94,28.18 v2(24.84,27.28)
  vias: v2(2.44,31.07) v2(2.44,30.46) v2(2.44,29.88) v2(2.45,29.28) v2(2.45,28.69) v2(11.81,62.37) v2(11.81,61.73) v2(11.81,61.1) v2(12.45,62.37) v2(12.45,61.73) v2(12.45,61.1) v2(12.73,64.58) v2(13.08,62.37) v2(13.08,61.73) v2(13.08,61.1) v2(13.72,62.37) v2(13.72,61.73) v2(13.72,61.1)
+VBUS_DC_SS: length 112.4
  TOP w0.127: v2(23.78,61.43) 23.48,61.13 23.48,60.44 v1(22.61,59.57)
  TOP w0.254: PC289.1 23.31,64.97 22.67,64.97 21.85,64.14 21.85,63.72 22.98,62.58 22.98,62.23 v2(23.78,61.43)
  TOP w0.508: PD303.2 54.36,9.15 53.23,10.28 53.23,11.39 53.43,11.59 v2(53.4,11.59) ; v2(25.4,59) 25.78,59 25.91,59.13 PC288.1
  IN2 w0.508: v2(21.91,19.06) 23.05,19.06 23.98,19.99 25.74,19.99 29.05,23.29 29.05,24.47 29.69,25.12 30.44,25.12 31.09,24.47 38.53,24.47 40.7,22.3 44.56,22.3 45.52,21.34 45.52,20.72 45.82,20.42 47.46,20.42 49.28,22.23 51.23,22.23 54.06,19.4 54.06,18.64 53.66,18.23 53.66,16.01 54.37,15.3 54.37,13.15 53.43,12.21 53.43,11.72 53.44,11.71 53.44,11.59 v2(53.4,11.59)
  IN5 w0.508: v2(21.91,19.06) 21.91,20.3 24.24,22.63 24.24,23.47 24.01,23.7 24.01,26.29 23.6,26.7 23.6,27.96 21.97,29.58 21.97,39.81 20.07,41.71 20.07,44.11 19.39,44.79 19.39,48.98 20.66,50.26 20.66,54.28 20.75,54.36 20.75,58.76 21.71,59.72 23.29,59.72 23.78,60.21 v2(23.78,61.43)
  BOTTOM w0.508: PR260.1 v2(21.91,19.06)
+VCC0V9_CIO: length 4.7
  TOP w0.089: v2(28.01,40.99) 28.4,40.99 v3(28.57,41.16)
  TOP w0.381: v2(32.98,42.49) 32.98,42.59 32.64,42.93 CT102.1 32.32,42.96 CT103.1 32.32,43.76 31.88,44.2 CT101.1
  IN4 w0.508: v2(28.66,42.29) 28.66,42.14 28.01,41.49 v2(28.01,40.99)
+VCC0V9_DP: length 1.3
  IN2 w0.254: v2(29.31,40.99) 29.31,40.35 v2(29.31,40.35) ; v2(26.72,42.94) v2(27.36,42.94)
  vias: v1(27.43,42.33) v2(26.71,40.99)
+VCC0V9_PCIE: length 2.6
  IN2 w0.254: v2(26.71,39.69) v2(26.71,39.04) v2(26.71,38.39) v2(26.71,37.74) v2(27.36,37.74)
  vias: v3(26.76,37.13)
+VCC0V9_USB: length 1.6
  TOP w0.381: CT93.1 28.79,37.87 CT94.1 28.66,38.37 v2(28.66,39.04)
+VCC_CORE: length 28.7
  TOP w0.508: PC1269.1 163.23,69.94 v2(163.64,69.94) ; v2(161.22,70) 160.82,70 PC1261.1 ; v2(168.56,71.81) 168.97,71.81 PC1220.1 ; PC1276.1 160.75,71.27 v2(161.16,71.27)
  BOTTOM w0.152: UH1.P14 169.33,67.89 ; UH1.P14 169.33,68.51 ; UH1.P14 168.69,67.87 ; 169.62,67.86 UH1.N13 170.25,67.86 ; 165.7,67.67 165.57,67.55 UH1.W13 UH1.W14 ; 168.69,67.87 v2(168.56,67.87) 168.43,67.87 UH1.R13 168.2,67.46 168.93,67.46 UH1.P13 ; 168.69,67.87 UH1.P13 ; UH1.L14 172.07,67.89 ; UH1.L14 UH1.K14 172.42,67.77 v2(172.31,67.66) ; UH1.L14 171.45,67.89 ; UH1.L14 171.45,68.51 ; UH1.AC14 162.45,68.2 v2(162.12,67.87) ; UH1.AC14 UH1.AC13 162.48,67.55 162.16,67.87 v2(162.12,67.87) ; UH1.AC14 162.75,68.2 v2(163.08,67.87) 163.4,67.55 UH1.AA13 163.69,67.55 163.91,67.76 ; UH1.AC14 162.62,68.71 ; UH1.V14 UH1.V13 166.07,67.55 165.95,67.66 ; UH1.V14 165.97,68.51 ; UH1.V14 166.59,68.51 ; UH1.V14 165.97,67.89 ; 169.62,67.89 UH1.N14 ; UH1.N14 170.25,67.89 ; UH1.N14 169.62,68.51 ; UH1.N14 170.25,68.51 ; 165.05,68.51 UH1.W14 ; UH1.W14 165.67,68.51 ; UH1.W14 165.67,67.89 ; UH1.AE14 161.1,67.89 ; UH1.AE14 UH1.AE13 161.06,67.55 161.11,67.6 ; UH1.AE14 161.1,68.51 ; 161.38,67.62 161.46,67.55 UH1.AD13 161.8,67.55 v2(162.12,67.87) ; 172.54,67.43 172.72,67.43 UH1.K13 172.91,67.79 172.75,67.95 ; 161.39,68.51 UH1.AD14 ; UH1.AD14 161.39,67.89 ; UH1.AD14 161.8,68.2 v2(162.12,67.87) ; UH1.P13 169.34,67.55 169.36,67.53 ; 171.45,67.86 UH1.L13 172.07,67.86
  BOTTOM w0.508: RH197.1 157.49,94.64
  vias: v1(152.91,105.86) v2(149.95,110.4) v2(149.95,109.79) v2(149.92,109.18) v2(149.92,108.59) v2(149.92,107.96) v2(149.92,107.32) v2(149.92,106.69) v2(149.92,106.05) v2(150.58,110.4) v2(150.58,109.79) v2(150.56,109.18) v2(150.56,108.59) v2(150.56,107.96) v2(150.56,107.32) v2(150.56,106.69) v2(150.56,106.05) v2(151.22,110.4) v2(151.22,109.79) v2(151.19,109.18) v2(151.19,108.59) v2(151.19,107.96) v2(151.19,107.32) v2(151.83,109.18) v2(151.83,108.59) v2(151.83,107.96) v2(151.83,107.32) v2(151.79,102.74) v2(151.85,110.4) v2(151.85,109.79) v2(152.32,103.01) v2(152.32,102.37) v2(152.49,110.4) v2(152.49,109.79) v2(152.46,109.18) v2(152.46,108.59) v2(152.46,107.96) v2(152.46,107.32) v2(152.96,103.01) v2(152.96,102.37) v2(152.96,101.49) v2(152.96,100.86) v2(153.12,110.4) v2(153.12,109.79) v2(153.1,109.18) v2(153.1,108.59) v2(153.1,107.96) v2(153.1,107.32) v2(153.59,103.01) v2(153.59,102.37) v2(153.56,101.51) v2(153.56,100.87) v2(153.73,109.18) v2(153.73,108.59) v2(153.73,107.96) v2(153.73,107.32) v2(153.76,110.4) v2(153.76,109.79) v2(154.2,104.61) v2(154.23,103.92) v2(154.23,103.29) v2(154.23,102.64) v2(154.19,102.04) v2(154.19,101.41) v2(154.39,110.4) v2(154.39,109.79) v2(154.37,109.18) v2(154.37,108.59) v2(154.37,107.96) v2(154.37,107.32) v2(154.37,106.69) v2(154.36,105.88) v2(154.36,105.24) v2(154.84,104.61) v2(154.84,103.92) v2(154.84,103.29) v2(154.84,102.65) v2(154.83,102.04) v2(154.83,101.41) v2(154.99,105.88) v2(154.99,105.24) v2(155.47,104.61) v2(155.47,103.92) v2(155.47,103.3) v2(155.47,102.66) v2(155.47,102.03) v2(155.47,101.39) v2(155.63,105.86) v2(155.63,105.24) v2(156.11,104.61) v2(156.11,103.92) v2(156.11,103.29) v2(156.11,102.65) v2(156.11,102.02) v2(156.11,101.38) v2(156.22,105.86) v2(156.26,105.24) v2(156.86,98.81) v2(156.86,98.18) v2(156.86,97.54) v2(156.86,96.85) v2(159.98,87.83) v2(160.12,86.04) v2(160.12,84.73) v2(160.12,82.13) v2(160.38,104.49) v2(160.38,103.86) v2(160.38,103.22) v2(160.38,102.59) v2(160.38,101.95) v2(160.38,101.32) v2(160.61,87.83) v2(160.72,78.05) v2(160.91,86.69) v2(160.91,85.38) v2(160.91,84.08) v2(161.01,104.49) v2(161.01,103.86) v2(161.01,103.22) v2(161.01,102.59) v2(161.01,101.95) v2(161.01,101.32) v2(161.25,87.83) v2(161.27,67.86) v2(161.65,104.56) v2(161.65,103.92) v2(161.65,103.22) v2(161.65,102.59) v2(161.65,101.95) v2(161.65,101.32) v2(161.7,86.04) v2(161.7,84.73) v2(161.7,83.43) v2(161.7,82.13) v2(161.88,87.83) v2(162.52,87.83) v2(162.49,84.08) v2(162.49,82.78) v2(162.49,81.49) v2(162.62,78.05) v2(162.82,76.34) v2(162.82,75.7) v2(162.82,75.07) v2(162.82,74.43) v2(163.15,87.83) v2(163.27,86.04) v2(163.27,84.73) v2(163.27,82.13) v2(163.64,71.51) v2(163.79,87.83) v2(164.06,86.69) v2(164.06,85.38) v2(164.06,84.08) v2(164.06,82.78) v2(164.42,87.83) v2(164.47,78.05) v2(164.85,84.73) v2(164.85,82.13) v2(164.83,81.49) v2(164.86,83.42) v2(164.92,68.53) v2(165.06,87.83) v2(165.63,86.69) v2(165.63,85.38) v2(165.63,84.08) v2(165.69,87.83) v2(166.18,71.21) v2(166.33,87.83) v2(166.42,86.69) v2(166.42,86.04) v2(166.42,84.73) v2(166.42,83.43) v2(166.42,82.13) v2(166.37,78.43) v2(166.76,68.53) v2(166.96,87.83) v2(167.21,85.38) v2(167.21,84.08) v2(167.21,82.78) v2(167.21,81.49) v2(167.6,87.83) v2(168,86.69) v2(168,86.04) v2(168,84.73) v2(168,82.13) v2(168.15,78.43) v2(168.78,85.38) v2(168.76,84.75) v2(168.78,84.08) v2(168.78,83.41) v2(168.78,82.78) v2(168.79,82.11) v2(169.46,67.86) v2(169.57,86.7) v2(169.59,85.39) v2(169.57,84.73) v2(169.55,82.79) v2(171.31,68.6)
+VCCGT: length 48.1
  TOP w0.508: v2(151.36,71.74) 151.96,71.74 PC1300.1 152.99,71.95 PC1350.1 ; v2(154.8,70.1) 154.37,70.1 PC1363.1 ; PC1376.1 154.48,77.61 PC1375.1 154.85,77.24 v2(155.25,77.24) ; v2(147.56,70.16) 147.06,70.16 PC1374.1 ; PC1373.1 149.48,70.16 v2(149.97,70.16) ; PC1372.1 151.89,70.16 v2(152.38,70.16) ; PC1353.1 153.07,73.55 PC1361.1 151.54,73.24 v2(151.13,73.24) ; PC1310.1 147.5,74.18 PC1305.1 146,73.96 v2(145.39,73.96) ; PC1354.1 153.07,76.26 PC1348.1 151.59,75.97 v2(151.19,75.97) ; PC1303.1 146.27,71.95 PC1304.1 146,71.74 v2(145.32,71.74) ; PC1360.1 153.08,74.94 PC1359.1 151.59,74.63 v2(151.19,74.63) ; v2(145.21,77.4) 145.68,77.4 PC1379.1 146.9,77.63 PC1314.1 ; PC1377.1 149.77,77.3 v2(150.17,77.3) ; PC1306.1 147.61,76.01 PC1311.1 146.06,75.8 v2(145.45,75.8) ; PC1378.1 144.65,70.16 v2(145.15,70.16)
  BOTTOM w0.152: UH1.AM13 155.17,67.55 v2(154.85,67.87) ; UH1.AM13 UH1.AM14 ; UH1.AM13 UH1.AL13 ; 154.08,68.51 UH1.AN14 ; UH1.AN14 154.52,68.2 v2(154.85,67.87) ; UH1.AN14 154.08,67.89 ; 146.76,67.89 UH1.BB14 ; UH1.BB14 147.24,68.2 v2(147.52,67.92) ; UH1.BB14 146.76,68.51 ; 144.02,67.89 UH1.BF14 ; UH1.BF14 144.02,68.51 ; UH1.BF14 144.64,67.89 ; UH1.BF14 144.64,68.51 ; v2(147.52,67.92) 147.8,68.2 UH1.BA14 ; v2(147.52,67.92) 147.15,67.55 UH1.BB13 146.8,67.55 146.72,67.62 ; v2(147.52,67.92) 147.89,67.55 UH1.BA13 UH1.BA14 ; UH1.AL13 155.75,68.02 155.49,68.02 UH1.AM14 ; UH1.AL13 156.3,67.55 156.57,67.81 ; UH1.BD14 145.38,68.2 v2(145.7,67.87) 145.38,67.55 UH1.BD13 145.03,67.55 144.9,67.69 ; UH1.BD14 144.93,67.89 ; UH1.BD14 144.93,68.51 ; UH1.AM14 155.17,68.2 v2(154.85,67.87) ; UH1.AM14 155.3,68.65 155.3,68.65 ; 153.16,68.51 UH1.AP14 ; UH1.AP14 153.79,68.51 ; UH1.AP14 153.79,67.89 ; UH1.AP14 UH1.AP13 153.66,67.55 153.77,67.66 ; 144.64,67.86 UH1.BF13 144.02,67.86 ; UH1.BA14 147.99,68.63 147.99,68.64 ; UH1.AT14 151.96,68.51 ; UH1.AT14 151.33,68.51 ; UH1.AT14 151.33,67.89 ; v2(154.85,67.87) 154.52,67.55 UH1.AN13 154.22,67.55 154.09,67.67 ; UH1.AW14 150.13,68.51 ; UH1.AW14 149.51,67.89 ; UH1.AW14 149.51,68.51 ; 150.42,68.51 UH1.AU14 ; UH1.AU14 151.04,68.51 ; UH1.AU14 151.04,67.89
  BOTTOM w0.203: UH1.BF38 144.05,86.36
  BOTTOM w0.508: RH203.1 157.49,87.78
  vias: v1(117.92,76.26) v2(116.71,81.42) v2(116.84,80.72) v2(116.84,80.08) v2(116.84,79.45) v2(116.84,78.81) v2(116.84,78.22) v2(116.97,74.56) v2(116.97,73.92) v2(116.97,73.31) v2(116.97,72.72) v2(117.34,81.56) v2(117.48,80.78) v2(117.48,80.15) v2(117.48,79.51) v2(117.48,78.88) v2(117.48,78.24) v2(117.6,74.62) v2(117.6,73.99) v2(117.6,73.35) v2(117.6,72.72) v2(118.11,80.15) v2(118.11,79.51) v2(118.11,78.88) v2(118.11,78.24) v2(118.24,74.62) v2(118.24,73.99) v2(118.24,73.35) v2(118.24,72.72) v2(118.75,80.15) v2(118.75,79.51) v2(118.75,78.88) v2(118.75,78.24) v2(118.87,74.62) v2(118.87,73.99) v2(118.87,73.35) v2(118.87,72.75) v2(119.38,80.15) v2(119.38,79.51) v2(119.38,78.88) v2(119.38,78.24) v2(119.51,74.62) v2(119.51,73.99) v2(119.51,73.35) v2(119.51,72.75) v2(119.64,77.61) v2(119.64,76.97) v2(119.64,76.34) v2(119.64,75.7) v2(119.7,70.81) v2(119.7,70.18) v2(119.83,72.08) v2(119.83,71.45) v2(120.02,80.15) v2(120.02,79.51) v2(120.02,78.88) v2(120.02,78.24) v2(119.95,75.19) v2(120.21,74.62) v2(120.21,73.99) v2(120.21,73.35) v2(120.21,72.72) v2(120.27,77.61) v2(120.27,76.97) v2(120.27,76.34) v2(120.27,75.7) v2(120.33,70.81) v2(120.33,70.18) v2(120.46,72.08) v2(120.46,71.45) v2(120.73,75.27) v2(120.83,76.64) v2(120.8,76.01) v2(120.84,74.62) v2(120.84,73.99) v2(120.84,73.35) v2(120.84,72.72) v2(121.03,70.14) v2(121.11,72.09) v2(121.06,70.77) v2(121.18,71.38) v2(138.92,84.89) v2(139.77,87.78) v2(140.41,87.78) v2(141.04,87.78) v2(141.68,87.78) v2(142.01,86.71) v2(142.31,87.78) v2(142.8,86.04) v2(142.8,84.73) v2(142.8,84.08) v2(142.8,82.13) v2(142.95,87.78) v2(143.58,87.78) v2(143.59,84.08) v2(143.59,82.78) v2(143.59,81.49) v2(143.59,80.07) v2(144.22,87.78) v2(144.38,86.04) v2(144.38,84.73) v2(144.38,82.13) v2(144.79,68.52) v2(144.85,87.78) v2(145.16,86.69) v2(145.16,85.38) v2(145.16,84.08) v2(145.16,82.78) v2(145.49,87.78) v2(145.95,84.73) v2(145.95,83.43) v2(145.95,82.13) v2(145.95,81.49) v2(146.12,87.77) v2(146.62,68.51) v2(146.74,86.69) v2(146.74,85.38) v2(146.78,87.75) v2(147.43,87.75) v2(147.52,86.04) v2(147.52,84.73) v2(147.52,83.43) v2(147.52,82.13) v2(148.07,87.75) v2(148.31,84.08) v2(148.31,82.78) v2(148.31,81.49) v2(149.1,86.04) v2(149.1,84.73) v2(149.1,82.13) v2(149.89,86.69) v2(149.89,85.38) v2(149.89,84.08) v2(149.89,82.78) v2(150.27,68.52) v2(150.67,84.73) v2(150.67,83.43) v2(150.67,82.13) v2(150.68,81.5) v2(151.46,86.69) v2(151.46,85.38) v2(152.25,86.04) v2(152.25,84.73) v2(152.25,83.43) v2(152.25,82.13) v2(153.04,84.08) v2(153.04,82.78) v2(153.04,81.49) v2(153.82,86.04) v2(153.82,84.73) v2(153.82,82.13) v2(153.93,67.87) v2(154.61,86.69) v2(154.61,85.38) v2(154.61,84.08) v2(154.61,82.78) v2(154.59,82.15) v2(155.39,86.69) v2(155.4,84.73) v2(155.4,82.13) v2(156.19,86.04) v2(156.19,85.38) v2(156.19,84.08) v2(156.19,82.78) v2(156.31,75.52) v2(156.35,72.87) v2(156.97,84.73) v2(156.97,83.43) v2(156.97,82.13) v2(157.76,84.08) v2(157.76,82.78) v2(157.76,81.49)
+VCCIO: length 279.9
  TOP w0.305: v2(294.74,20.55) 295.02,20.26 UE3.B51
  TOP w0.508: v2(309.22,25.49) 309.24,25.49 311.66,23.07 RE69.1 ; RH30.2 176.92,87.52 v2(176.36,87.52) ; RH483.1 130.86,98.21 131.8,97.27 134.65,97.27 135.73,96.18 v1(135.73,94.66) v2(135.73,94.01) ; CE34.1 291.17,22.1 v2(292.25,22.1)
  IN1 w0.381: v2(172.38,78.61) 172.63,78.61 173.01,78.99 173.01,79.98 172.3,80.69 170.8,80.69 170.48,81.01 170.48,83.56 171.08,84.16 171.29,84.16 171.93,84.79 172.34,84.79 173.39,85.85 173.39,86.66 174.81,88.08 175.88,88.08 176.36,87.6 v2(176.36,87.52)
  IN1 w0.508: v2(294.74,20.55) 300.59,20.55 301.15,21.11 304.73,21.11 305.86,22.23 305.86,23.1 308.24,25.49 v2(309.22,25.49)
  IN3 w0.508: v2(159.42,67.25) 159.52,67.25 160.25,66.52 160.68,66.52 162.28,64.92 162.28,63.93 162.91,63.29 164.61,63.29 165.14,62.77 165.14,58.01 167.37,55.78 170.1,53.04 172.49,53.04 v2(172.67,53.22) 174.55,53.22 178.21,49.56 198.13,49.56 198.95,48.75 200.85,48.75 201.95,49.85 202.94,49.85 203.82,48.97 211.24,48.97 230.06,30.15 239.21,30.15 v2(241.17,28.19)
  IN4 w0.508: v2(142.71,72.49) 141.69,73.5 141.69,80.07 141.01,80.76 138.67,80.76 138.27,81.16 138.27,85.53 135.73,88.06 v2(135.73,94.01)
  IN6 w0.508: v2(241.17,28.19) 240.87,27.89 240.87,20.05 238.98,18.16 238.98,16.52 240.63,14.87 256.83,14.87 259.34,17.37 265.69,17.37 268.11,19.8 278.7,19.8 279.37,20.47 280.53,20.47 282.48,22.41 286.13,22.41 286.61,21.93 292.08,21.93 v2(292.25,22.1)
  BOTTOM w0.152: 173.9,73 UH1.G19 173.9,72.43 ; UH1.J19 173.14,73.03 ; UH1.J19 173.14,72.4 ; UH1.J19 172.52,72.4 ; UH1.J26 UH1.H26 173.31,78.4 173.31,78.52 ; UH1.J26 173.14,78.54 ; UH1.J26 172.52,78.54 ; 172.52,73.98 UH1.J21 ; UH1.J21 173.14,73.98 ; UH1.J21 UH1.H21 ; UH1.J21 172.52,74.6 ; 173.17,71.45 UH1.H17 ; UH1.H17 173.17,70.83 ; UH1.H17 173.79,70.83 ; UH1.H17 173.79,71.45 ; 173.17,72.4 UH1.H19 ; UH1.H19 173.79,72.4 ; UH1.H19 173.17,73.03 ; UH1.H19 173.79,73.03 ; UH1.J27 173.14,78.7 ; UH1.J27 UH1.H27 173.48,78.85 173.32,78.69 ; UH1.J27 172.52,78.7 ; UH1.J16 173.14,70.04 ; UH1.J16 173.14,70.66 ; UH1.J16 172.52,70.66 ; UH1.J16 172.52,70.04 ; 173.14,71.45 UH1.J17 173.14,70.83 ; 173.17,70.66 UH1.H16 ; UH1.H16 173.79,70.04 ; UH1.H16 173.79,70.66 ; UH1.H16 173.17,70.04 ; 173.17,69.88 UH1.H15 173.79,69.88 ; 174.02,69.9 174.18,69.73 UH1.G15 173.88,69.57 173.85,69.59 ; 173.14,69.88 UH1.J15 172.52,69.88 ; 172.52,73.81 UH1.J20 ; UH1.J20 173.14,73.81 ; UH1.J20 173.14,73.19 ; 173.9,74.57 UH1.G21 173.9,74.01 ; 173.17,73.19 UH1.H20 ; UH1.H20 173.79,73.19 ; UH1.H20 173.17,73.81 ; UH1.H20 173.79,73.81 ; UH1.H21 173.79,74.6 ; UH1.H21 173.79,73.98 ; UH1.H21 173.17,73.98 ; 173.9,70.86 UH1.G17 173.9,71.43
  BOTTOM w0.203: UH1.AG12 159.29,67.22 v2(159.42,67.25)
  BOTTOM w0.381: v2(172.67,53.22) 173.2,53.76 173.2,54.29 RH24.1
  BOTTOM w0.508: v2(294.74,20.55) 294.74,21.48 293.51,22.7 292.6,22.7 292.25,22.35 v2(292.25,22.1)
  vias: v2(117.78,67.93) v2(117.78,67.29) v2(117.79,66.62) v2(117.82,65.85) v2(118.42,67.93) v2(118.42,67.29) v2(118.43,66.62) v2(118.49,65.92) v2(119.05,67.93) v2(119.06,67.32) v2(119.06,66.62) v2(173.86,73.14) v2(173.85,72.34) v2(173.86,70.71)
+VCCSA: length 6.5
  TOP w0.508: v2(170.85,79.82) 171.26,79.82 PC1386.1 ; v2(171.04,74.1) 171.45,74.1 PC1390.1 ; v2(171.04,75.43) 171.45,75.43 PC1385.1 ; 171.23,85.76 171.23,87.14 170.99,87.38 CH134.1 ; v2(170.88,76.87) 171.54,76.87 PC1382.1
  BOTTOM w0.508: v2(178.8,88.83) 178.68,88.83 178.14,89.37 RH201.2
  vias: v1(114.23,88.75) v2(115.34,90.33) v2(115.7,89.54) v2(115.98,90.33) v2(116.31,89.77) v2(116.61,90.36) v2(116.87,89.59) v2(117.27,90.08) v2(117.73,87.32) v2(117.81,90.38) v2(117.77,89.53) v2(117.76,88.85) v2(118.4,90.15) v2(118.4,89.53) v2(118.43,88.85) v2(118.37,87.32) v2(119.04,90.1) v2(119.04,89.47) v2(119.04,88.83) v2(119.06,87.33) v2(119.67,90.1) v2(119.67,89.47) v2(119.67,88.83) v2(119.76,88.25) v2(119.76,87.32) v2(120.27,90.14) v2(120.27,89.51) v2(120.27,88.87) v2(120.35,88.22) v2(120.33,87.64) v2(167.68,92.54) v2(167.7,90.39) v2(168.3,90.38) v2(168.43,92.54) v2(169.53,92.54) v2(169.53,90.37) v2(170.12,90.37) v2(170.28,92.54) v2(171.15,84.73) v2(171.15,83.43) v2(171.15,82.13) v2(171.93,85.38) v2(171.93,82.78) v2(171.93,82.13) v2(171.97,84.09) v2(172.31,92.54) v2(172.34,91.96) v2(172.72,82.78) v2(173.06,92.54) v2(173.09,91.96) v2(174.61,92.54) v2(174.61,91.96) v2(175.21,92.54) v2(175.2,91.96) v2(175.83,92.53) v2(175.82,91.94)
+VCCST: length 211.9
  TOP w0.127: v1(113.51,115.35) 113.51,114.47 PC1137.1
  TOP w0.381: PR1145.1 116.16,114 v2(115.83,113.67)
  TOP w0.508: RH98.1 RH97.1 108.85,8.52 v2(108.87,8.51) ; v2(115.83,113.67) 115.38,113.67 115.05,114 PR1131.1 114.76,114.05 PC1137.1 ; v2(180.11,63.65) 179.75,64 RH164.1 ; v2(133.49,103.01) RH151.1 RH152.1
  IN3 w0.508: v2(115.83,113.67) 119.04,110.46 123.69,110.46 124.97,109.18 124.97,105.96 127,103.93 127,102.99 127.61,102.38 131.46,102.38 132.08,103.01 v2(133.49,103.01) 134.44,103.01 134.94,102.51 134.94,99.32 132.14,96.53 v2(132.14,96.17)
  IN4 w0.508: v2(132.14,96.17) 132.14,95.23 133.73,93.64 133.73,85.31 134.21,84.83 134.21,81.97 131.14,78.89 v2(131.14,77.53) 129.65,76.05 129.65,70.33 128.27,68.96 128.27,65.7 123.56,60.99 123.56,58.44 124.24,57.76 124.24,47.8 110.68,34.23 110.68,26.29 110.79,26.18 110.79,19.92 108.95,18.08 v2(108.95,16.67)
  IN6 w0.508: v2(180.89,79.03) 180.89,86 181.24,86.35 181.24,89.34 180.3,90.28 176.53,90.28 176.23,90.58 171.68,90.58 170.37,91.89 158.37,91.89 157.42,92.85 145.05,92.85 141.72,96.17 134.23,96.17 133.62,96.78 132.75,96.78 v2(132.14,96.17)
  BOTTOM w0.203: v2(172.38,79.42) 172.77,79.8 UH1.J28 UH1.H28 ; UH1.H30 173.88,80.99 v2(173.88,80.98)
  BOTTOM w0.508: v2(108.95,16.67) 108.95,16.43 109.88,15.5 109.88,13.76 110.36,13.28 110.36,10 v2(108.87,8.51) 108.66,8.3 RH100.1 ; RH156.1 RH570.1 130.67,78 v2(131.14,77.53)
  vias: v2(180.47,78.6)
+VCCSTG: length 197.4
  TOP w0.127: v2(182.93,81.47) v1(183.36,81.03)
  TOP w0.508: CH105.1 174.91,83.01 CH106.1 174.02,82.44 173.69,82.12 v2(173.47,82.12)
  IN1 w0.508: v2(173.47,82.12) 173.47,81.73 173.11,81.37 173.11,80.77 173.67,80.21 173.88,80.21 v2(173.89,80.2)
  IN3 w0.508: v2(203.57,51.33) 202.6,51.33 202.19,51.74 197.62,51.74 196.25,50.36 179.78,50.36 175.7,54.44 171.82,54.44 v2(171.6,54.23) ; v2(132.82,98.38) 132.55,98.12 131.98,98.12 131.79,98.31 v2(131.79,98.36)
  IN5 w0.508: v2(203.57,51.33) 203.21,51.33 200.28,54.26 199.21,54.26 198.06,55.42 197.41,55.42 192.45,60.38 192.45,68.14 193.24,68.93 193.24,80.95 192.72,81.47 v2(182.93,81.47)
  IN6 w0.508: v2(131.79,98.36) 131.48,98.05 130.72,98.05 130.24,98.54 129.15,98.54 127.5,96.88 123.89,96.88 123.22,96.21 123.22,87.7 127.05,83.87 v2(127.46,83.87)
  BOTTOM w0.203: UH1.G30 173.47,82.08 v2(173.47,82.12)
  BOTTOM w0.254: v2(173.89,80.2) 173.89,80.2 173.53,80.55 UH1.H29
  BOTTOM w0.508: v2(171.6,54.23) 170.83,53.45 165.66,53.45 161.14,48.93 136.81,48.93 132.77,52.97 132.77,64.96 134.24,66.43 134.24,67.06 134.88,67.7 135.76,67.7 136.15,68.08 136.15,69.48 135.31,70.32 132.76,70.32 129.78,73.3 RH165.1 129.51,78.8 127.33,80.98 127.33,83.74 v2(127.46,83.87) ; v2(132.82,98.38) 133.3,98.38 133.67,98.01 RH496.1 RH495.1 ; v2(131.79,98.36) 131.7,98.27 RH494.1
  vias: v2(182.3,81.44)
DV12S: length 11.5
  TOP w0.14: v2(327.05,32.43) v1(327.71,32.43)
  IN1 w0.508: v2(327.05,32.43) 327.53,32.91 327.53,35.65 v2(327.33,35.85)
  BOTTOM w0.203: UR1.14 330.82,36.68 330.79,36.71 330.25,36.71 330.13,36.83 ; UR1.10 331.42,35.08 330.88,34.53 330.88,34.41
  BOTTOM w0.508: 330.13,36.83 328.3,36.83 CR2.1 328.05,36.19 327.71,35.85 v2(327.33,35.85) ; 330.88,34.41 330.88,33.78
DV33_18: length 5.3
  BOTTOM w0.14: v1(329.75,41.68) 330.11,41.32 330.62,41.32 330.99,40.96 330.99,40.3 CR3.1
  BOTTOM w0.203: 332.43,39.15 332.88,38.69 UR1.18
  BOTTOM w0.508: CR3.1 331.88,39.7 332.43,39.15
GND: length 2644
  TOP w0.127: v1(113.83,13.38) v2(113.83,14.07) ; v2(28.46,78.6) v1(27.79,78.6) ; v2(328.55,85.15) v1(328.55,85.92) ; v2(347.05,85.15) 347.05,85.9 v1(347.04,85.91) ; v2(323.89,55.04) v1(324.38,55.53) ; v2(319.68,29.6) v1(319.68,30.27)
  TOP w0.14: v2(319.2,42.06) 318.64,42.06 v1(318.54,42.16)
  TOP w0.203: UZ7.11 v2(241.59,4.5) ; v2(53.43,19.05) 53.56,18.92 53.56,18.41 53.45,18.31 PU300.22 ; UZ1.11 311.44,34.61 v2(311.34,34.51) ; PU700.24 246.38,50.14 v2(246.74,49.78) ; v2(245.75,48.59) 245.38,48.59 245.19,48.78 PU700.23
  TOP w0.254: DT16.2 v2(11.18,65.11) ; v2(11.72,64.56) 11.46,64.31 DT18.2 ; v2(11.18,73.95) 11.18,73.72 11.18,73.72 DT23.2 ; RPH13.8 216.08,63.43 216.32,63.19 v2(216.51,63.19) ; RT1.2 27.72,39.33 v2(27.36,39.69) 27.85,40.19 CT163.2 ; CH196.2 87.98,6.89 87.71,7.16 87.71,7.72 87.44,7.99 v2(87.29,7.99) ; UZ21.3 167.28,3.68 v2(167.11,3.51) ; v2(10.12,67.48) DT14.2 ; v2(155.93,3.78) UE1.32 ; v2(19.12,29.75) 18.85,29.48 UT3.5 ; DT17.2 v2(10.31,64.65) ; DT19.2 10.7,62.79 v2(10.65,62.74) ; v2(6.96,60.39) 6.8,60.23 DT25.2 ; JUSBC1.A1 8.85,68.56 v2(8.85,68.56) ; v2(11.62,71.7) 11.27,72.06 DT24.2 ; JXDP.37 126.8,94.51 126.34,94.05 v2(126.34,94.05) ; RPH13.6 215.08,63.2 v2(215.28,63) 215.58,63.3 RPH13.7 ; UN3.5 335.06,102.04 v2(334.93,102.18) ; DT15.2 11.1,67 v2(10.71,67.38) ; JUSBC1.A12 8.07,62.85 v2(8.07,62.24) ; v2(230.62,62) 230.62,61.46 230.49,61.34 UZ17.5 ; v2(172.57,4.2) 172.42,4.04 RZ86.2 ; UI1.14 23.4,90.96 v2(22.92,91.44) ; CZ57.2 132.07,68.45 131.82,68.2 UZ16.5 ; UE1.16 152.43,10.17 152.72,10.46 v2(152.72,10.78) ; v2(11.7,67.51) 11.41,67.51 DT13.2 ; UE1.23 151.25,5.93 v2(150.81,5.5) ; v2(11.79,69.39) 11.56,69.16 DT12.2 ; v2(155.51,8.33) 155.93,8.74 UE1.9 ; v2(213.94,63.33) 214.4,63.33 214.58,63.51 RPH13.5 ; UE6.5 223.51,10.03 223.76,10.28 225.05,10.28 225.35,9.98 RZ32.1 ; DT22.2 v2(6.42,71.58) ; 100.8,26.02 101.16,25.66 101.41,25.66 101.99,25.08 CH48.2 103.04,24.61 103.51,24.14 104.78,24.14 105.41,23.5 v2(105.41,23.51) 106.18,23.51 106.85,24.18 106.85,28.26 106.53,28.58 103.74,28.58 103.05,27.9 CH47.2 102.58,28.27 102.02,28.27 101.23,27.48 v2(101.23,27.34) 100.8,26.91 v2(100.8,26.37) 100.8,26.02
  TOP w0.279: v2(129.67,91.7) 129.63,91.74 129.63,92.69 129.31,93.01 JXDP.31 ; v2(126.33,100.12) 126.47,99.98 126.55,99.98 126.63,99.89 127.06,99.89 127.18,100.01 JXDP.59
  TOP w0.305: JXDP.8 121.1,87.01 v2(120.91,87.21) ; v2(122.92,84.52) 123.6,84.52 123.94,84.86 123.94,85.29 123.72,85.51 JXDP.2 ; v2(229.27,52.56) 229.53,52.81 UF1.10 ; UE3.B11 300.02,11.16 300.05,11.18 300.05,11.95 v2(300.29,12.19) ; UE3.B18 303.84,11.38 v2(304.31,10.91) ; CT72.2 28.92,35 v2(28.69,34.77) 28.34,34.77 28.16,34.95 CT71.2 ; v2(124.69,90.1) 124.6,90.01 JXDP.20 ; v2(120.96,94.65) 121.1,94.51 JXDP.38 ; CT144.2 13.15,38.14 13.6,38.14 v2(13.63,38.17) ; RT43.1 RT40.1 RT38.1 19.99,32.13 v2(20.49,31.63) ; JXDP.13 127.11,88.51 126.39,89.23 v2(126.39,89.35) 127.04,90.01 128.19,90.01 JXDP.19 ; JXDP.50 124.08,97.51 v2(124.09,97.52) ; v2(130,87.18) 129.83,87.01 JXDP.7 ; v2(120.98,91.1) 120.96,91.1 121.37,91.51 JXDP.26 ; v2(129.67,97.2) 129.63,97.2 129.32,97.51 JXDP.49 ; v2(7.61,36.43) 7.58,36.41 CT158.2 ; UF1.16 232.03,55.42 232.25,55.2 v2(232.25,54.68) 232.13,54.68 231.9,54.92 UF1.15 ; UF1.5 v2(229.03,57.32) ; v2(120.97,92.57) 120.97,92.78 121.21,93.01 JXDP.32 ; UE3.B66 v2(295.12,12.38) ; UE3.B60 v2(295.19,15.38) ; v2(129.67,91.7) 129.47,91.51 JXDP.25 ; UE3.B54 294.69,18.38 294.94,18.13 v2(295.16,18.13) ; JXDP.14 v2(120.97,88.51)
  TOP w0.356: RH77.2 61.6,10.77 61.2,10.37 61.2,9.94 61.34,9.8 UH7.3 ; v2(24.56,34.81) 24.56,35.26 RT164.1 ; CT93.2 27.97,37.13 v2(28.01,37.09) ; UI4.3 27.45,82.65 RI8.1 ; v2(26,34.77) CT80.2 25.97,35.29 RT12.2 ; CT99.2 26.04,37.73 v2(26.06,37.74) ; v2(26.63,34.77) CT81.2 CT82.2 ; CT100.2 25.88,39.52 v2(26.06,39.69)
  TOP w0.381: 26.5,23.49 26.67,23.31 v2(26.67,22.87) ; 26.5,23.49 PQ225.3 ; 26.5,23.49 26.66,23.49 26.99,23.82 26.99,24.06 28.08,25.15 PR271.2 ; v2(31.61,28.49) 31.61,28.45 31.89,28.17 32.58,28.17 PQ231.3 ; CT143.2 23.46,42.55 v2(23.46,42.94) ; UZ11.3 179.32,4.72 v2(178.81,5.22) ; 117.21,97.11 117.21,97.71 117.77,98.27 117.77,99.32 PC1107.2 ; v2(202.64,54.16) 202.42,54.38 QZ7.1 ; v2(161.67,105.48) 161.69,105.47 162.15,105.47 162.55,105.86 PC1008.2 ; PQ101.3 37.43,31.87 37.18,31.62 v2(36.9,31.62) ; v2(235.83,102.4) 235.95,102.27 QZ6.4 ; RH423.2 60.39,3.55 v2(60.39,4.14) 60.58,4.33 61.18,4.33 61.41,4.55 CZ19.2 ; CT145.2 11.47,35.1 v2(11.74,34.83) ; v2(134.14,74.04) 134.14,73.87 133.48,73.21 RH188.2 ; v2(123.16,56.1) 123.16,55.73 124.38,54.51 UC1.3 ; UZ12.3 174.43,4.71 174.66,4.95 RZ71.2 ; QZ7.4 v2(204.6,53.08) ; v2(13.41,85.16) 13.6,85.35 DV4.3 v2(17.11,85.35) ; v2(25.33,48.49) 25.15,48.3 RT3.1 ; RH565.2 82.35,6.31 82.35,5.61 v2(82.83,5.14) ; CE24.2 300.9,6.54 v2(300.84,6.6) ; v2(19.12,29.75) 19.14,29.78 CT106.2 ; RT5.2 31.25,35.92 30.37,35.92 29.96,36.33 v5(29.96,36.47) ; v5(31.23,37.74) 31.41,37.56 CT67.2 CT68.2 ; v2(17.18,81.29) DV5.3 13.98,81.29 v2(13.83,81.13) ; CT161.2 11.74,40.73 v2(11.69,40.78) ; CT65.2 26.16,40.24 v2(26.06,40.34) ; UV14.3 199.93,45.58 200.56,46.21 201.4,46.21 RV45.2 ; RZ74.2 244.43,2.07 244.45,2.09 244.45,2.65 v2(244.5,2.7) ; CT94.2 29.4,38.26 CT66.2 30.06,37.85 v2(29.96,37.74) ; v2(38.58,26.05) 38.45,25.93 38.45,24.7 CZ43.2 ; v2(89.71,10.92) 89.58,10.92 89.12,10.46 CH80.2 CH173.2 ; v2(235.92,76.01) 235.42,75.52 CV708.2 ; CT63.2 29.17,43.7 v5(29.31,43.56) ; UZ18.3 126.27,67.56 v2(126.27,67.56) ; v2(33.29,42.02) 33.81,42.53 CT50.2 ; UZ23.3 v2(105.22,52.06) ; v2(6.41,11.31) 6.62,11.11 PU204.3
  TOP w0.406: v2(20.63,103.54) 20.47,103.39 19.18,103.39 ; v2(9.17,39.4) 9.17,39.86 CT155.2 ; DI9.3 335.33,73.44 JUSB2.7
  TOP w0.457: v2(218.96,86.02) 219.1,85.89 CV605.2 ; v2(96.14,6.96) 96.14,6.3 CH51.1 ; v2(311.57,15.22) 311.67,15.33 QE4.1 ; RI13.1 322.82,49.65 322.61,49.86 UI5.3 ; CE55.2 279.18,9.58 UE4.6
  TOP w0.508: v2(220.51,81.67) 219.71,80.87 PC1049.2 ; v2(138.16,19.47) 138.15,19.46 CD75.2 ; PC1349.2 154.54,76.21 PC1354.2 154.16,76.59 v2(153.78,76.59) ; v2(241.88,100.57) 241.95,100.5 CV789.2 RV394.2 ; PC1305.2 144.93,74.6 v2(145.39,74.6) ; v2(208.93,86.75) 208.3,86.13 CV588.2 ; CE27.2 298.35,24.22 298.17,24.39 RE61.2 CE44.2 298.02,22.75 297.99,22.73 v2(297.99,22.7) ; UV16.2 18.7,90.49 v2(18.67,90.46) ; 212.73,79.51 212.09,79.51 v2(212.03,79.57) ; 212.73,79.51 PC1027.2 PC1082.2 212.73,75.62 PC1020.2 212.03,75.57 v2(211.98,75.52) 211.99,75.51 PC1003.2 212.19,74.16 PC1063.2 ; 212.73,79.51 PC1019.2 PC1074.2 ; PC1222.2 168.87,70.47 168.58,70.76 v2(168.58,71.19) 168.2,71.19 PC1220.2 ; v2(221.47,71.71) 221.23,71.94 CV589.2 ; v2(210.24,113.69) 210.3,113.63 QV23.3 ; v2(280.48,19.06) 280.28,19.26 280.28,19.95 RZ41.2 ; v2(145.13,70.8) 145.41,70.8 PC1378.2 ; CV650.2 RV355.2 224.93,107.29 225.36,107.72 225.36,108.52 224.91,108.97 v2(224.66,108.97) ; PQ209.3 28.82,2.87 v2(28.64,2.69) 28.64,1.84 PR269.2 ; v2(246.08,16.86) 246.09,16.86 246.09,17.63 246.89,18.44 RD38.2 ; QF1.4 228.53,48.58 v2(228.04,48.08) ; CV586.2 196.37,66.05 v2(195.71,65.39) ; PC1070.2 215.93,74.3 CV604.2 217.17,74.3 v2(217.41,74.55) ; CZ18.2 RZ46.1 57.2,7.82 CZ11.2 55.88,8.14 v2(56.26,8.52) ; v2(109.45,6.95) 109.22,6.73 RH529.2 ; CV616.2 203.69,68.58 v2(203.89,68.38) ; RD30.2 CD18.2 150.19,19.09 v2(150.48,19.37) ; v2(221.53,83.38) 221.11,83.38 CV591.2 ; v2(336.47,29.09) 336.47,30.23 PC414.2 ; CV810.2 241.28,66.65 v2(241.28,66.26) 241.22,66.21 RV381.2 ; v2(230.62,62) 230.77,62.15 RV314.1 RV315.1 ; RN33.1 338.7,104.61 v2(338.58,104.72) ; v2(154.78,70.74) 155.13,70.74 PC1363.2 ; RZ50.2 v2(110.55,64.51) ; v2(289.56,13.53) 290.06,14.03 CE21.2 CE20.2 ; CV728.2 234.9,95.18 v2(234.97,95.26) ; v2(214.67,8.48) 215.25,7.9 CE77.2 ; v2(243.91,86.07) 243.76,86.22 CV731.2 ; v2(148.5,76.44) 148.9,76.44 PC1306.2 150.24,76.02 PC1348.2 ; CD23.2 216.68,27.25 v2(216.17,27.75) ; PC1390.2 170.67,73.48 v2(171.05,73.48) 171.05,73.14 170.74,72.82 PR810.1 ; QV22.3 231.77,101.12 228.92,101.12 v2(228.84,101.04) ; CV732.2 239.25,88.08 v2(239.26,88.1) ; CV584.2 198.08,62.62 v2(197.66,63.04) ; v2(202.21,49.21) 201.55,48.55 RV45.2 ; v2(78.71,11.51) 78.28,11.08 CH191.2 ; v2(17.17,4.03) 16.79,4.42 PR240.2 ; CV812.2 247.14,94.89 v2(246.32,94.89) ; v2(201.07,111.38) 201.3,111.61 201.3,112.01 CV676.2 ; v2(224.64,8.64) 224.64,9.05 224.87,9.28 RZ32.1 ; PC1269.2 164.45,70.37 PC1243.2 ; PC1269.2 164.01,70.56 v2(163.62,70.56) ; PC1269.2 164.42,70.14 PC1248.2 ; CH183.2 85.59,17.86 v2(85.81,17.64) ; PD101.1 21.63,12.49 v2(21.63,10.8) ; CH197.2 120.46,52.77 v2(120.94,52.29) ; v2(204.37,92.12) 204.32,92.17 CV599.2 202.25,92.17 CV598.2 ; RV343.2 220.7,86.94 221.43,87.67 v2(221.47,87.67) ; CV592.2 214.64,84.86 213.81,84.86 213.45,84.5 PC1062.2 213.11,85.05 v2(213.08,85.07) ; RH88.1 95.73,9.03 v2(95.37,9.39) ; JRTC.2 v2(328,102.77) ; 31.09,21.87 29.62,21.87 29.03,21.28 PU203.2 ; v2(228.41,97.93) 228.41,96.96 CV791.2 ; v2(290.19,22.94) 290.25,22.89 CE34.2 ; SW2.1 v2(348.63,109.11) ; CH201.2 106.85,12.57 105.64,11.36 105.36,11.36 v2(105.21,11.21) ; v2(220.7,78.3) 220.7,77.62 CV636.2 ; CV607.2 219.06,79.25 CV608.2 218.71,79.26 v2(218.41,79.56) 218.4,79.57 PC1048.2 ; UZ20.3 180.13,5.15 v2(179.87,5.41) ; RH209.2 123.81,17.05 v2(124.14,16.73) ; v2(214.29,111.36) 213.88,111.77 CV653.2 CV654.2 ; v2(179.87,4.02) 179.63,3.78 RZ85.2 ; v2(158.54,81.45) 157.87,80.78 PC1320.2 PC1328.2 v2(157.87,78.62) ; v2(343.07,114.82) 343.19,114.94 DL1.1 ; CE75.2 v2(159.83,9.15) 159.83,10.05 CE76.2 ; JAUDIO.36 19.28,20 v2(19.33,20.05) ; v2(222.29,100.16) 222.14,100 CV663.2 ; PC1015.2 211.49,82.08 v2(212.03,81.54) ; v2(176.16,5.25) 175.86,4.95 RZ71.2 ; v2(204.26,102.56) 204.26,102.78 203.89,103.15 CV683.2 ; v2(175.45,21.1) 175.45,19.57 CD13.2 174.6,18.72 CD12.2 ; PC1321.2 PC1322.2 149.7,78.69 150.16,78.23 v2(150.16,77.92) 150.54,77.92 PC1377.2 PC1376.2 ; CE31.2 v2(305.56,10.98) ; QF1.1 226.97,50.19 v2(227.33,50.55) ; PC1333.2 151.13,69.54 150.67,70 PC1373.2 150.24,70.8 v2(149.96,70.8) ; CH108.2 171.81,80.66 171.17,81.3 v2(171.17,81.51) 170.58,81.51 CH111.2 ; CD15.2 CD14.2 176.15,19.6 v2(176.16,19.62) ; v2(25.05,28.44) 25.11,28.38 PR238.1 ; v2(285.75,6.46) 285.75,6.46 285.75,6.24 286.94,5.04 CE71.2 ; CV613.2 204.61,89.44 v2(204.79,89.26) ; CH107.2 173.91,79.18 CH110.2 174.33,78.41 v2(174.52,78.6) ; PC1044.2 216.75,72.77 v2(217,72.52) ; v2(152.27,79.21) 151.84,79.64 PC1325.2 PC1324.2 ; PC1073.2 208.81,80.84 v2(208.18,81.47) 208.83,82.11 PC1014.2 ; v2(242.35,92.46) 242.07,92.17 CV729.2 ; CE48.2 309.22,17.51 v2(309.22,16.99) ; PC329.2 34.48,3.5 v2(34.04,3.95) ; CV700.2 243.05,65.59 242.27,66.38 v2(242.27,66.41) ; v2(139.9,19.56) 139.57,19.23 CD74.2 ; v2(246.32,93.27) 246.41,93.18 CV814.2 ; v2(221.46,75.89) 221.54,75.81 CV609.2 ; PC1247.2 v2(168.55,68.54) 168.55,69.11 PC1221.2 ; v2(104.96,2.83) 105.47,2.83 CH53.2 ; CV597.2 v2(207.05,83.64) ; CV798.2 203.2,64.93 v2(203.94,64.19) ; v2(211.05,109.1) 210.6,109.1 210.24,108.73 CV802.2 CV776.2 ; CZ12.2 v2(316.74,37.22) ; CV583.2 198.69,60.78 v2(198.37,60.46) ; v2(215.11,70.13) 215.13,70.15 CV623.2 ; v2(5.44,29.73) 4.5,29.73 4.37,29.85 4.37,29.96 4.24,30.08 DT10.1 ; CH118.2 151.96,68.02 v2(152.1,67.87) ; CE13.2 152.72,11.68 v2(152.72,10.78) ; JAUDIO.33 1.9,13.79 v2(2.26,13.43) ; CV702.2 247.29,78.45 v2(246.33,78.45) ; v2(205.06,111.36) 205.12,111.42 CV679.2 ; PC334.2 50.61,11.22 v2(51.03,10.8) ; CV705.2 238.55,66.16 v2(238.3,66.41) ; CH128.2 175.39,62.4 175.81,61.99 v2(175.95,61.99) ; v2(116.1,97.11) 116.59,97.6 PC1132.2 ; v2(124.27,104.34) 124.21,104.28 PR1129.2 PC1114.2 PC1115.2 ; PC1109.2 110.99,105.86 110.71,105.59 110.71,105.58 v2(110.43,105.29) ; CV813.2 242.24,94.94 v2(242.31,94.87) ; PC1035.2 215.09,72.15 v2(215.09,72.52) ; JTAG1.2 v2(298.44,26.06) ; v2(50.1,19.19) 49.77,18.86 PC320.2 ; CE22.2 v2(309.16,21.54) ; CH102.2 174.47,69.92 v2(174.51,69.96) ; v2(246.39,96.37) 246.75,96.73 CV735.2 ; CH135.2 169.89,84.09 169.53,83.73 v2(169.53,83.43) ; QV24.3 247.6,64.39 247.97,64.02 CV701.2 248.29,63.05 v2(248.39,62.95) ; v2(212.08,20.74) 212.25,20.74 212.93,20.05 CD20.2 ; CZ97.2 179.68,86.37 179.3,86.75 v2(178.81,86.75) ; JRTC.4 v2(330.85,97.18) ; CV808.2 241.54,77.21 241.92,76.83 v2(242.31,76.83) ; CI1.2 v2(23.86,86.66) ; CD80.2 222.96,28.47 v2(222.74,28.26) ; CN22.2 v2(332.46,102.05) ; v2(284.97,13.07) 284.97,13.24 CE37.2 ; PR406.2 v2(349.56,18.04) ; v2(117.22,97.11) 117.21,97.11 117.36,97.27 PC1126.2 ; v2(193.37,112.57) 193.07,112.87 CV682.2 ; PC1341.2 PC1335.2 145.2,78.58 v2(145.2,78.04) 144.92,78.04 PC1379.2 ; QZ6.1 237.96,103.45 v2(238.15,103.64) 238.15,104.43 QZ8.3 ; CV734.2 v2(244.64,81.23) ; CV687.2 196.72,98.22 CV688.2 195.87,98.24 v2(194.65,99.45) ; CD79.2 v2(142.86,27.61) CD78.2 ; CV590.2 v2(212,83.99) ; CD26.2 v2(210.65,27.99) ; v2(242.19,88.8) 242.34,88.65 CV811.2 ; PR292.2 16.51,1.66 v2(16.38,1.53) ; v5(29.96,43.57) 29.96,43.42 30.32,43.06 RT2.2 ; CD82.2 218.48,27.59 v2(219.16,27.59) 219.83,27.59 CD81.2 ; PC418.2 339.17,20.98 v2(338.96,20.77) 338.96,20.29 PC419.2 ; PC1018.2 209.82,71.9 v2(209.2,72.52) 209.1,72.52 PC1076.2 ; v2(181.35,16.87) 181.1,16.62 CZ53.2 ; CH70.2 85.13,5.27 v2(85,5.14) ; v2(22.3,27.31) 22.28,27.31 21.97,27.62 21.97,28.06 PQ229.3 ; v2(218.1,75.51) 217.72,75.89 PC1043.2 ; JCR.21 332.82,34.5 333.06,34.75 v2(333.06,35.19) ; v2(232.3,16.86) 232.3,16.85 231.96,16.51 RH212.2 ; PC400.2 349.57,21.13 v2(349.57,21.75) 349.34,21.98 PR403.1 ; v2(307.29,12.54) CE19.2 CE18.2 ; DE2.1 v2(347,110.94) ; PR410.2 v2(349.56,17.09) ; v2(266.01,19.91) 266.01,18.91 266.37,18.55 CD39.2 CD38.2 ; RV392.1 245.5,91.31 v2(245.5,91.64) ; v2(213.62,11.64) 213.62,13.04 DE5.1 ; JCR.4 326.52,51.85 326.29,52.08 v2(326.26,52.08) 326.02,51.84 CR15.2 ; CV680.2 204.29,107.32 v2(204.26,107.36) ; RV479.2 v2(205.59,68.33) ; v2(142.3,20.98) 142.55,20.98 142.95,20.59 CD6.2 ; PC1233.2 167.97,69.73 PC1223.2 167.46,68.74 v2(167.65,68.55) ; v2(222.63,46.68) PC912.2 ; v2(24.18,18.87) 24.18,18.7 PC218.2 ; v2(255.33,19.78) 254.86,19.78 CD88.2 CD89.2 CD90.2 ; v2(207.03,73.49) 207.2,73.32 CV570.2 207.1,72.77 206.5,72.77 CV794.2 ; CH188.2 94.77,14.22 v2(94.77,13.76) ; CV656.2 222.73,106.26 223.1,106.62 v2(223.1,107.39) ; PC1351.2 154.49,73.53 PC1353.2 154.16,73.86 v2(153.78,73.86) ; CD73.2 135.09,27.27 v2(134.28,28.08) ; RH544.2 110.58,5.28 v2(110.78,5.09) ; v2(120.79,1.9) 120.03,2.66 SW4.5 ; v2(104.14,6.8) 104.14,7.3 103.75,7.69 103.75,8.73 RH95.1 ; v2(172.82,87.79) 173.1,87.51 CH113.2 CH112.2 ; CT162.2 CT105.2 17.78,33.92 17.27,34.43 14.98,34.43 v2(14.1,35.31) ; CE28.2 289.82,18.09 289.23,18.09 288.35,18.97 v2(288.35,19.02) ; PR105.2 37.58,34.9 38.11,35.43 40.69,35.43 v2(41.96,36.7) ; RH210.2 233.88,16.7 234.05,16.86 v2(234.05,16.86) ; QE4.4 310.37,13.76 v2(310.08,13.47) ; v2(109.41,66.11) 109.03,65.73 PC800.2 ; v2(234.94,67.63) 235,67.69 CV704.2 ; PC1352.2 PC1360.2 154.23,75.19 v2(153.85,75.19) ; v2(149.35,4.14) 148.91,4.58 CE14.2 148.65,5.43 CE12.2 ; PD102.1 18.63,10.6 v2(18.63,10.17) ; PC1225.2 PC1224.2 v2(167.27,78.38) ; CV793.2 221.76,65.57 v2(222.28,65.05) ; CD32.2 250.82,18.87 CD90.2 ; v2(159.34,81.49) 159.78,81.06 PC1246.2 ; v2(213.99,27.76) 214.5,27.25 CD25.2 ; v2(84.62,17.29) 84.66,17.33 RH528.2 ; RH183.2 132.47,78.2 RH184.2 133.45,78.2 v2(133.64,78.01) ; v2(131.28,104.36) 131.71,104.8 RH498.1 ; v2(170.39,65.22) 170.36,65.19 CH120.2 ; RV109.2 52.34,26.69 v2(52.59,26.44) ; v2(20.87,91) 21.39,90.48 RI6.2 RI7.2 ; v2(18.67,78.24) 19.5,78.24 20.41,77.34 QV13.3 ; CV678.2 CV681.2 197.73,111.52 198.66,110.6 v2(198.66,110.59) ; v2(208.12,77.61) 208.85,76.89 PC1083.2 ; v2(208.12,77.61) 207.58,77.07 CV580.2 ; v2(208.12,77.61) 207.54,78.19 CV582.2 ; v2(16.89,21.97) 17.03,22.12 PQ233.3 ; CI21.2 RI26.2 v2(27.43,88.22) ; PC1339.2 145.41,68.81 v2(145.7,68.52) ; PC1364.1 v2(114.75,94.88) ; PC335.2 v2(349.06,26.81) ; PQ226.3 28.5,25.59 PR271.2 ; CV593.2 211.1,84.3 v2(211.1,83.55) 210.94,83.39 PC1012.2 ; CE78.2 216.33,10.25 215.96,10.62 v2(215.96,11.03) ; JAUDIO.32 1.91,17.24 v2(1.91,15.82) ; CH46.2 100.38,1.81 v2(100.42,1.85) ; v2(91.83,5.11) 91.94,5.22 CH52.2 ; v2(306.02,18.35) 306.02,18.68 CE52.2 ; v2(77.98,2.74) 77.51,2.27 RH455.1 ; PC1326.2 v2(154.89,68.53) ; CV796.2 v2(206.48,67.51) ; v2(30.36,27.17) 30.36,27.36 29.44,28.28 29.44,28.78 29.8,29.14 PC224.2 ; v2(136.76,27.82) 136.56,27.62 CD2.2 ; v2(289.64,12) CE42.2 CE43.2 ; v2(173.86,66.81) 174.19,67.14 CZ49.2 ; PC1101.2 117.67,112.11 118,112.44 PC1102.2 v2(118.62,113.12) ; v2(169.05,78.38) PC1231.2 PC1240.2 169.05,81.23 v2(168.76,81.51) ; UV17.4 66.58,23.8 v2(66.66,23.72) ; RE27.2 300.98,28.08 v2(301.01,28.11) 301.04,28.11 301.88,27.26 RE33.1 RE32.1 ; v2(244.71,69.63) 245.35,69.63 CV703.2 ; v2(161.21,70.62) 161.59,70.62 PC1261.2 ; v2(223.89,103.36) 223.85,103.4 CV652.2 ; RZ40.2 38.37,28.95 38.09,29.23 37.59,29.23 v2(37.5,29.14) ; PC1239.2 v2(158.86,78.64) ; v2(197.85,107.33) 198.27,107.33 198.58,107.02 CV805.2 ; v2(5.91,34.97) 5.63,35.25 RT199.2 ; PR906.2 v2(223.08,50.81) 223.08,50.62 223.32,50.38 PR912.2 ; v2(216.1,75.29) 216.09,75.29 216.09,75.26 215.52,75.26 PC1013.2 PC1081.2 ; v2(120.08,20.47) 120.08,19.9 120.74,19.24 RH211.2 ; v2(29.02,7.95) 28.96,7.95 28.91,7.9 28.9,7.9 28.68,7.67 28.68,7.67 28.45,7.44 PR299.2 ; v2(293.79,25) 293.79,24.43 CE39.2 ; v2(78.74,13.79) 78.6,13.93 CH190.2 ; CV803.2 206.06,107.16 v2(205.86,107.36) ; v2(347.32,115.25) 347.89,115.82 CE16.2 CE15.2 ; v2(221.53,59.34) 221.53,59.06 221.18,58.72 RV318.2 ; PC1361.2 149.82,73.55 PC1310.2 ; v2(111.68,8.36) 111.89,8.16 UH14.3 ; v2(50.29,13.47) 49.54,14.22 PC319.2 ; CT160.2 CT159.2 6.22,32.19 v2(5.08,31.05) ; v2(153.02,67.87) 153.03,67.89 PC1332.2 ; CV581.2 207.64,76.18 v2(208.07,75.74) 208.18,75.64 PC1028.2 209.3,75.19 PC1004.2 ; v2(246.3,76.04) 246.35,75.99 CV713.2 ; DI8.1 20.3,100.16 v2(20.7,100.57) ; RV107.2 55.47,26.91 v2(55.47,26.48) ; PR508.2 v2(136.46,2.14) ; v2(219.05,76.53) 219.21,76.69 PC1054.2 ; v2(248.34,81.4) 248.3,81.37 QV25.3 ; v2(151.19,64.7) 151,64.51 CH121.2 ; v2(291.28,5.76) 291.49,5.97 291.49,6.25 291.78,6.54 CE70.2 ; v2(149.55,9.55) 149.56,9.56 149.56,9.88 149.57,9.9 149.57,10.11 149.85,10.38 CE8.2 ; CD35.2 247.99,25.9 CD34.2 247.99,27.79 v2(248.1,27.9) ; v2(7.82,24.1) 8.5,24.77 PR264.1 ; UZ10.2 182.06,8.45 CZ54.2 181.61,7.5 v2(181.61,6.55) ; v2(203,67.51) 202.17,67.51 CV600.2 ; PC1116.2 125.74,108.01 PC1110.2 v2(125.76,108.81) ; CZ8.2 306.16,31.81 305.86,31.5 v2(305.86,31.29) ; v2(159.13,4.2) 159.16,4.23 CE11.2 ; RH580.2 95.59,15.36 v2(95.59,16.12) ; PC1071.2 216.37,82.11 216.95,82.69 v2(217.04,82.69) 216.39,83.34 PC1051.2 ; RZ80.2 129.82,67.95 v2(129.82,67.96) ; RZ52.2 183.16,16.49 v2(182.79,16.87) ; CZ4.2 v2(307.98,33.66) ; CH82.2 93.68,16.5 v2(93.29,16.12) ; v2(248.44,86.18) CV726.2 RV395.2 ; v2(216.68,100.15) 216.68,99.64 CV657.2 ; RV379.1 244.69,72.93 v2(244.77,72.85) ; PC1311.2 145,76.44 v2(145.45,76.44) ; v2(91.23,12.22) 91.44,12.01 CH203.2 ; CV596.2 CV595.2 207.44,82.36 v2(207.17,82.62) ; PC1075.2 215.15,80.55 v2(215.24,80.46) ; RV369.2 203.46,111.69 v2(203.46,111.36) ; v2(221.55,107.26) 221.56,107.25 RV353.1 ; CH186.2 91.09,7.32 v2(90.81,7.05) ; CV806.2 195.61,107.21 v2(195.45,107.36) ; RE44.2 289.21,16.44 289.38,16.44 v2(289.57,16.25) ; CH45.2 v2(100.46,2.74) ; CE53.2 v2(273.72,7.06) ; PC1386.2 170.48,79.19 v2(170.86,79.19) ; CE17.2 v2(291.21,11.25) ; v2(169.57,86.04) 169.87,86.04 170.38,86.55 170.38,86.89 170.08,87.19 CH134.2 ; v2(307.9,4.66) 307.51,5.05 303.51,5.05 CE40.2 ; JCR.22 331.95,60.03 331.36,59.43 v2(330.35,59.43) ; CD83.2 215.87,18.62 CD22.2 215.87,19.94 v2(215.86,19.95) ; CZ46.2 v2(244.86,6.77) ; v2(233.39,50.11) 233.39,50.63 CF1.2 ; v2(244.71,83.66) 244.71,83 CV736.2 ; v2(170.39,66.58) 170.39,66.87 170.23,67.04 CH127.2 ; SW2.2 v2(348.63,112.78) ; CD85.2 226.4,28.65 v2(226.72,28.32) ; PC1232.2 161.43,68.86 161.08,68.51 v2(160.33,68.51) ; v2(218.15,20.98) 218.64,20.98 219.25,20.38 CD24.2 ; CD90.2 251.41,19.08 v2(250.77,19.72) ; v2(147.5,68.53) 147.38,68.64 PC1340.2 ; v2(134.81,19.44) 135.18,19.07 CD77.2 ; CE51.2 298.71,6.09 v2(299.02,5.78) ; PC1244.2 PC1242.2 v2(161.62,78.04) ; PC1342.2 149.22,68.26 CH124.2 149.61,67.87 v2(150.27,67.87) ; v2(198.68,103.36) 198.26,103.36 CV804.2 ; v2(201.06,100.96) 201.19,100.82 RV340.2 ; v2(237.51,68.03) 237.45,68.09 CV707.2 ; v2(154.39,79.19) 153.88,79.7 PC1329.2 PC1331.2 ; PR501.2 PC500.2 v2(131.57,1.53) ; v2(152.37,70.8) 152.65,70.8 PC1372.2 ; PC1138.1 109.55,108.26 108.97,108.85 v2(108.97,109.23) ; v2(66.54,31.71) 65.86,32.38 CV156.2 ; v2(213.54,100.16) 213.64,100.06 213.64,99.6 CV662.2 ; v2(225.11,11.95) 225.11,11.76 224.41,11.06 CE65.2 ; PC1072.2 217.2,80.84 v2(217,80.64) ; PC1271.2 161.91,71.51 PC1276.2 161.53,71.89 v2(161.15,71.89) ; PC1034.2 213.1,72.23 v2(213.1,72.52) ; PC1131.2 115.43,99.28 115.43,97.99 114.85,97.41 114.27,97.41 113.79,97.89 113.34,97.89 112.9,98.32 v2(112.9,98.92) 113.44,98.92 PR1138.1 ; v2(171.05,74.81) 170.67,74.81 PC1385.2 ; CZ57.2 v2(132.07,69.83) 132.02,69.88 RH186.2 ; CV799.2 214.16,102.48 v2(214.24,102.56) ; v2(155.77,68.51) 155.89,68.39 CH119.2 ; v2(218.99,64.21) 219.52,64.74 CV792.2 ; CH109.2 176.15,80.84 176.79,80.84 177.1,80.53 v2(177.1,80.22) ; v2(185.19,98.08) 185.19,97.82 184.85,97.48 PR1013.1 ; v2(227.59,97.95) 227.59,97.11 CV637.2 CV639.1 ; v2(204.7,85.92) 204.9,86.13 CV610.2 205.65,86.13 206.22,86.7 CV611.2 ; CH189.2 98.57,9.52 v2(98.3,9.25) 98.87,8.68 RH401.1 ; v2(112.1,3.74) 112.1,3.4 111.62,2.92 SW4.4 ; v2(155.24,77.86) 155.52,77.86 155.84,77.54 PC1375.2 155.94,78.65 PC1330.2 PC1338.2 ; CV797.2 224.13,58.21 v2(223.62,58.72) ; v2(221.62,61.24) 221.47,61.39 RV544.2 ; v2(224.69,110.56) 224.9,110.77 CV801.2 ; v2(171.34,16.87) 171.34,17.39 RD28.2 ; JCR.20 v2(349.42,34.5) ; v2(178.79,84.76) 178.76,84.79 CH117.2 ; v2(208.18,79.47) 208.35,79.64 PC1016.2 PC1021.2 ; CV727.2 236.2,83.96 v2(236.71,84.46) ; RE70.1 285.87,8.87 v2(285.36,9.37) ; JCR.19 v2(349.6,42.75) ; v2(235.04,87.67) 234.96,87.67 234.57,87.27 CV738.2 ; v2(31.88,3.88) 31.7,3.71 PQ210.3 ; v2(308.15,15.33) RE57.2 CE25.2 ; PR1107.2 122.44,112.33 v2(122.01,112.76) 121.55,112.3 PR1108.2 ; PC1129.2 PR1137.2 v2(112.17,99.55) ; CV795.2 222.24,58.48 v2(222.03,58.68) ; CV711.2 v2(245.5,72.81) ; PR405.1 v2(347.98,24.41) ; CD5.2 150.22,28.65 v2(150.53,28.34) ; SW1.4 v2(331.41,118.15) ; JCR.15 v2(349.55,50.25) ; v2(178.79,88.17) 178.4,87.79 CH114.2 ; CT165.2 19.1,43.14 v2(19.07,43.17) ; RE31.1 v2(310.44,17.01) ; CV651.2 RV356.2 215.9,113.11 v2(215.89,113.12) ; CD29.2 RD40.2 227.49,19.1 227.44,19.15 v2(227.44,19.85) 227.93,19.85 CD84.2 ; PC1033.2 v2(212.23,71.07) ; v2(21.85,9.09) 21.39,8.63 PQ234.3 ; RV330.2 226.33,56.64 v2(226.82,56.14) 227.22,56.54 RV501.1 ; CH187.2 v2(100.14,4.5) ; CV778.2 v2(241.85,80.9) ; RE13.2 160.24,7.95 v1(160.64,7.54) 160.64,7.01 v2(160.48,6.85) 159.61,5.98 RE127.2 ; CV706.2 234.97,77.77 235.13,77.61 v2(235.13,77.64) ; v2(324.55,48.84) 324.8,48.59 CR14.2 ; PC1304.2 144.93,72.37 v2(145.32,72.37) ; v2(172.31,71.93) 172.72,72.34 CH103.2 ; RI8.1 28.16,82.46 v2(28.28,82.58) ; v2(244.58,98.88) 244.96,98.5 CV733.2 ; CZ95.2 227.36,61.35 v2(226.95,61.76) 226.78,61.92 RV313.1 ; JRTC.3 v2(323.9,97.13) ; CE23.2 304.67,24.34 v2(304.67,24.94) ; RH77.2 61.91,10.82 v2(62.33,10.4) ; CV615.2 203.34,69.78 v2(203.9,69.22) ; v2(267.03,2.9) 267.51,3.39 CD40.2 CD41.2 ; v2(134.52,5.98) 135.05,6.51 PC503.2 ; CV129.2 198.68,49.13 v2(199.07,49.53) 198.68,49.92 RV187.2 ; CZ96.2 v2(183.14,87.58) ; PR812.2 107.13,65.67 v2(107.51,66.05) ; CH202.2 104.43,11.06 v2(104.59,11.21) ; 139.87,27.76 140.38,27.25 CD72.2 ; 139.87,27.76 139.87,28.43 v2(139.87,28.43) ; 139.87,27.76 139.87,27.75 139.37,27.25 CD8.2 ; v2(145.07,20.04) 145.07,19 145.4,18.67 CD70.2 ; CZ45.2 237.55,6.76 v2(237.57,6.75) ; CD69.2 133.29,17.04 v2(133.14,16.9) ; CH106.2 176.33,82.44 v2(176.45,82.56) 176.45,82.86 176.2,83.11 CH105.2 ; v2(246.48,70.56) 247.12,70.56 CV712.2 ; v2(162.15,68.51) 162.35,68.72 PC1245.2 ; v2(61.15,26.5) 59.94,26.5 59.56,26.12 RV114.2 ; RD39.2 v2(251.33,24.22) ; v2(280.19,8.5) 280.08,8.39 CE54.2 ; PC1374.2 147.83,70.8 v2(147.55,70.8) ; v2(323.89,55.04) 323.29,54.44 RI27.2 CI22.2 ; CV659.2 v2(225.3,113.17) ; v2(120.84,67.64) 121.26,67.22 RZ87.2 122.37,65.17 UZ22.3 ; CV612.2 198.49,91.26 v2(198.96,90.79) ; v2(41.96,27.39) 42.87,28.3 UZ8.2 ; PR404.2 v2(349.56,19.82) ; RI13.1 322.82,49.02 323.09,48.75 v2(323.09,48.7) ; CH126.2 167.8,65.2 v2(167.66,65.34) ; RV328.2 RV329.2 215.24,71.01 v2(215.18,70.94) ; v2(226.26,21.03) 226.26,19.6 225.34,18.68 CD86.2 ; v2(298.04,3.43) 298.04,3.48 298.45,3.88 RE30.2 ; PD100.2 15.71,76.84 v2(14.77,77.78) ; PC1359.2 150.09,74.94 PC1310.2 ; PC1323.2 v2(156.73,69.97) ; CF2.2 v2(231.72,58.51) ; v2(216.29,107.2) 216.07,107.42 CV800.2 ; JCR.7 326.92,43.5 v2(326.28,42.86) ; v2(159.5,63.24) 158.89,63.24 CD7.2 ; CH125.2 162.05,66.72 v2(162.16,66.61) ; PC1103.1 PC1100.1 v2(111.1,110.73) ; v2(75.12,26.59) 75.72,27.19 CH180.2 ; CV725.2 241.48,82.25 v2(241.81,81.92) ; CH176.2 85.46,7.49 85.18,7.21 v2(84.87,7.21) ; v2(220.46,104.33) 220.46,104.91 CV660.2 ; JCR.12 v2(349.56,54.8) ; PC1017.2 211.01,72.33 v2(211.2,72.52) ; v2(229.05,97.9) 229.22,98.08 CV790.2 ; v2(217.06,76.54) 217.66,77.14 PC1077.2 ; v2(94.16,7.34) 94.07,7.34 93.59,6.85 CH200.2 ; CD21.2 212.86,27.62 v2(213.06,27.82) ; v2(223.89,100.16) 223.91,100.13 CV661.2 ; v2(246.44,68.01) 246.57,67.89 CV710.2 ; PC1310.2 148.84,74.53 v2(148.43,74.53) ; CV655.2 v2(221.06,113.11) ; PC1300.2 PC1303.2 148.71,72.37 v2(148.31,72.37) ; RV382.2 246.48,66.33 v2(246.41,66.4) ; v2(214.38,79.57) 214.25,79.45 PC1080.2 213.69,78.19 PC1079.2 ; v2(122.71,57.06) 121.92,57.85 UZ19.3 ; v2(147.6,20.66) 148.65,19.6 CD71.2 ; v2(193.04,108.98) 192.66,108.61 CV677.2 ; v2(285.3,17.56) 285.08,17.56 284.65,17.13 284.65,16.58 283.83,15.76 RE75.1 RE74.1 ; RH567.2 77.9,8.89 78.28,9.26 v2(78.73,9.26) ; v2(170.56,27.74) 170.9,27.39 CD16.2 170.9,26.13 171.02,26.02 CD17.2 ; PR1109.2 120.59,112.33 v2(120.16,112.76) 119.7,112.3 PR1110.2 ; v2(163.52,78) PC1230.2 PC1229.2 ; CV606.2 215.04,90.32 v2(214.77,90.05) ; v2(158.5,67.21) 158.33,67.38 CH122.2 ; PR263.2 9.46,21.48 v2(8.99,21.01) ; v2(132.86,74.04) 132.86,74.43 RH185.2 132.08,74.79 RH187.2 ; v2(212.08,22.11) 211.84,22.11 211.31,21.57 211.31,18.79 CD19.2 ; CV809.2 242.27,68.77 v2(242.31,68.81) ; CV157.2 65.51,31.25 v2(65.04,31.72) ; CV807.2 238.18,77.52 v2(238.28,77.62) ; v2(199.12,113.99) 198.61,113.47 RV366.1 ; CV658.2 v2(222.83,113.1) ; v2(194.63,107.36) 194.73,107.26 CV777.2 ; v2(218.99,67.51) 218.91,67.43 CV621.2 ; v2(165.36,78) PC1226.2 PC1241.2 ; CV686.2 204.18,100.08 v2(204.26,100.16) ; RV312.1 226.54,63.19 v2(227.13,63.78) 227.27,63.64 227.27,63.08 227.67,62.67 RV310.1 ; v2(98.32,11.49) 98.07,11.74 RH581.2 ; CZ9.2 v2(313.44,38.62) ; CV601.2 202.06,65.87 202.06,65.25 v2(202.26,65.05) ; v2(328,77.57) 328.35,77.57 328.35,77.54 CH44.2 ; CZ6.2 v2(307.91,35.06) ; CD76.2 v2(136.63,19.45) ; v2(195.75,64.27) CV585.2 ; v2(163.67,108.47) PC1029.2 ; PR1018.1 v2(163.59,112.72) ; CV619.2 CV622.2 216.22,66.91 v2(216.45,66.68) ; PC1209.2 v2(150.94,102.24) ; PC1052.2 217.2,78.36 v2(216.99,78.56) ; v2(13.4,87.39) 14.18,87.39 CV178.2 15.14,87.94 15.25,87.83 CV179.2 ; v2(294.26,29.6) 294.26,29.31 293.86,28.91 293.21,28.91 PC613.2 ; CV614.2 203.15,70.84 v2(203.05,70.94) ; RE85.1 v2(152.45,3.65) ; PR1116.2 124.22,111.25 v2(123.83,111.64) ; JAUDIO.31 2.82,20 3.11,19.71 v2(3.11,18.86) ; v2(220.72,20.41) 221.21,20.41 222.24,19.37 CD87.2 ; v2(170.88,76.23) 170.47,76.23 PC1382.2 ; CV684.2 202.66,99.54 v2(202.66,100.16) ; CI19.2 v2(332.03,71.51) ; CV638.2 222,86.22 v2(222.31,85.9) ; CE67.2 v2(322.84,36.71) ; v2(96.6,37.3) 96.6,37.58 96.98,37.96 98.1,37.96 CE66.2 ; v2(266.68,19.92) 266.68,19.91 267.42,20.65 CD36.2 ; CV603.2 218.61,90.19 218.97,89.82 v2(218.97,89.2) ; CH174.2 v2(131.14,93.73) ; CE41.2 RE58.2 v2(307.21,8.47) ; v2(112.22,114.28) 112.45,114.05 PC1137.2 ; v2(153.97,72.53) 154.33,72.53 PC1350.2 PC1362.2 ; CE55.2 280.06,9.28 v2(280.19,9.16) ; v2(146.56,28.43) 146.56,28.41 146.62,28.47 CD1.2 ; CH133.2 172.38,86.79 v2(171.88,86.79) ; v2(162.06,63.32) 162.45,62.93 CH123.2 ; v2(10.86,13.22) 11.13,12.95 PC225.2 ; CH116.2 174.67,84.97 v2(175.08,85.38) ; CE38.2 v2(288.2,14.94) ; 222.76,8.64 v2(221.24,8.64) ; PC1104.1 v2(110.36,107.13) ; v2(234.97,93.72) 234.94,93.76 CV737.2 ; RV311.1 v2(233.44,62.04) ; PC708.1 v2(248.54,49.55) ; PC900.2 v2(220.16,55.74) ; RV414.2 234.57,89.05 v2(234.96,89.44) 235,89.4 CV730.2 ; PC1327.2 PC1334.2 147.62,78.46 v2(147.62,77.92) 148,77.92 PC1314.2 ; v2(172.26,77.89) 172.65,77.49 CH104.2 ; PR700.1 v2(248.53,48.46) ; v2(217.55,46.07) PC913.2 ; RZ88.2 v2(109.87,52.76) ; PC1121.2 v2(124.08,108.02) ; UE2.1 v2(347.44,120.66) ; CV617.2 v2(213.97,69.1)
  IN5 w0.508: v2(21.68,46.32) 21.79,46.32 22.35,45.76 22.35,44.71 21.91,44.27 21.91,42.04 21.51,41.64 v2(21.09,41.64)
  BOTTOM w0.102: v2(81.56,18.58) UH2.R38
  BOTTOM w0.127: v1(349.56,51.09) 349.55,51.08 v2(349.55,50.25) ; v2(344.89,44.55) 344.89,44.56 344.91,44.57 344.91,45.28 v1(344.39,45.81) ; v2(112.22,114.28) v1(111.44,114.28) ; 97.35,26.49 97.35,26.36 97.01,26.02 96.86,26.02 96.7,25.86 96.7,25.5 UH2.B6 ; v1(327.18,73.5) 327.69,73 v2(327.92,73) ; v1(348.65,34.51) 348.66,34.5 v2(349.42,34.5) ; v2(313.44,38.62) 313.44,38.64 v1(313.96,39.16) ; v1(349.57,54.07) 349.56,54.09 v2(349.56,54.8) ; v1(308.66,35.06) v2(307.91,35.06) ; v2(326.71,78.05) v1(326.71,77.21)
  BOTTOM w0.152: UH2.B25 UH2.A25 87.29,25.8 87.53,26.03 88.2,26.03 v2(88.47,26.3) ; UH2.BB21 89.75,5.96 89.95,6.17 89.95,6.41 UH2.AW19 ; v2(147,58.8) 147.4,59.2 147.4,59.69 UH1.BB1 147.37,59.76 147.37,60.36 UH1.BB2 147.37,60.41 147.37,61.01 UH1.BB3 ; 174.18,78.26 173.85,78.59 173.85,79.47 UH1.G28 ; v2(82.22,11.28) UH2.AJ36 ; UH2.AJ26 87.38,11.83 ; UH2.AJ26 86.97,12.24 ; UH2.AJ26 86.56,11.83 ; UH2.AJ26 86.97,11.43 ; UH2.AH26 87.26,12.32 ; UH2.AH26 87.26,12.89 ; UH2.AH26 86.69,12.32 ; UH2.AH26 86.69,12.89 ; UH1.BB3 147.37,61.06 147.37,61.66 UH1.BB4 147.37,61.71 147.37,62.31 UH1.BB5 147.37,62.36 147.37,62.96 UH1.BB6 ; UH1.BB3 147.3,61.04 v2(146.97,60.71) ; UH1.AF4 UH1.AF3 UH1.AF2 UH1.AF1 v2(159.92,59.19) ; UH2.V20 90.35,16.97 ; UH2.V20 90.35,17.54 ; UH2.V20 89.78,16.97 ; UH2.Y18 91.13,16.2 ; UH2.Y18 90.56,16.2 ; UH2.Y18 90.56,16.77 ; UH1.BE3 UH1.BE4 UH1.BE5 ; UH1.BE3 UH1.BE2 UH1.BE1 144.83,59.22 v2(144.39,58.77) ; UH1.BE3 144.79,61.04 v2(144.38,60.62) ; 90.56,15.99 UH2.AA18 ; UH2.AA18 90.56,15.42 ; UH2.AA18 91.13,15.99 ; UH2.AA18 91.13,15.42 ; 89.01,16.2 UH2.Y21 ; UH2.Y21 89.01,16.77 ; UH2.Y21 89.58,16.77 ; UH2.Y21 89.58,16.2 ; 89.78,14.44 UH2.AE20 ; UH2.AE20 90.35,14.44 ; UH2.AE20 90.35,13.87 ; UH2.AE20 89.78,13.87 ; v2(77.26,10.43) 77.67,10.43 UH2.AM45 ; UH2.C37 UH2.B37 81.6,25.67 UH2.A37 ; UH2.AJ29 85.42,12.24 ; UH2.AJ29 UH2.AL29 UH2.AM29 ; UH2.AJ29 85.01,11.83 ; v2(169.98,58.96) UH1.N1 UH1.N2 UH1.N3 ; UH2.AE28 86.48,13.87 ; UH2.AE28 85.91,13.87 ; UH2.AE28 85.91,14.44 ; v2(167.02,60.73) 167.33,61.04 UH1.T3 ; UT1.P1 UT1.P2 ; UH2.AF25 88.03,13.1 ; UH2.AF25 87.46,13.1 ; UH2.AF25 87.46,13.67 ; UH2.AF25 88.03,13.67 ; 85.79,11.83 UH2.AJ28 ; UH2.AJ28 86.2,12.24 ; UH2.AJ28 86.2,11.43 ; v2(78.71,11.51) 78.79,11.43 UH2.AK42 ; UH2.Y20 90.35,16.77 ; UH2.Y20 89.78,16.77 ; UH2.Y20 90.35,16.2 ; UH2.Y20 89.78,16.2 ; UT1.H2 UT1.H1 ; UH2.AF20 90.35,13.1 ; UH2.AF20 89.78,13.1 ; UH2.AF20 90.35,13.67 ; UH2.AF20 89.78,13.67 ; 90.56,12.89 UH2.AH18 ; UH2.AH18 91.13,12.32 ; UH2.AH18 90.56,12.32 ; UH2.AH18 91.13,12.89 ; UT1.R22 UT1.R23 ; v2(99.49,19.03) 99.49,18.59 UH2.T1 UH2.T2 ; v2(87.33,21.99) UH2.H24 ; v2(169.54,60.71) 169.86,61.04 UH1.N3 ; 85.91,13.67 UH2.AF28 ; UH2.AF28 85.91,13.1 ; UH2.AF28 86.48,13.67 ; UH2.AF28 86.48,13.1 ; UH2.AE18 91.13,13.87 ; UH2.AE18 90.56,13.87 ; UH2.AE18 90.56,14.44 ; UH2.BE32 83.97,3.39 83.36,2.79 v2(83.09,2.79) ; v2(98.27,16.14) UH2.AA4 UH2.AB4 ; UH2.T42 v2(78.78,18.44) ; 90.84,11.43 UH2.AJ18 ; UH2.AJ18 90.44,11.83 ; UH2.AJ18 90.84,12.24 ; UH2.AA25 v2(88.13,15.32) UH2.AC25 ; UH2.AG4 UH2.AE4 ; UH2.AE4 UH2.AD4 ; UH2.AE4 v2(98.31,13.79) ; UH2.AH1 99.54,12.44 99.66,12.44 99.69,12.41 99.89,12.21 100.29,12.21 100.55,12.47 v2(100.55,12.63) ; 89.01,14.44 UH2.AE21 ; UH2.AE21 89.58,14.44 ; UH2.AE21 89.58,13.87 ; UH2.AE21 89.01,13.87 ; UH2.Y17 91.87,16.23 ; UH2.Y17 91.89,16.75 ; UH2.Y17 91.38,16.24 ; UH2.AU45 77.22,8.09 v2(77.14,8.01) ; UH2.AF18 91.13,13.1 ; UH2.AF18 90.56,13.1 ; UH2.AF18 90.56,13.67 ; UH2.AF18 91.13,13.67 ; UH2.E31 83.56,23.82 UH2.E33 v2(82.94,23.34) ; UH2.AR42 78.83,9.16 v2(78.73,9.26) ; 90.56,16.97 UH2.V18 ; UH2.V18 91.13,17.54 ; UH2.V18 90.56,17.54 ; UH2.AH28 86.48,12.89 ; UH2.AH28 85.91,12.89 ; UH2.AH28 85.91,12.32 ; UH2.AH28 86.48,12.32 ; UH2.AF26 87.26,13.1 ; UH2.AF26 86.69,13.67 ; UH2.AF26 86.69,13.1 ; UH2.AF26 87.26,13.67 ; UH2.AD11 94.75,14.61 95.59,14.61 UH2.AD8 ; 89.78,15.22 UH2.AC20 ; UH2.AC20 90.35,15.22 ; UH2.AC20 90.35,14.65 ; UH2.AC20 89.78,14.65 ; 91.62,11.43 UH2.AJ17 ; UH2.AJ17 91.95,11.91 UH2.AJ15 ; UH2.AJ17 v2(91.23,12.22) ; UH2.AJ17 91.21,11.83 ; UH2.AJ17 91.62,12.24 ; UH2.AA29 85.71,15.42 ; UH2.AA29 85.14,15.42 ; UH2.AA29 85.71,15.99 ; UH2.AA29 85.14,15.99 ; 88.03,13.87 UH2.AE25 87.46,13.87 ; UH1.N5 UH1.N4 UH1.N3 ; UH2.AC21 89.58,15.22 ; UH2.AC21 89.58,14.65 ; UH2.AC21 89.01,15.22 ; UH2.AC21 89.01,14.65 ; UH2.AF21 89.58,13.67 ; UH2.AF21 89.58,13.1 ; UH2.AF21 89.01,13.67 ; UH2.AF21 89.01,13.1 ; v2(93.28,2.73) 93.2,2.73 92.8,3.13 92.8,3.49 93.06,3.75 UH2.BE14 ; UH2.Y29 85.71,16.2 ; UH2.Y29 85.14,16.2 ; UH2.Y29 85.14,16.77 ; UH2.AH29 85.71,12.89 ; UH2.AH29 85.14,12.89 ; UH2.AH29 85.14,12.32 ; UH2.AH29 85.71,12.32 ; UH2.AH20 90.35,12.32 ; UH2.AH20 90.35,12.89 ; UH2.AH20 89.78,12.89 ; 89.78,15.99 UH2.AA20 ; UH2.AA20 90.35,15.42 ; UH2.AA20 89.78,15.42 ; UH2.AA20 90.35,15.99 ; UH2.D36 82.3,24.26 UH2.D35 83.41,24.26 UH2.D33 ; UH2.AM17 v2(90.81,10.93) ; v2(90.81,10.93) UH2.AL19 ; v2(90.81,10.93) UH2.AL17 ; v2(90.81,10.93) UH2.AM19 ; UH2.BB34 v2(82.83,5.14) ; 88.24,13.1 UH2.AF23 ; UH2.AF23 88.8,13.67 ; UH2.AF23 88.8,13.1 ; UH2.AF23 88.24,13.67 ; 91.33,15.42 UH2.AA17 91.33,15.99 ; UH1.T3 UH1.T4 UH1.T5 ; UH1.T3 UH1.T2 UH1.T1 167.47,59.22 v2(167.02,58.77) ; UH2.AD33 v2(83.75,13.74) UH2.AD32 ; UH2.AC45 77.42,14.94 v2(77.26,15.1) ; 90.56,14.65 UH2.AC18 ; UH2.AC18 90.56,15.22 ; UH2.AC18 91.13,15.22 ; UT1.N22 UT1.N23 ; 87.26,16.77 UH2.Y26 86.69,16.2 ; UH2.BB16 91.83,5.42 91.83,5.11 v2(91.83,5.11) ; 88.8,16.97 UH2.V23 88.24,16.97 ; UH2.AC29 85.71,14.65 ; UH2.AC29 85.71,15.22 ; UH2.AC29 85.14,15.22 ; UH2.AC29 85.14,14.65 ; UH2.AA21 89.58,15.99 ; UH2.AA21 89.58,15.42 ; UH2.AA21 89.01,15.42 ; UH2.AA21 89.01,15.99 ; v2(77.17,24.22) 77.34,24.39 UH2.D45 ; v2(84.4,26.49) 84.4,26.32 83.98,25.9 UH2.A32 ; 85.91,16.2 UH2.Y28 86.48,16.2 ; 89.01,16.97 UH2.V21 89.58,16.97 ; 89.55,12.85 89.31,12.61 UH2.AH21 89.04,12.86 ; UH2.F44 v2(78.74,22.74) UH2.G42 ; v2(76.85,17.34) 76.98,17.21 UH2.V45 ; UH2.AF29 85.71,13.1 ; UH2.AF29 85.71,13.67 ; UH2.AF29 85.14,13.67 ; UH2.AF29 85.14,13.1 ; UH2.AH17 92,12.24 UH2.AJ15 ; UH2.AH17 91.33,12.89 ; UH2.AH17 91.33,12.32 ; UH2.L4 v2(98.28,20.64) ; v2(77.29,12.9) 77.52,12.66 UH2.AH45 ; UT1.AB2 UT1.AC2 32.22,45.4 32.4,45.4 v2(32.5,45.5) 32.27,45.73 UT1.AC1 UT1.AB1 ; v2(77.55,19.9) 77.55,19.57 77.63,19.48 UH2.P45 ; 85.14,14.44 UH2.AE29 ; UH2.AE29 85.71,13.87 ; UH2.AE29 85.14,13.87 ; UH2.AE29 85.71,14.44 ; 87.46,12.89 UH2.AH25 ; UH2.AH25 88.03,12.89 ; UH2.AH25 87.46,12.32 ; 88.29,12.84 UH2.AH23 88.76,12.85 ; UH2.BB30 v2(85,5.14) ; UH2.BB11 94.07,5.83 v2(94.07,5.98) ; UH2.BB25 87.34,5.74 v2(87.34,6.07) ; UH2.AJ15 UH2.AJ14 ; UH2.N36 v2(81.56,19.43) ; UH2.U28 85.98,17.81 ; v2(99.37,15.38) 99.52,15.22 99.52,15.02 99.42,14.92 UH2.AC1 ; v2(90.55,26.5) 90.8,26.25 UH2.A18 ; v2(98.3,9.25) UH2.AP4 97.84,9.78 UH2.AN4 ; 88.03,16.97 UH2.V25 87.46,16.97 ; UH2.AU1 99.5,7.91 v2(99.85,7.91) ; 85.14,16.97 UH2.V29 ; UH2.V29 85.14,17.54 ; UH2.V29 85.71,17.54 ; UH2.M42 v2(78.73,20.63) ; UT1.K2 UT1.K1 ; UH2.U38 v2(81.56,18.58) ; UT1.AC6 UT1.AB6
  BOTTOM w0.178: UT1.T1 UT1.T2 ; UT1.AC18 UT1.AB18 ; UT1.J22 UT1.J23 ; UT1.E22 UT1.E23 ; UT1.B8 UT1.A8 ; UT1.AA22 UT1.AA23 ; UT1.B10 UT1.A10 ; UT1.AC20 UT1.AB20 ; UH2.AN39 80.79,9.84 81.37,10.42 v2(81.47,10.42) ; v2(21.05,35.29) 21.2,35.29 UT1.A22 UT1.B22 ; UT1.C22 UT1.C23 ; UT1.AC12 UT1.AB12 ; UT1.A12 UT1.B12 ; UT1.B14 UT1.A14 ; UT1.M1 UT1.M2 ; v2(21.05,37) 21.06,36.99 UT1.A20 UT1.B20 ; UT1.L22 UT1.L23 ; UT1.AC8 UT1.AB8 ; UT1.B16 UT1.A16 ; UT1.U22 UT1.U23 ; UT1.B18 UT1.A18 ; UT1.AC16 UT1.AB16 ; UT1.G22 UT1.G23 ; UT1.W23 UT1.W22 ; UT1.AC10 UT1.AB10 ; UT1.AB14 UT1.AC14 ; UT1.A6 UT1.B6 ; UT1.AC22 UT1.AB22
  BOTTOM w0.203: UH2.J10 v2(94.75,21.45) UH2.J11 ; v2(223.18,66.71) 223.1,66.63 222.31,66.63 221.9,67.05 UV1.G5 ; UH2.N15 v2(93.12,20.32) ; v2(93.12,20.32) UH2.L15 ; v2(93.12,20.32) UH2.L13 ; UH1.E38 175.08,86.26 v2(175.08,85.38) 174.76,85.06 UH1.F36 174.55,85.06 UH1.H35 173.77,84.41 UH1.J36 ; UH2.N10 v2(94.75,20.61) UH2.L12 ; UH1.BT3 137.35,60.93 136.94,60.93 v2(136.85,60.84) ; UH1.AC37 v2(162.49,85.38) ; UH2.AD11 v2(94.77,13.76) ; UH1.AH34 158.22,83.76 v2(158.55,83.43) 158.23,83.11 UH1.AH33 ; UH1.BH7 142.96,64.1 v2(142.96,64.7) ; UH1.BH7 142.32,63.46 UH1.BH6 ; UH1.BH7 UH1.BH8 UH1.BH9 ; v2(91.83,24.7) 91.84,24.69 UH2.D16 92.51,24.26 UH2.D15 ; UH2.P19 v2(90.75,19.7) UH2.N19 ; UH1.BH6 142.28,62.99 v2(141.9,62.61) ; UH1.BH6 UH1.BG6 UH1.BF6 UH1.BE6 ; UH1.W3 164.81,61.04 v2(164.51,60.74) ; UH1.W3 UH1.W2 UH1.W1 164.95,59.25 v2(164.51,58.81) ; UH1.W3 UH1.W4 UH1.W5 165.6,62.99 UH1.V6 UH1.U6 167.19,63.55 UH1.T7 UH1.T8 UH1.T9 ; UH1.BG13 UH1.BG14 143.28,68.2 v2(142.96,67.88) 142.64,68.2 UH1.BH14 ; UH1.BG13 143.57,67.55 v2(143.92,67.2) ; UH1.BG13 UH1.BG12 ; UH1.T33 v2(168,83.43) 167.67,83.76 UH1.T34 ; UH2.AL13 v2(93.07,11.18) UH2.AM15 ; UH2.AL13 v2(93.96,11.18) UH2.AL11 ; UH2.AL13 v2(93.09,10.43) ; UH2.AL13 v2(93.94,10.44) ; UH2.H27 v2(86.29,21.99) UH2.K27 ; UH1.BC13 UH1.BC12 146.06,66.9 v2(145.69,67.27) 145.97,67.55 UH1.BC13 ; UH1.BC13 UH1.BC14 146.03,68.2 v2(145.7,68.52) ; UH1.E35 175.53,84.36 175.53,83.79 UH1.E34 175.48,83.6 UH1.D33 176.45,82.64 v2(176.45,82.56) 176.45,82.5 UH1.C31 176.44,81.83 v2(176.44,81.77) 176.44,81.69 UH1.D30 ; UH1.A3 177.51,60.99 UH1.B3 176.88,61.12 v2(176.82,61.07) ; UH1.A3 UH1.A4 ; UH1.A3 178.08,60.47 v2(178,60.39) ; UH1.D6 176.78,63.92 UH1.C8 176.78,64.12 v2(177.11,64.45) ; UH1.N9 170.12,64.95 v2(170.39,65.22) 170.39,64.75 UH1.N8 ; UH1.N9 UH1.N8 ; UH1.N9 UH1.N10 UH1.N11 ; UH1.BN12 139.72,67.29 139.72,67.36 v2(139.72,67.36) 139.72,67.43 UH1.BM13 ; UH1.BN12 139.4,66.93 v2(139.73,66.61) ; UH1.BN12 139.36,66.93 138.8,66.93 UH1.BP12 UH1.BR12 UH1.BT12 136.88,66.97 v2(136.67,67.18) ; UH1.F29 174.83,80.52 v2(175.16,80.2) ; UH1.P37 v2(169.57,86.04) UH1.P38 ; UH1.K11 172.92,65.93 v2(173.04,65.93) ; UH1.H25 UH1.J25 172.71,77.44 v2(172.26,77.89) ; v2(155.77,68.51) 155.9,68.51 UH1.AL14 ; UH1.E9 175.48,64.77 v2(175.16,64.45) ; UH1.AW3 UH1.AW4 UH1.AW5 150.26,62.73 150.45,62.73 UH1.AU6 150.7,63.62 UH1.AU7 ; UH1.AW3 UH1.AW2 UH1.AW1 149.75,59.74 v2(149.42,60.06) ; UH1.AW3 149.75,61.04 v2(149.42,60.71) ; UH1.BA38 147.92,86.29 147.98,86.22 147.98,85.85 147.92,85.78 UH1.BA37 147.98,85.71 v2(148.31,85.38) ; UH2.AG38 v2(81.46,12.7) ; UH2.R22 UH2.P22 v2(89.71,19.7) UH2.N22 ; UH1.AL12 156.01,67.1 v2(155.77,67.1) 155.56,66.9 UH1.AM12 155.04,67.16 154.65,67.16 UH1.AN12 ; v2(162.17,65.97) 162.08,65.97 UH1.AD10 ; v2(94.69,11.17) UH2.AJ10 ; v2(94.69,11.17) UH2.AL11 ; v2(94.69,11.17) UH2.AL10 ; 176.18,64.89 176.73,64.89 UH1.C9 176.78,64.77 v2(177.11,64.45) ; 176.18,64.89 176.25,64.96 176.25,65.51 UH1.D10 ; 176.18,64.89 UH1.D9 ; UH1.Y10 UH1.Y11 164.64,66.25 v2(164.91,65.97) 164.82,65.97 UH1.Y10 ; UH1.Y10 UH1.Y9 UH1.Y8 UH1.Y7 164.27,63.65 163.61,62.99 UH1.AB6 UH1.AC6 ; v2(178.68,81.78) 178.48,81.58 UH1.A30 ; UH1.AM38 155.07,86.36 v2(155.4,86.04) 155.08,85.71 UH1.AM37 ; v2(151.19,65.34) v2(151.19,64.7) 150.98,64.7 UH1.AU9 ; v2(151.19,65.34) 151.19,65.34 v2(151.19,65.97) 150.92,66.25 UH1.AU11 ; v2(151.19,65.34) 150.99,65.34 UH1.AU10 ; UH1.T9 UH1.T10 ; UH1.T9 167.27,64.95 v2(167.66,65.34) 167.45,65.34 UH1.T10 ; UH1.T10 UH1.T11 ; UH1.T10 167.57,65.97 v2(167.65,65.97) 167.38,66.25 UH1.T11 ; UH1.BD11 145.61,66.61 v2(145.7,66.61) 145.42,66.9 UH1.BD12 145.11,66.9 v2(144.79,67.22) 144.66,67.22 UH1.BF12 144.03,67.2 v2(143.92,67.2) ; UH1.BD11 145.43,66.25 v2(145.71,65.97) 145.62,65.97 UH1.BD10 ; UH1.BD11 UH1.BD10 ; UH1.C37 177.38,85.64 UH1.B37 177.94,85.64 UH1.A37 178.81,86.52 v2(178.81,86.75) ; UH1.BH12 142.37,66.9 v2(142.05,66.57) 141.68,66.94 UH1.BJ12 ; UH1.BH12 142.67,66.9 v2(142.96,66.61) 143.25,66.9 UH1.BG12 ; UH1.BH12 UH1.BH11 ; UH1.BP33 138.75,82.59 UH1.BN31 139.72,81.62 v2(139.72,81.57) 139.72,81.46 UH1.BN30 ; UH1.BN4 139.87,62.26 UH1.BM5 ; 91.21,18.03 UH2.U17 91.62,17.62 ; UH1.BH10 142.7,65.6 v2(142.96,65.34) 142.57,64.95 UH1.BH9 ; UH1.BH10 142.88,65.97 v2(142.96,65.97) 142.69,66.25 UH1.BH11 ; UH1.BH10 UH1.BH11 ; UH1.BH10 UH1.BH9 ; UH2.U15 v2(92.14,18.75) UH2.P17 ; UH1.BA12 147.66,67.22 v2(147.53,67.22) 147.4,67.22 UH1.BB12 146.81,67.17 v2(146.62,67.17) ; UH1.BA12 148.33,67.24 v2(148.45,67.24) 148.56,67.24 UH1.AY12 149.27,67.26 v2(149.37,67.26) 149.45,67.26 UH1.AW12 150.15,67.23 v2(150.3,67.23) 150.4,67.23 UH1.AU12 ; UH1.BA12 148.28,66.61 v2(148.45,66.61) 148.08,66.25 UH1.BA11 ; UH1.BA12 UH1.BA11 ; UH1.L29 UH1.L30 171.54,81.15 v2(171.17,81.51) ; UH1.AC38 v2(162.49,86.69) ; v2(93.09,10.43) UH2.AM15 ; v2(93.09,10.43) v2(93.66,9.52) ; UH1.AP12 153.14,67.23 v2(153.02,67.23) 152.88,67.23 UH1.AR13 ; UH1.AP12 153.65,66.9 v2(153.93,66.61) ; UH1.AP12 153.83,67.26 v2(153.95,67.26) 154.03,67.26 UH1.AN12 ; UH1.AD10 UH1.AD9 ; UH1.AD10 UH1.AD11 162.07,66.61 v2(162.16,66.61) ; UH1.AD9 UH1.AD8 UH1.AD7 161.73,63.65 v2(162.06,63.32) ; UH1.AD9 161.49,64.95 v2(161.23,64.68) ; UH1.Y38 v2(164.85,86.04) UH1.Y37 ; 145.65,64.7 v2(145.7,64.7) ; 145.65,64.7 145.49,64.7 UH1.BD9 ; 145.65,64.7 UH1.BD8 ; UH1.AV38 150.35,86.36 v2(150.67,86.04) 150.35,85.71 UH1.AV37 ; v2(97.04,8.09) 96.52,8.83 UH2.AR7 ; v2(97.04,8.09) 96.63,7.94 UH2.AU7 ; v2(97.04,8.09) 97.41,8.69 UH2.AR5 ; UH1.BM5 139.85,62.36 UH1.BM6 139.93,62.99 UH1.BL6 UH1.BK6 141.53,62.99 v2(141.9,62.61) ; UH1.BM5 140.19,62.02 v2(140.19,61.81) 139.95,61.58 UH1.BM3 139.95,60.77 UH1.BM2 139.72,60.39 UH1.BN2 ; v2(84.62,17.29) UH2.U31 ; v2(84.62,17.29) UH2.W31 ; v2(84.62,17.29) UH2.U32 ; v2(162.44,59.19) UH1.AC1 UH1.AC2 UH1.AC3 UH1.AC4 ; v2(93.66,9.52) UH2.AN11 ; v2(93.66,9.52) v2(93.94,10.44) ; v2(93.66,9.52) UH2.AP11 ; UH2.AN11 v2(93.94,10.44) ; UH2.AN11 UH2.AN10 ; UH2.AN11 UH2.AP11 ; v2(81.79,22.46) UH2.H35 ; v2(81.79,22.46) v2(81.15,22.23) ; v2(81.79,22.46) UH2.K36 ; 169.55,83.43 169.94,83.11 UH1.N33 ; 169.55,83.43 169.94,83.76 UH1.N34 ; 169.55,83.43 v2(169.53,83.43) ; UH1.AR5 UH1.AR4 UH1.AR3 UH1.AR2 UH1.AR1 152.38,58.29 v2(152.39,58.27) ; UH1.BM18 140.05,71.63 v2(139.73,71.3) 139.4,71.63 UH1.BN18 UH1.BP18 UH1.BR18 UH1.BT18 136.73,71.7 v2(136.69,71.66) ; UH1.AL9 156.28,64.95 v2(156.68,65.34) ; UH2.AL11 v2(93.94,10.44) ; UH2.AL11 UH2.AN10 ; v2(142.28,58.97) 142.07,59.18 UH1.BH1 142.07,60.13 UH1.BH2 UH1.BH3 UH1.BH4 UH1.BH5 142.18,62.34 v2(141.9,62.61) ; v2(154.89,59.19) UH1.AM1 UH1.AM2 UH1.AM3 154.93,61.07 154.93,61.65 UH1.AM4 154.83,61.69 v2(154.5,62.01) ; UH1.Y14 164.55,68.2 v2(164.88,67.87) 164.55,67.55 UH1.Y13 ; v2(176.82,61.07) 176.82,60.54 UH1.C2 ; v2(176.82,61.07) 176.36,61.07 UH1.D3 ; UH2.U8 v2(95.58,18.61) ; UH2.AL24 v2(87.29,10.96) UH2.AM24 ; 139.73,65.79 139.73,65.72 UH1.BN9 ; 139.73,65.79 140.05,65.47 UH1.BM9 139.96,65.3 139.96,64.71 UH1.BM8 139.98,64.54 139.98,63.9 UH1.BM7 UH1.BN7 ; 139.73,65.79 140.05,66.12 UH1.BM11 139.73,66.51 v2(139.73,66.61) ; v2(177.11,70.75) 176.78,71.07 UH1.C17 176.78,71.28 UH1.D18 ; 141.04,68.1 141.35,68.41 UH1.BK14 141.35,68.55 v2(140.96,68.94) UH1.BK15 UH1.BJ15 ; 141.04,68.1 141.35,67.79 UH1.BK13 141.35,67.34 v2(141.18,67.17) ; 141.04,68.1 UH1.BL13 140.7,67.69 v2(140.38,67.37) 140.38,67.3 UH1.BM12 140.05,66.93 v2(139.73,66.61) ; UH1.AR37 152.71,85.71 v2(153.04,85.38) ; v2(153.93,66.61) 153.94,66.61 v2(153.94,65.97) ; v2(153.93,66.61) 154.22,66.9 UH1.AN12 ; v2(153.93,66.61) 153.84,66.61 UH1.AP11 153.75,65.97 v2(153.94,65.97) ; UH2.K10 v2(95.89,21.66) UH2.L8 ; UH1.BD10 UH1.BD9 ; UH1.BD10 145.51,65.34 v2(145.7,65.34) 145.31,64.95 UH1.BD9 ; UH1.C29 177.1,80.27 v2(177.1,80.22) ; v2(175.16,70.75) 175.16,70.82 UH1.F17 174.83,71.21 v2(174.51,71.54) 174.51,71.6 UH1.G18 174.16,71.9 173.5,71.9 UH1.H18 UH1.J18 v2(172.31,71.93) ; UH1.G20 174.51,73.18 v2(174.51,73.11) 174.83,72.79 UH1.F19 174.83,72.64 v2(174.51,72.32) ; UH1.A28 178.84,79.8 v2(178.93,79.89) ; UH1.K3 UH1.K4 ; UH1.K3 172.44,61.04 v2(172.05,60.65) ; UH1.K3 UH1.K2 UH1.K1 ; UH1.K4 UH1.K5 172.14,62.69 v2(172.05,62.69) ; UH1.K4 UH1.J4 173.66,62.01 173.74,62.01 ; v2(136.93,61.69) 136.99,61.75 UH1.BT4 ; UH1.BJ32 141.55,82.46 v2(141.23,82.78) ; UH2.BE40 80.53,3.65 v2(80.53,3.56) ; v2(151.46,84.08) 151.14,83.76 UH1.AU34 ; UH1.AG11 159.28,66.57 v2(159.38,66.57) 159.71,66.9 UH1.AF12 UH1.AF13 UH1.AF14 160.19,68.51 v2(160.33,68.51) ; UH1.T12 167.36,66.9 v2(167.65,66.61) 167.93,66.9 UH1.R12 168.37,67.16 168.76,67.16 UH1.P12 169.24,67.12 169.72,67.12 UH1.N12 ; UH1.T12 167.02,67.06 166.44,67.06 UH1.V12 166.11,67.06 165.53,67.06 UH1.W12 ; UH1.T12 UH1.T13 167.05,67.55 v2(166.75,67.85) 167.09,68.2 UH1.T14 ; UH1.T12 UH1.T11 ; UH2.AB31 v2(84.39,14.8) UH2.AB32 ; UH2.BE18 90.79,3.79 v2(90.95,3.63) ; UH2.T4 UH2.U4 97.92,17.62 UH2.V3 97.94,16.99 UH2.W4 97.85,16.6 UH2.AA4 ; UH2.T4 v2(98.25,18.6) ; UH2.T4 UH2.R5 ; UH2.AL33 83.81,10.45 ; 83.81,10.45 84.18,10.82 UH2.AL32 ; 83.81,10.45 84.35,9.91 UH2.AN31 ; v2(145.23,62.66) 145.56,62.99 UH1.BD6 UH1.BC6 146.84,62.66 v2(146.97,62.66) 147.02,62.66 UH1.BB6 ; v2(145.23,62.66) 145.16,62.66 UH1.BE5 144.79,62.38 144.79,62.95 UH1.BE6 ; v2(145.23,62.66) 144.9,62.99 UH1.BE6 ; UH1.F13 174.83,67.85 UH1.G12 174.18,67.14 v2(173.86,66.81) ; v2(162.16,66.61) 162.45,66.9 162.62,66.9 UH1.AC12 162.88,67.16 163.27,67.16 UH1.AA12 ; v2(162.16,66.61) 161.87,66.9 UH1.AD12 ; UH2.BE9 95.36,4.09 95.35,4.08 95.35,3.8 95.36,3.79 95.36,3.54 v2(95.44,3.46) ; v2(148.45,65.97) 148.26,65.97 UH1.BA11 ; v2(88.79,3.49) 88.79,3.84 UH2.BE23 ; UH2.J3 UH2.K4 v2(97.09,21.54) ; UH1.AU33 151.13,83.11 v2(151.46,82.78) ; UH1.K7 172.79,63.65 v2(173.03,63.89) ; UH2.U11 v2(94.83,18.63) UH2.U10 ; v2(153.93,65.34) v2(153.93,64.7) ; v2(153.93,65.34) 153.93,65.97 v2(153.94,65.97) ; v2(153.93,65.34) 153.73,65.34 UH1.AP10 ; v2(153.93,64.7) 153.53,64.3 UH1.AP8 153.91,63.86 153.91,63.13 UH1.AN6 154,62.94 UH1.AN5 154.33,62.01 v2(154.5,62.01) ; v2(153.93,64.7) 153.72,64.7 UH1.AP9 ; UH1.N6 169.93,63.03 UH1.N7 UH1.N8 ; UH1.N6 UH1.M6 ; UH1.N6 UH1.N5 ; UH1.N6 UH1.P6 ; UH1.BC33 146.41,83.11 v2(146.74,82.78) ; UH1.BJ29 142.11,80.23 v2(142.43,79.91) ; v2(94.16,7.34) 93.76,6.94 UH2.AW13 ; v2(162.06,63.32) 162.39,62.99 UH1.AC6 ; v2(162.06,63.32) 161.73,62.99 UH1.AD6 161.26,62.65 v2(161.18,62.65) 161.09,62.65 UH1.AE6 ; v2(96.9,20.56) UH2.N5 UH2.N4 ; UH1.G9 174.51,65.17 v2(174.51,65.24) ; UH1.BT5 136.51,62.55 v2(136.46,62.51) ; UH1.AR13 152.89,67.87 v2(153.02,67.87) 152.69,68.2 UH1.AR14 152.43,68.2 v2(152.1,67.87) ; UH1.AR13 152.45,67.55 v2(152.12,67.22) ; UH1.AG8 UH1.AG7 158.96,63.11 UH1.AG6 ; v2(173.03,63.89) 172.63,64.3 UH1.K8 172.66,64.35 172.66,64.89 UH1.K9 172.5,64.95 v2(172.2,65.25) 172.55,65.6 UH1.K10 172.71,65.6 v2(173.04,65.93) ; v2(173.03,63.89) 173.3,63.63 UH1.J7 173.76,63.63 UH1.G8 UH1.F8 174.83,64.12 v2(175.16,64.45) ; v2(178.56,78.29) 178.5,78.23 UH1.A26 ; UH1.A14 v2(178.64,68.78) ; UH1.A24 v2(178.72,76.65) ; UH2.AG31 v2(84.56,12.63) UH2.AJ31 ; UH1.J10 173.35,65.63 v2(173.04,65.93) ; UH2.H22 v2(89.71,21.99) UH2.H19 v2(90.75,21.99) UH2.H17 v2(92.07,21.9) ; v2(174.51,76.26) 174.51,76.19 UH1.G23 ; v2(174.51,76.26) 174.83,75.94 UH1.F23 175.16,75.54 v2(175.16,75.47) ; v2(174.51,76.26) 174.51,76.33 UH1.G24 ; UH1.N12 170.08,66.9 v2(170.39,66.58) ; UH1.N12 UH1.N11 ; UH1.D16 176.78,69.7 UH1.C15 176.78,69.5 v2(177.11,69.17) ; v2(175.16,64.45) 174.83,64.77 UH1.F9 174.83,64.91 v2(174.51,65.24) ; UH2.K33 83.43,21.15 v2(83,20.71) UH2.M35 ; UH1.BR36 137.99,85.05 UH1.BT36 v2(136.86,85.05) ; UH1.BT14 UH1.BR14 138.1,68.62 v2(138.43,68.94) 138.75,68.62 UH1.BP14 UH1.BN14 ; UH1.BG12 143.62,66.9 v2(143.92,67.2) ; UH2.AN27 v2(86.29,10.16) ; UH2.AP11 v2(95.37,9.39) ; UH2.AP11 UH2.AT10 UH2.AT9 UH2.AR9 v2(95.37,9.39) ; v2(95.37,9.39) UH2.AN10 ; v2(95.37,9.39) UH2.AN8 UH2.AN7 ; UH2.AU36 81.47,7.66 81.47,7.59 v2(81.1,7.22) 81.1,7.29 ; v2(154.5,62.01) 154.83,62.34 UH1.AM5 ; v2(153.04,86.69) 152.72,86.36 UH1.AR38 ; UH2.W14 v2(93.29,16.12) UH2.AB14 UH2.AB15 ; UH1.BD9 UH1.BD8 ; UH2.D35 v2(82.84,24.73) ; v2(136.68,78) UH1.BT26 UH1.BR26 UH1.BP26 ; UH2.U18 90.84,18.44 ; UH2.U18 90.84,17.62 ; UH2.U18 90.44,18.03 ; v2(135.2,63.01) 135.45,63.01 135.89,63.45 136.23,63.45 136.69,63.91 137.88,63.91 137.97,63.82 UH1.BR7 UH1.BP7 UH1.BN7 ; 85.42,17.62 UH2.U29 ; UH2.U29 85.01,18.03 ; UH2.U29 85.42,18.44 ; UH1.AU7 151.39,62.99 UH1.AT6 ; UH1.AU7 UH1.AU8 UH1.AU9 ; UH1.BR29 UH1.BP29 UH1.BN29 UH1.BM29 ; UH2.AB8 v2(96.34,16.12) UH2.AB7 ; UH2.AW9 95.68,6.96 v2(96.14,6.96) 96.47,7.29 UH2.AV6 ; UH1.AH12 158.19,66.9 v2(158.5,67.21) ; UH1.F2 174.88,60.39 174.74,60.52 174.71,60.52 v2(174.53,60.71) 174.85,61.04 UH1.F3 174.92,61.27 174.82,61.38 UH1.F4 ; UH1.F4 UH1.E4 ; UH1.F4 UH1.G4 174.06,61.69 173.74,62.01 ; UH1.BT32 136.97,82.66 v2(136.87,82.76) ; UH2.H29 v2(85.05,22.03) ; UH1.G5 174.67,62.34 UH1.F5 ; UH1.G5 174.18,62.38 174.18,62.94 UH1.G6 ; UH1.G5 174.07,62.34 173.74,62.01 ; v2(170.39,66.58) 170.71,66.9 UH1.M12 UH1.M13 UH1.M14 ; v2(170.39,66.58) 170.06,66.25 UH1.N11 ; v2(173.86,66.81) 173.86,66.74 UH1.H11 ; v2(173.86,66.81) 173.53,67.14 UH1.H12 ; v2(176.45,72.32) 176.78,72.65 UH1.C19 176.78,72.85 UH1.D20 ; UH1.AU9 UH1.AU10 ; UH1.AU10 UH1.AU11 ; UH2.AG33 v2(83.75,12.66) UH2.AG32 ; UH1.F25 175.16,77.11 v2(175.16,77.05) ; UH2.AB10 v2(95.59,16.12) UH2.W8 ; UH1.AC6 UH1.AC5 UH1.AC4 ; UH1.F11 174.83,66.35 v2(175.16,66.02) ; UH1.BM29 139.93,80.24 139.93,79.7 UH1.BM28 140.05,79.5 v2(140.38,79.18) 140.05,78.85 UH1.BM27 ; UH1.BM29 140.08,80.39 140.68,80.39 UH1.BL29 141.14,80.36 UH1.BK29 141.75,80.97 UH1.BJ30 141.62,81.09 v2(141.23,81.48) 141.55,81.81 UH1.BJ31 ; UH1.BT24 UH1.BR24 138.13,76.45 138.73,76.45 UH1.BP24 138.81,76.48 139.35,76.48 UH1.BN24 139.4,76.35 v2(139.73,76.03) 140.05,75.7 UH1.BM23 ; v2(142.6,71.54) 142.44,71.7 UH1.BJ18 UH1.BK18 ; UH1.G14 174.83,69.43 UH1.F15 174.83,69.64 v2(174.51,69.96) 174.51,70.03 UH1.G16 ; UH1.BA11 UH1.BA10 UH1.BA9 UH1.BA8 UH1.BA7 147.99,63.63 UH1.BB6 ; UH1.D28 176.78,79.15 UH1.C27 177.11,78.69 v2(177.11,78.66) ; UH2.BE28 v2(86.24,3.42) ; UH2.R10 v2(94.77,19.43) ; UH1.BE6 145.25,63.4 UH1.BD7 UH1.BD8 ; UH1.W33 v2(165.63,82.78) ; UH2.AM15 v2(92.3,11.18) ; v2(84.86,24.66) UH2.D30 ; UH1.AG6 UH1.AH6 UH1.AJ6 UH1.AJ5 UH1.AJ4 UH1.AJ3 ; UH1.AG6 159.34,63.24 v2(159.5,63.24) ; UH1.G26 174.18,78.26 v2(174.52,78.6) 174.52,78.7 UH1.F27 ; UH1.L33 171.61,83.11 v2(171.93,83.43) 171.61,83.76 UH1.L34 ; UH1.AC4 162.32,61.69 v2(161.99,61.36) ; UH1.AL10 156.31,65.6 v2(156.68,65.97) 156.68,65.34 v2(156.68,65.34) ; UH1.AL34 155.73,83.76 v2(155.4,83.43) 155.72,83.11 UH1.AL33 ; UH2.AD14 v2(93.29,13.77) ; UH1.AU12 UH1.AU11 ; UH1.AU12 151.09,67.26 v2(151.18,67.26) ; v2(159.42,65.97) 159.34,65.97 UH1.AG10 ; UH1.D22 176.78,74.43 UH1.C21 176.78,74.22 v2(177.11,73.9) ; UH1.BN21 139.4,74.13 v2(139.73,74.45) 140.05,74.13 UH1.BM21 140.05,73.97 v2(140.36,73.67) ; UH1.BN21 139.34,74 138.82,74 UH1.BP21 ; UH1.BN21 UH1.BN20 139.24,73.11 139.24,72.65 UH1.BN19 ; UH2.AB38 v2(80.9,16.14) ; UH2.W38 v2(81.46,17.16) ; UH2.AG13 v2(94.05,12.64) UH2.AG11 ; v2(173.51,82.78) 173.2,82.46 UH1.J32 ; v2(173.51,82.78) 173.18,83.11 UH1.J33 ; v2(173.51,82.78) 173.59,82.78 UH1.H32 174.15,82.22 174.78,82.22 UH1.F31 ; UH2.R14 v2(93.16,18.47) UH2.U14 ; v2(175.95,61.99) 176.29,61.99 UH1.C5 177.14,62.84 177.64,62.84 UH1.A6 ; UH1.AP33 153.5,83.11 v2(153.82,83.43) 153.49,83.76 UH1.AP34 ; v2(97.05,22.56) UH2.J5 UH2.H3 ; UH1.AY34 148.77,83.76 v2(149.1,83.43) 148.78,83.11 UH1.AY33 ; UH1.BN7 139.4,63.36 v2(139.47,63.29) ; PU600.3 v2(288.27,32.01) ; v2(156.68,65.34) v2(156.68,64.7) 156.27,64.3 UH1.AL8 UH1.AL7 ; UH1.AJ3 UH1.AJ2 UH1.AJ1 v2(157.41,59.19) ; UH1.AJ3 157.08,60.71 v2(156.96,60.71) 156.96,61.24 UH1.AK4 UH1.AL4 ; UH1.BG38 v2(143.59,86.69) ; v2(136.51,65.41) 137.44,65.41 UH1.BT9 ; UH2.AT15 UH2.AV17 v2(90.81,7.05) UH2.AW19 ; UH1.AE34 UH1.AE33 v2(160.91,82.78) ; UH1.C25 176.78,77.58 UH1.D26 176.13,78.26 v2(176.47,78.6) ; UH1.BD38 145.62,86.36 v2(145.95,86.04) 145.63,85.71 UH1.BD37 ; UH2.AW29 85.22,6.86 v2(84.87,7.21) ; UH1.BB6 UH1.BA6 ; UH1.BG37 143.26,85.71 v2(143.59,85.38) ; UH1.BK25 UH1.BJ25 v2(142.58,77.21) ; UH1.G10 174.51,65.3 v2(174.51,65.24) ; UH1.BR34 UH1.BP34 138.75,83.44 v2(139.08,83.12) 139.4,83.44 UH1.BN34 ; v2(83.75,17.16) UH2.W32 ; v2(83.75,17.16) UH2.W33 ; v2(83.75,17.16) UH2.U33 ; UH1.A12 v2(178.72,67.2) ; 85.79,18.03 UH2.U28 86.2,18.44 ; UH2.AB11 v2(94.83,16.14) ; v2(177.11,67.6) 176.78,67.92 UH1.C13 176.78,68.13 UH1.D14 ; v2(178.77,73.61) 178.66,73.5 UH1.A20 ; UH1.BL38 140.91,86.4 v2(140.56,86.74) 140.19,86.37 UH1.BM38 ; UH1.J22 UH1.H22 173.53,75.03 174.13,75.03 UH1.G22 174.51,74.75 v2(174.51,74.69) 174.83,74.36 UH1.F21 175.16,73.96 v2(175.16,73.9) ; v2(156.97,85.39) 157.3,85.71 UH1.AJ37 UH1.AJ38 ; UH1.A16 v2(178.72,70.35) ; UH2.N24 v2(88.27,19.63) ; UH1.A9 UH1.B9 177.43,64.77 v2(177.11,64.45) ; v2(178.65,65.59) 178.61,65.63 UH1.A10 ; v2(137.9,87.02) 137.9,86.51 UH1.BR38 ; UH1.BM25 140.38,77.54 v2(140.38,77.6) 140.38,77.67 UH1.BM26 ; UH2.AL4 97.84,10.95 UH2.AK4 v2(98.32,11.49) ; UH2.J7 v2(96.1,22.53) UH2.G9 ; UH1.BF34 144.05,83.76 v2(144.38,83.43) 144.05,83.11 UH1.BF33 ; UH1.AB33 v2(163.27,83.43) UH1.AB34 ; UH2.AB5 v2(97.1,16.12) ; UH1.K38 172.3,86.36 v2(171.88,86.79) ; v2(204.7,85.92) 204.74,85.96 206.45,85.96 206.84,86.35 UV1.AE28 ; UH2.AD36 v2(82.22,13.74) ; v2(177.11,75.47) 176.78,75.8 UH1.C23 176.78,76 UH1.D24 ; UH2.F8 v2(96.69,23.25) ; UH1.U37 v2(167.21,86.04) UH1.U38 ; UH2.AV31 v2(84.02,7.97) UH2.AV33 ; v2(78.74,13.79) 78.82,13.71 UH2.AE42 ; UH2.AY45 77.13,6.47 76.74,6.09 v2(76.74,5.82) ; PU600.1 287.47,31.53 287.05,31.95 v2(286.96,31.95) ; UH2.BE37 v2(81.67,3.56) ; UH1.A18 v2(178.72,71.93) ; UH2.AM22 v2(89.71,10.92) ; v2(142.56,74.9) 142.51,74.85 UH1.BJ22 UH1.BK22 ; UH1.BM35 140.4,84.64 v2(140.4,84.65) 140.64,84.41 UH1.BL35 ; UH2.R33 v2(83.87,19.5) ; UH1.BC34 146.42,83.76 v2(146.74,84.08) ; UH1.A22 v2(178.72,75.08) ; UH1.W34 165.3,83.76 v2(165.65,83.42) ; v2(177.11,66.02) 176.78,66.35 UH1.C11 176.78,66.55 UH1.D12 ; UH2.AA42 79.37,16.15 v2(79.72,16.15) ; UH1.BR21 UH1.BT21 v2(136.59,74.06)
  BOTTOM w0.229: UT4.L11 6.28,35.42 5.91,35.05 v2(5.91,34.97) ; UT4.A1 11.66,40.78 11.68,40.78 v2(11.69,40.78)
  BOTTOM w0.254: UV5.H2 218.73,101.31 218.73,100.6 UV5.H1 218.69,100.48 219.05,100.12 v2(219.05,99.93) ; UV1.G3 221.87,65.45 v2(222.28,65.05) 221.88,64.65 UV1.G2 ; UV5.D10 221.89,107.6 v2(221.55,107.26) ; v2(211.05,109.1) 211.1,109.1 211.22,109.22 211.26,109.22 211.41,109.36 UV5.U12 ; UV6.A14 v2(206.66,111.36) ; v2(245.51,77.63) UV9.R14 ; v2(239.26,88.1) 239.25,88.09 238.74,88.09 UV10.F5 ; PU1202.10 155.2,115.63 v2(154.94,115.9) ; UV6.U12 193.41,109.36 v2(193.04,108.98) ; UV1.N2 216.51,64.31 v2(216.51,63.19) ; UV10.F10 242.71,88.07 v2(242.29,87.65) ; UV5.G10 v2(219.9,108.17) ; UV1.N7 216.41,69.19 v2(216.41,70.04) ; UV10.C11 v2(243.91,86.07) UV10.C12 ; v2(199.62,64.14) 199.4,64.36 UV1.AP2 ; v2(239.19,71.21) 238.82,70.83 UV9.G5 ; v2(69.53,31.72) 69.55,31.74 JEDP1.5 ; v2(234.96,89.44) 235.19,89.67 UV10.H1 235.57,89.6 236.25,89.6 UV10.H2 ; UV1.AG11 205.33,72.15 v2(205.65,71.83) ; UV6.E3 203.07,102.16 203.07,102.15 203.07,102.18 202.68,101.79 v2(202.68,101.76) ; UV10.A1 235.47,84.03 v2(235.01,84.03) ; UV1.A33 v2(226.39,90.86) UV1.B34 ; v2(234.57,9.41) 234.36,9.62 JHDD.7 ; v2(238.3,70.43) 238.31,70.43 UV9.F5 ; v2(224.66,108.97) 224.29,109.35 UV5.A12 ; UV1.B31 226,88.81 v2(225.64,89.17) ; JAPS.8 175.12,6.66 v2(175.07,6.61) 174.37,6.61 174.12,6.86 JAPS.10 ; JEDP1.17 63.55,31.75 63.55,31.75 v2(63.55,31.7) ; JEDP1.30 v2(57.05,31.71) ; v2(172.2,6.55) 172.12,6.63 JAPS.14 ; v2(225.6,66.71) 226,66.31 UV1.B4 ; v2(193.85,100.17) 193.84,100.17 UV6.U1 ; UV1.K2 219.35,64.57 v2(218.99,64.21) ; v2(224.85,79.23) 225.2,78.89 UV1.C19 ; UV5.F5 220.29,104.16 v2(220.46,104.33) ; UV5.R3 213.09,102.19 v2(212.7,102.57) UV5.R4 ; v2(216.45,66.68) 216.81,67.05 UV1.N5 ; v2(197.05,107.36) UV6.M10 ; v2(202.63,104.15) 202.26,103.78 UV6.F5 ; v2(242.31,68.81) 242.69,68.43 UV9.D10 ; UV1.AH30 204.35,88.03 v2(204.76,87.61) UV1.AH29 ; v2(213.97,69.1) 214.32,68.75 UV1.T7 ; UV5.B10 223.48,107.76 223.1,107.38 v2(223.1,107.39) ; v2(206.41,68.33) 206.83,68.75 UV1.AE7 ; UV10.N14 246.31,93.27 v2(246.32,93.27) ; UV6.C14 v2(205.06,111.36) ; UZ9.5 v2(185.98,86.91) ; v2(193.06,110.56) 193.46,110.96 UV6.U14 ; UV9.C1 235.51,67.63 v2(234.94,67.63) ; JDIMM2.61 198.67,27.15 197.64,28.19 v2(197.47,28.19) ; UV1.M18 UV1.M17 218.6,76.97 v2(219.05,76.53) ; DT27.2 v2(8.48,61.86) ; UV1.AE2 206.85,64 v2(206.95,63.9) ; v2(235.92,76.01) 235.53,75.63 UV9.N1 ; UV5.C3 222.68,102.16 v2(222.28,102.56) 222.68,102.96 UV5.C4 ; v2(81.1,7.22) 80.96,7.57 UH2.AU39 ; v2(81.1,7.22) UH2.AY38 ; v2(81.1,7.22) UH2.AW37 ; v2(246.32,94.89) 245.94,95.27 UV10.R14 ; UV6.P10 v2(195.45,107.36) ; UV6.U3 193.85,101.76 v2(193.85,101.76) ; UV6.C12 204.66,109.36 v2(204.26,109.76) ; UV5.U3 211.86,101.79 v2(211.86,101.74) ; v2(204.26,100.16) UV6.C1 ; PU1301.10 106.41,71.53 106.62,71.32 v2(106.68,71.32) ; UV9.F10 242.71,70.11 v2(242.39,70.43) 242.71,70.75 UV9.G10 ; UV10.U1 235.51,96.86 v2(235.91,96.46) ; v2(178.79,83.93) 178.5,83.93 178.23,84.2 UH1.A34 ; UV6.R4 v2(194.66,102.57) 195.05,102.17 UV6.R3 ; v2(234.96,91.27) UV10.K1 UV10.K2 ; v2(213.54,100.16) 213.14,100.56 UV5.R1 ; UH2.L41 v2(79.62,20.67) UH2.N41 ; UV9.N14 245.91,75.65 v2(246.3,76.04) ; UV5.M5 215.49,103.78 v2(215.88,104.17) UV5.L5 ; v2(197.85,107.33) 198.26,107.73 UV6.L10 ; UV10.B10 242.19,84.86 v2(242.18,84.88) ; UV1.N30 v2(216.45,88.45) ; v2(332.8,65.79) 332.8,64.84 331.98,64.01 UI2.14 ; v2(237.51,86.87) UV10.E3 ; UV6.R11 v2(195.45,108.96) ; UV10.E1 235.11,87.67 v2(235.04,87.67) ; UV5.H13 v2(219.09,110.56) UV5.H14 ; v2(242.19,88.8) 242.65,88.8 UV10.G10 ; v2(194.65,110.56) UV6.R14 ; 81.47,10.49 81.13,10.83 UH2.AL38 ; 81.47,10.49 v2(81.47,10.42) ; 81.47,10.49 81.47,10.5 ; UH2.R29 85.03,19.28 v2(85.03,19.44) ; v2(178.79,84.76) 178.59,84.76 178.35,85.01 UH1.A36 ; UV9.R11 243.51,77.27 v2(243.09,77.7) 242.75,78.03 UV9.T10 ; RPH32.7 206.69,56.25 v2(206.96,56.52) 207.19,56.3 RPH32.8 ; UV6.C3 204.66,102.15 v2(204.27,101.76) ; UV1.AN4 199.8,66.3 v2(199.58,66.07) ; UV6.K1 v2(198.66,100.96) UV6.K2 ; UV6.A1 206.26,100.18 v2(206.14,100.07) ; UV6.G10 201.55,107.67 202.16,107.67 UV6.F10 v2(202.66,107.36) ; UV6.H2 v2(201.06,100.96) UV6.H1 ; v2(242.31,86.83) 242.68,86.47 UV10.D10 ; UV6.T5 193.79,104.22 v2(193.79,104.75) ; UV1.G7 221.95,68.8 UV1.F7 UV1.E7 223.6,68.83 v2(223.98,69.21) ; JEDP1.11 66.55,32.2 66.54,31.72 v2(66.54,31.71) ; v2(215.14,100.15) 215.15,100.15 214.74,100.56 UV5.N1 ; v2(222.31,73.46) 221.96,73.8 UV1.G13 ; v2(202.26,65.05) 201.86,64.65 UV1.AL2 ; v2(194.65,100.97) 195.05,100.57 UV6.R1 ; v2(211.87,111.37) 211.49,110.99 UV5.U14 ; UV6.A3 206.26,102.22 v2(206.58,102.54) ; UV1.AC17 207.6,77.09 v2(208.12,77.61) 207.69,78.05 UV1.AC18 ; v2(65.04,31.72) 65.05,31.73 JEDP1.14 ; v2(68.04,31.71) 68.05,31.72 JEDP1.8 ; UV10.U14 245.91,96.85 v2(246.39,96.37) ; v2(238.3,66.41) 238.3,66.41 UV9.B5 ; UH2.AR33 v2(83.03,9.42) UH2.AR34 ; v2(121.46,28.39) 122.37,27.47 JDIMM1.61 ; 71.2,31.68 v2(71.2,31.72) ; 71.2,31.68 71.55,32.04 JEDP1.1 ; 71.2,31.68 71.05,31.83 JEDP1.2 ; UV1.C7 UV1.B7 226.43,68.8 v2(226.56,68.68) ; v2(212.21,90.02) 211.85,89.66 UV1.W32 ; UV5.G5 219.52,103.79 v2(219.52,104.31) ; UV5.C12 222.69,109.32 v2(222.32,108.95) 222.69,108.57 UV5.C11 ; UV1.G30 v2(221.47,87.67) ; v2(243.91,78.43) UV9.U12 ; v2(99.57,25.85) 100.09,26.37 v2(100.8,26.37) 100.8,25.83 101.03,25.6 102.17,25.6 102.49,25.92 102.49,26.93 102.08,27.34 v2(101.23,27.34) 101,27.57 99.44,27.57 98.49,26.62 97.47,26.62 97.35,26.49 ; PU1001.6 173.28,95.27 173.61,94.94 ; v2(208.9,66.62) 209.33,67.05 UV1.AB5 ; UV10.R4 237.9,95.27 v2(237.5,95.66) 237.51,95.66 UV10.R3 ; v2(201.07,111.38) 200.66,110.97 UV6.H14 ; UV1.G28 221.9,86.31 v2(222.31,85.9) 222.72,86.3 UV1.F28 ; UV1.M20 218.6,79.75 v2(218.41,79.56) ; v2(239.24,89.02) 238.87,89.02 UV10.G5 ; v2(236.71,72.83) UV9.K2 ; UI3.10 319.91,35.04 320.05,35.19 v2(320.05,35.48) ; v2(340.16,41.79) 340.17,41.79 340.22,41.74 UZ5.5 ; UV9.E14 245.53,68.85 v2(245.53,68.84) ; UV1.E5 223.52,67.05 v2(223.18,66.71) ; UV5.E1 v2(220.69,100.16) ; v2(243.13,96.47) 242.72,96.07 UV10.T10 ; UV5.R14 v2(212.69,110.56) ; v2(79.41,21.62) UH2.K43 ; v2(79.41,21.62) UH2.K42 ; v2(79.41,21.62) UH2.J39 ; v2(245.5,91.64) 245.5,91.62 245.15,91.27 UV10.K13 ; UV9.C3 v2(237.51,68.03) UV9.C4 ; UV9.L5 238.7,74.03 v2(238.28,74.45) 238.66,74.83 UV9.M5 ; v2(246.37,91.62) 246.01,91.27 UV10.K14 ; v2(218.97,89.2) 219.35,89.58 UV1.K32 ; UV9.C14 246.3,68.01 v2(246.44,68.01) ; v2(235.04,69.62) 235.42,69.23 UV9.E1 ; JKB.15 156.27,9.73 v2(156.53,9.47) 156.77,9.71 JKB.14 ; JEDP1.34 55.05,31.89 55.21,31.73 v2(55.69,31.73) 55.69,32.11 55.55,32.25 JEDP1.33 ; UV1.B1 226,63.9 v2(226.41,64.31) 226.75,64.65 UV1.A2 ; v2(234.97,93.72) 234.99,93.71 235.47,93.71 UV10.N1 ; v2(196.98,104.87) 197.46,104.4 UV6.M5 ; v2(41.96,27.39) 42.32,27.39 42.76,27.83 CT47.2 ; UV10.U12 244.31,96.91 v2(243.94,97.29) ; v2(244.77,72.85) 244.71,72.8 244.71,72.03 UV9.H13 ; v2(213.91,66.65) 214.31,67.05 UV1.T5 ; v2(238.31,84.46) UV10.B5 ; v2(233.06,9.14) 232.86,9.34 JHDD.4 ; UV1.N33 216.98,90.32 216.98,89.78 UV1.N32 216.9,89.65 v2(217.3,89.25) ; UV5.T10 v2(212.69,107.36) ; UV1.AK10 202.6,71.26 202.92,70.94 v2(203.05,70.94) ; UV10.C14 245.97,85.67 246.35,85.28 v2(246.33,85.28) ; UV6.G5 v2(201.86,104.16) ; DT26.2 v2(10.98,61.86) ; UV10.C1 235.47,85.7 v2(234.96,85.7) ; UV1.K28 219.29,86.35 v2(218.96,86.02) ; UV1.B10 UV1.C10 225.2,71.28 v2(224.84,70.93) ; v2(246.33,78.45) 245.95,78.83 UV9.U14 ; UV6.D10 203.86,107.76 v2(204.27,108.17) 204.65,108.56 UV6.C11 ; UV9.U3 237.11,78.91 236.74,79.28 v2(236.73,79.28) ; UV5.L10 v2(216.29,107.2) ; v2(222.29,100.16) UV5.C1 ; UH2.C1 UH2.D1 ; v2(237.51,93.27) UV10.N3 ; v2(198.96,90.79) 199.3,90.45 UV1.AP33 ; UV5.E12 221.09,109.32 v2(221.46,108.95) ; v2(202.66,100.16) UV6.E1 ; v2(235.13,77.64) 235.13,77.62 UV9.R1 ; UV1.AH32 204.4,89.65 v2(204.79,89.26) ; UV5.R12 v2(213.49,108.96) ; UV1.AN1 199.86,63.51 v2(199.62,63.51) ; UV10.L10 242.71,92.1 v2(242.35,92.46) 242.71,92.82 UV10.M10 ; v2(198.68,103.36) 198.68,103.37 198.29,103.76 UV6.L5 ; UH2.AT36 v2(82.28,8.34) UH2.AU35 ; UV1.AH7 204.3,68.82 v2(203.9,69.22) ; PU1300.10 v2(107.17,78.75) ; UV10.C4 v2(237.51,86.07) UV10.C3 ; UH2.N35 v2(83.22,19.5) ; UV5.E3 v2(221.49,102.56) ; UV9.K13 245.25,73.23 245.5,72.98 v2(245.5,72.81) 245.91,73.22 UV9.K14 ; UV9.H2 v2(235.94,71.26) ; v2(223.91,65.03) 224.3,64.65 UV1.D2 ; v2(214.77,90.05) 214.37,89.65 UV1.T32 ; v2(173.67,6.55) 173.48,6.55 173.12,6.91 JAPS.12 ; v2(319.68,29.6) 319.91,29.84 UI3.21 ; UV1.AH10 204.16,71.3 v2(203.83,71.62) 204.3,72.09 UV1.AH11 ; v2(238.33,78.41) 238.33,78.41 UV9.T5 ; v2(11.74,34.83) 11.3,35.27 UT4.L1 ; v2(176.36,86.94) 176.36,86.74 UH1.D38 ; UV6.E14 203.06,110.96 v2(203.47,110.55) ; v2(244.71,77.63) UV9.R12 ; v2(224.69,110.56) UV5.A14 ; UV6.E12 v2(202.66,109.76) ; v2(203.89,68.38) 203.47,68.8 UV1.AJ7 UV1.AK7 ; DT21.2 v2(9.4,69.04) ; UV9.C12 244.31,67.6 v2(244.68,67.24) ; UV9.H1 v2(235.14,71.26) ; UV6.H13 200.66,110.17 v2(201.07,110.58) ; v2(214.29,111.36) UV5.N14 ; v2(224,88.45) UV1.D31 ; JEDP1.35 54.55,31.8 v2(54.47,31.72) ; v2(206.48,67.51) 206.85,67.13 UV1.AE5 ; v2(196.25,100.16) UV6.N1 ; UV9.A14 245.71,66.03 245.27,65.59 v2(244.73,65.59) 244.73,65.62 UV9.A12 ; v2(213.49,108.16) UV5.P10 ; PU1201.10 140.72,113.29 140.65,113.22 v2(140.65,113.17) ; v2(216.66,110.56) 217.06,110.96 UV5.K14 ; DT20.2 v2(9.4,71.56) ; UV1.AH2 204.35,64.61 v2(203.94,64.19) ; UV10.H14 245.87,89.67 v2(245.5,90.04) 245.13,89.67 UV10.H13 ; v2(25.33,48.49) 25.39,48.43 RT209.1 24.9,47.92 RT39.1 ; UV1.AL32 v2(201.41,90.09) 201.77,90.45 UV1.AL33 ; UV9.R3 237.11,77.19 v2(237.47,76.83) ; v2(208.95,69.13) 209.34,68.75 UV1.AB7 ; v2(225.57,73.4) 225.2,73.77 UV1.C13 ; v2(221.49,110.56) UV5.E14 ; UV9.A1 235.32,65.84 v2(234.96,65.84) ; UV10.R11 v2(243.91,94.87) UV10.R12 ; UV9.L10 242.78,74.03 243.13,74.38 v2(243.13,74.43) 242.73,74.83 UV9.M10 ; UV6.B10 v2(205.86,107.36) ; UV5.M10 v2(215.09,107.36) ; JHDD.10 v2(235.86,9.41) ; UV9.R4 237.91,77.26 v2(238.28,77.62) ; UV6.R12 v2(194.65,109.76) ; v2(2.49,38.04) 2.49,38.01 2.91,37.59 RT186.2 ; v2(236.71,66.43) UV9.A3 ; UV5.R11 213.09,108.61 v2(212.73,108.97) ; v2(216.69,101.76) UV5.K2 ; UV6.C4 v2(204.26,102.56) ; UV1.W28 211.83,86.35 v2(211.43,86.75) ; UV5.B5 v2(223.89,103.36) ; v2(237.51,68.83) UV9.E3 ; UV5.N12 v2(214.29,109.76) ; UV1.E10 223.45,71.3 v2(223.1,70.95) ; v2(242.31,76.83) UV9.P10 ; v2(242.31,94.87) UV10.P10 ; UV5.N3 214.64,102.16 v2(214.24,102.56) ; UH1.BT35 136.86,84.23 v2(136.84,84.25) ; RPH32.6 v2(206.19,56.4) ; v2(234.97,95.26) 234.98,95.27 UV10.R1 ; v2(244.71,87.67) UV10.E12 ; UV6.K13 199.06,110.2 198.67,110.59 v2(198.66,110.59) 199.03,110.96 UV6.K14 ; UV5.U1 211.86,100.18 v2(211.86,100.14) ; UV9.C11 243.49,67.63 v2(243.1,68.01) ; v2(148.45,68.52) 148.77,68.2 UH1.AY14 ; UH2.D31 v2(84.86,24.66) ; UV1.AH5 v2(203.9,67.5) ; UV5.K13 v2(216.69,109.76) ; v2(244.71,76.03) UV9.N12 ; v2(242.27,66.41) 242.68,66.83 UV9.B10 ; UV10.M5 238.8,92.78 239.18,92.78 v2(239.3,92.65) ; v2(238.3,96.46) 238.7,96.07 UV10.T5 ; UV1.T2 v2(213.95,64.25) ; v2(214.76,86.76) UV1.T28 ; v2(246.29,71.23) 245.91,71.6 UV9.H14 ; v2(221.47,71.71) 221.87,71.3 UV1.G10 ; v2(199.62,68.46) 199.96,68.8 UV1.AN7 ; v2(245.51,83.66) UV10.A14 ; v2(246.48,87.27) UV10.E14 ; UV6.B5 v2(205.86,104.16) ; UV5.F10 v2(220.7,107.35) ; v2(223.89,100.16) UV5.A1 ; v2(235.9,78.44) 235.51,78.83 UV9.U1 ; UV1.K7 219.35,67.87 v2(218.99,67.51) 218.99,67.41 UV1.K5 ; v2(236.71,84.46) UV10.A3 ; UV1.G19 221.9,78.8 v2(222.31,79.22) ; v2(236.69,97.26) 237.09,96.87 UV10.U3 ; UV6.N12 v2(196.25,109.76) ; UV1.N28 v2(216.46,85.96) ; UV6.N3 v2(196.25,101.76) ; v2(223.09,110.56) UV5.C14 ; v2(244.71,69.63) UV9.E12 ; JEDP1.28 58.05,31.83 v2(58.17,31.71) 58.55,32.09 JEDP1.27 ; v2(244.71,94.07) UV10.N12 ; v2(237.51,75.23) UV9.N3 ; UV5.K1 v2(216.68,100.15) ; UV5.A3 v2(223.89,101.76) ; v2(218.1,75.51) 218.16,75.51 218.6,75.07 UV1.M15 ; JKB.13 v2(157.27,9.47) ; v2(235.11,73.63) UV9.K1 ; v2(244.71,83.66) UV10.A12 ; v2(238.34,91.7) UV10.L5 ; UV6.A12 v2(205.86,108.96) ; UV5.T5 v2(212.68,103.37) ; UV6.T10 v2(194.65,108.16) ; UV6.N14 v2(196.25,111.36)
  BOTTOM w0.279: UV1.AE32 206.85,89.72 v2(206.46,90.1) 206.81,90.45 UV1.AE33 ; v2(208.95,87.67) 208.97,87.67 UV1.AB30 ; UV1.G32 221.85,89.65 v2(221.44,90.06) 221.82,90.45 UV1.G33 ; UV1.C28 UV1.B28 226,86.36 v2(226.37,86.72) ; UV1.AL26 201.78,84.65 v2(201.4,85.03) ; v2(199.75,91.98) 199.75,91.7 UV1.AN34 ; v2(223.18,84.21) 223.59,83.8 UV1.E25 ; UV1.AB2 209.71,64.29 v2(209.71,64.14) ; v2(199.8,88.32) 200.17,87.95 UV1.AN30 ; UV1.AN25 UV1.AM25 201,83.71 v2(201.42,83.29) 201.76,82.95 UV1.AL24 UV1.AL23 ; UV1.AH32 UV1.AH33 ; UV1.G22 221.87,81.3 v2(221.45,81.72) ; UV1.AB28 209.33,86.35 v2(208.93,86.75) ; UV1.AH13 204.3,73.74 v2(203.96,73.4) ; UV1.D33 224.35,90.97 v2(224.19,91.13) ; v2(221.53,83.38) 221.9,83.76 UV1.G25 ; UV1.V14 UV1.W13 ; v2(224.91,75.88) 224.91,76.01 UV1.C16 ; UV1.B22 226,81.34 v2(225.58,81.76) 225.2,81.38 UV1.C22 ; UV1.AH22 204.3,81.29 v2(204.71,80.88) ; UV1.AE30 206.8,88.05 206.41,88.45 v2(206.4,88.45) ; UV1.E22 223.6,81.38 v2(224.02,81.79) ; UV1.AH24 v2(203.88,83.37) ; UV1.K30 219.04,87.74 v2(219.04,87.57) ; v2(201.44,87.56) 201.8,87.93 UV1.AL30 ; v2(204.7,85.92) 204.3,86.32 UV1.AH28 ; UV1.AB32 209.25,89.65 v2(208.92,89.32) ; UV1.G16 221.87,76.3 v2(221.46,75.89) ; UV1.K33 UV1.K32 ; v2(201.39,86.73) 201.8,86.32 UV1.AL28 ; UV1.AL5 202.16,67.51 v2(203,67.51) ; v2(226.43,84.2) 226.03,83.8 UV1.B25 UV1.C25 ; UV1.AH16 204.27,76.3 v2(203.84,75.87)
  BOTTOM w0.305: JDEG1.10 306.61,30.99 306.3,30.68 305.52,30.68 v2(305.36,30.84) ; JDIMM1.40 117.12,17.2 117.64,16.68 v2(117.89,16.68) 118.12,16.91 JDIMM1.44 ; 232.3,16.86 232.3,16.85 231.72,16.85 231.42,17.15 JDIMM2.184 ; 232.3,16.86 232.42,16.98 JDIMM2.188 ; 232.3,16.86 v2(232.3,16.86) ; JDIMM2.222 240.93,18.15 240.93,17.15 v2(241.21,16.86) ; UV1.N12 217.47,72.05 v2(217,72.52) 217,72.65 UV1.P13 UV1.R14 UV1.T15 UV1.U16 ; JDIMM1.1 107.37,27.44 107.7,27.76 108.76,27.76 v2(108.88,27.65) ; v2(119.47,27.6) 119.61,27.6 119.88,27.33 JDIMM1.51 ; JDIMM1.180 154.12,19.76 153.81,20.07 ; v2(10.69,43.87) 11.01,43.55 CT152.2 ; UV1.P18 216.6,78.18 v2(216.99,78.56) 217.47,79.05 UV1.N19 ; UV1.W13 211.2,72.65 v2(211.2,72.52) 210.73,72.05 UV1.Y12 ; JDIMM1.47 118.88,27.76 119.34,28.22 v2(119.47,28.22) ; v2(112.89,27.58) 112.88,27.57 JDIMM1.23 ; JDIMM1.78 126.62,17.12 v2(126.18,16.67) 125.64,16.67 125.12,17.19 JDIMM1.72 ; JDIMM2.14 186.92,17.32 187.35,16.89 187.56,16.89 ; v2(150.48,19.37) 150.93,19.37 151.12,19.18 JDIMM1.168 ; UV1.U12 213.57,72.05 v2(213.1,72.52) 212.63,72.05 UV1.V12 ; v2(131.73,27.89) 131.88,27.74 JDIMM1.99 ; JDIMM2.213 238.67,27.42 238.29,27.8 v2(237.97,27.8) 237.67,27.51 JDIMM2.209 ; JDIMM2.77 202.67,27.8 202.14,28.34 v2(201.94,28.34) 201.63,28.34 201.47,28.18 201.47,27.47 201.67,27.27 JDIMM2.73 ; v2(335.67,92.83) 335.8,92.7 JNGFF1.22 ; v2(228.16,27.65) 228.18,27.63 JDIMM2.171 ; JNGFF1.16 v2(334.3,92.85) ; JDIMM1.171 151.87,27.19 151.63,27.44 151.63,27.97 151.98,28.33 v2(152.17,28.33) ; v2(116.89,27.59) 116.89,27.58 116.88,27.57 JDIMM1.39 ; UV1.T17 UV1.R16 215.6,75.81 216.09,75.32 216.09,75.3 v2(216.1,75.29) 216.35,75.05 UV1.P15 216.89,74.76 217.2,74.76 v2(217.41,74.55) 217.6,74.36 UV1.N14 ; v2(134.29,28.71) 134.05,28.71 132.88,27.53 JDIMM1.103 ; JDIMM1.217 163.37,27.4 v2(163.74,27.76) ; v2(248.1,27.9) 248.18,27.83 JDIMM2.251 ; v2(204.68,20.99) 204.89,20.99 205.27,20.61 205.27,19.38 204.92,19.04 JDIMM2.86 ; JNGFF1.61 v2(345.55,85.15) ; v2(205.81,28.56) 205.86,28.56 206.67,27.75 JDIMM2.93 ; JDIMM2.223 241.18,27.28 241.67,27.78 v2(241.78,27.78) 242.18,27.33 JDIMM2.227 ; JNGFF2.51 259.5,10.04 259.29,9.83 259.29,8.93 259.68,8.54 JNGFF2.57 263.46,8.54 263.82,8.91 v2(263.82,9.06) ; v2(204.22,16.86) 203.92,17.15 JDIMM2.82 ; JDIMM2.210 237.94,18.15 237.94,17.22 v2(238.29,16.87) 238.74,16.87 238.93,17.05 JDIMM2.214 ; v2(239.29,27.82) 239.67,27.43 JDIMM2.217 ; v2(155.51,8.33) 155.38,8.2 JKB.16 ; JNGFF1.67 v2(347.05,85.15) ; JDIMM2.60 198.43,17.21 198.77,16.86 v2(198.93,16.86) 199.13,16.86 199.43,17.16 JDIMM2.64 ; JDIMM1.209 161.37,27.37 v2(161.15,27.59) 161.38,27.82 162.01,27.82 162.37,27.46 JDIMM1.213 ; JDIMM1.205 160.37,27.47 160.14,27.7 v2(160.03,27.7) 159.82,27.7 159.37,27.25 JDIMM1.201 ; JDIMM2.189 232.67,27.51 232.49,27.69 v2(232.24,27.69) 231.99,27.69 231.67,27.37 JDIMM2.185 ; JDIMM2.180 230.44,18.15 v2(230.44,16.86) ; JDIMM2.9 185.68,27.91 v2(186.03,28.26) ; v2(187.98,28.2) 187.85,28.2 187.18,27.52 JDIMM2.15 ; JDIMM2.252 248.42,17.24 248.03,16.85 v2(247.92,16.85) 247.71,16.85 247.42,17.14 JDIMM2.248 ; JDIMM2.102 208.94,18.15 208.94,17.06 209.14,16.86 209.39,16.86 v2(209.39,16.86) 209.39,16.86 209.47,16.86 209.94,17.33 JDIMM2.106 ; v2(208.13,16.86) 207.92,17.07 JDIMM2.98 ; v2(247.99,28.57) 247.18,27.75 JDIMM2.247 ; v2(218.99,81.54) 218.6,81.93 UV1.M22 ; JDIMM2.72 201.43,19.44 v2(202.65,20.67) ; JDIMM2.85 204.67,27.33 204.78,27.43 204.78,27.97 204.3,28.45 v2(204.11,28.45) ; UV1.U23 UV1.V23 212.6,83.05 212.6,83.39 v2(212,83.99) 211.54,83.99 v2(211.1,83.55) UV1.Y23 UV1.W22 211.6,81.97 v2(212.03,81.54) 212.11,81.54 UV1.V21 UV1.U21 ; JDIMM1.86 128.62,17.28 v2(128.04,16.69) 127.62,17.1 JDIMM1.82 ; v2(204.17,27.83) 204.02,27.83 203.67,27.48 JDIMM2.81 ; UV1.W18 UV1.Y19 UV1.AA20 UV1.AB21 v2(208.18,81.47) UV1.AC22 ; 187.56,16.89 187.92,17.26 JDIMM2.18 ; 187.56,16.89 v2(187.56,16.87) ; JNGFF1.10 v2(332.8,92.84) ; v2(215.09,83.55) 215.59,83.05 UV1.R23 UV1.T22 ; v2(197.67,16.87) 197.43,17.12 JDIMM2.56 ; JDIMM1.175 152.87,27.35 152.56,27.66 v2(152.18,27.66) ; JNGFF2.3 259.5,22.04 259.3,22.25 v2(258.81,22.25) 259.11,22.54 JNGFF2.1 ; v2(337.29,89.3) 337.15,89.44 337.15,90.33 337.3,90.49 JNGFF1.28 ; JNGFF1.15 334.05,84.82 v2(334.56,85.33) ; JDIMM2.22 188.92,17.23 189.3,16.86 189.5,16.86 v2(189.5,16.86) 189.5,16.86 189.52,16.86 189.85,17.19 189.92,17.26 JDIMM2.26 ; v2(193.12,28.64) 194.18,27.59 JDIMM2.43 ; JDIMM2.35 192.18,28.2 191.51,28.86 v2(191.14,28.86) ; JDIMM2.175 229.18,27.76 228.7,28.23 v2(228.16,28.23) ; JDIMM2.202 235.93,17.3 236.37,16.86 236.49,16.86 v2(236.49,16.86) 236.5,16.86 236.57,16.86 236.94,17.23 236.94,17.27 JDIMM2.206 ; v2(210.65,27.99) 210.18,27.51 JDIMM2.107 ; JDIMM2.244 246.42,17.21 v2(246.08,16.86) ; JDIMM2.47 195.18,28.13 v2(195.48,28.43) ; v2(259.02,4.63) 259.6,4.04 JNGFF2.67 ; v2(167.06,21.06) 167.24,21.06 167.63,20.67 167.63,20.03 166.63,19.02 166.63,18.15 ; v2(123.36,28.49) 124.37,27.48 JDIMM1.69 ; v2(261.64,19.91) 261.64,20.25 261.34,20.54 JNGFF2.9 ; JDIMM1.60 122.12,17.26 v2(122.66,16.72) 123.12,17.18 JDIMM1.64 ; v2(226.72,28.32) 226.82,28.32 227.3,27.84 227.3,27.44 227.18,27.31 JDIMM2.167 ; JDIMM1.239 168.87,27.5 168.63,27.75 168.06,27.75 v2(168.05,27.76) 167.87,27.59 JDIMM1.235 ; UV1.Y14 UV1.W15 211.6,75.15 v2(211.98,75.52) 212.5,76.05 UV1.V16 ; JDIMM2.36 192.43,17.32 191.96,16.85 191.67,16.85 ; JDIMM2.230 242.93,17.32 243.25,17 243.42,17 v2(243.55,16.86) 243.93,17.23 JDIMM2.234 ; JDIMM2.69 200.67,27.31 199.8,28.19 v2(198.9,28.19) ; JDIMM2.89 205.67,27.68 205.69,27.69 v2(205.82,27.83) ; JDIMM1.206 160.63,17.14 160.34,16.85 160.2,16.85 ; JNGFF1.49 342.55,84.7 342.94,85.09 v2(342.94,85.19) ; v2(164.4,6.42) 164.15,6.67 JKB.17 ; v2(204.68,22.26) 205.11,22.26 205.92,21.44 JDIMM2.90 ; JDIMM1.184 155.12,17.1 155.33,16.9 v2(155.75,16.9) 156.12,17.27 JDIMM1.188 ; v2(200.26,16.86) 200.43,17.02 JDIMM2.68 ; v2(338.7,85.86) 338.67,85.89 338.15,85.89 337.9,85.63 337.9,84.9 338.05,84.74 JNGFF1.31 ; v2(210.59,28.59) 210.24,28.59 209.18,27.53 JDIMM2.103 ; 109.8,27.65 v2(109.83,27.67) ; 109.8,27.65 109.37,27.22 JDIMM1.9 ; 109.8,27.65 v2(108.88,27.65) ; JDIMM1.196 158.12,17.18 v2(157.84,16.9) 157.37,16.9 157.12,17.14 JDIMM1.192 ; v2(193.19,27.75) 193.19,27.75 193.18,27.74 JDIMM2.39 ; v2(124.14,16.73) 124.12,16.74 JDIMM1.68 ; UV1.P17 216.6,77 v2(217.06,76.54) 217.55,76.05 UV1.N16 ; JNGFF1.21 335.55,84.71 336,85.15 v2(336.55,85.15) JNGFF1.25 ; JDIMM1.244 170.12,17.19 v2(169.8,16.86) ; JDIMM1.210 161.63,17.24 v2(161.97,16.9) 162.21,16.9 162.63,17.31 JDIMM1.214 ; RT207.1 RT45.1 RT44.1 RT208.1 19.65,42.97 19.9,42.72 21.02,42.72 v2(21.09,42.8) ; JDIMM1.234 167.63,17.13 167.4,16.9 v2(167.37,16.9) ; JDIMM2.176 229.44,17.27 v2(229.04,16.86) 228.85,16.86 228.44,17.28 228.44,18.15 JDIMM2.172 ; JDIMM1.36 116.12,17.19 115.61,16.67 v2(115.37,16.67) 115.24,16.67 114.62,17.29 JDIMM1.30 ; v2(206.58,16.86) 206.92,17.21 JDIMM2.94 ; JDIMM2.168 227.43,18.16 227.43,19.84 v2(227.44,19.85) ; RT187.1 11.05,32.71 11.26,32.5 v2(11.26,32.31) 11.69,32.73 RT188.1 ; JDIMM1.43 117.88,27.32 v2(116.92,28.27) ; 153.81,20.07 153.81,20.63 153.38,21.06 v2(153.29,21.06) ; 153.81,20.07 153.12,19.39 JDIMM1.176 ; v2(233.56,27.7) 233.67,27.58 JDIMM2.193 ; v2(189.3,28.39) 189.63,28.39 190.18,27.76 JDIMM2.27 ; JDIMM2.31 191.18,27.61 v2(191.19,27.63) ; v2(230.43,27.6) 230.67,27.36 JDIMM2.181 ; JDIMM1.77 126.37,27.78 v2(125.71,28.44) 125.19,27.91 125.19,27.46 125.37,27.27 JDIMM1.73 ; JNGFF2.45 261.27,11.54 261.63,11.91 v2(261.63,12.58) 261.63,12.79 261.37,13.04 JNGFF2.39 ; JNGFF2.15 261.8,19.04 262.23,19.48 v2(262.23,19.91) ; JDIMM1.5 108.37,27.19 108.83,27.65 v2(108.88,27.65) ; v2(150.53,28.34) 150.62,28.34 151,27.96 151,27.44 150.87,27.31 JDIMM1.167 ; JDIMM1.226 165.63,17.28 165.2,16.86 v2(164.86,16.86) 164.63,17.1 JDIMM1.222 ; JDIMM2.48 195.43,17.14 195.7,16.86 195.92,16.86 v2(195.92,16.86) 195.92,16.86 195.98,16.86 196.43,17.3 JDIMM2.52 ; v2(218.99,72.59) 218.6,72.97 UV1.M13 ; JDIMM1.193 157.39,27.33 157.09,27.63 v2(156.94,27.63) ; JDIMM1.85 128.37,27.89 v2(127.81,28.45) ; UV1.W17 UV1.Y16 UV1.AA15 209.2,74.65 UV1.AB14 UV1.AC13 207.48,73.05 v2(207.03,73.49) ; JDIMM1.251 171.89,26.35 171.89,27.68 171.83,27.74 v2(170.56,27.74) 170.62,27.67 170.89,27.67 JDIMM1.247 ; JNGFF1.55 v2(344.05,85.15) ; 160.2,16.85 160.01,16.85 159.63,17.23 JDIMM1.202 ; 160.2,16.85 v2(160.2,16.86) ; v2(123.39,27.73) 123.37,27.71 JDIMM1.65 ; v2(131.83,16.9) 131.83,16.95 131.62,17.15 JDIMM1.98 ; v2(339.6,85.07) 339.55,85.03 JNGFF1.37 ; JDIMM1.52 120.12,17.11 119.69,16.68 v2(119.58,16.68) 119.46,16.68 119.12,17.02 JDIMM1.48 ; JDIMM1.15 110.88,27.52 111.55,28.2 v2(111.68,28.2) ; JDIMM1.172 152.12,17.11 152.35,16.89 v2(152.43,16.89) ; v2(167.06,23.6) 167.17,23.6 167.57,24 167.57,24.83 166.87,25.52 JDIMM1.231 ; UV1.T18 UV1.R19 UV1.P20 216.6,80.24 v2(217,80.64) 217.41,81.05 UV1.N21 ; v2(197.47,27.61) 197.67,27.4 JDIMM2.57 ; JDIMM2.205 236.67,27.28 236.25,27.7 v2(236.14,27.7) 235.67,27.24 JDIMM2.201 ; UV1.U14 UV1.T13 215.09,72.56 v2(215.09,72.52) 215.56,72.05 UV1.R12 ; JDIMM2.19 188.18,27.37 v2(187.98,27.56) ; v2(184.16,20.39) 184.33,20.39 184.92,19.8 JDIMM2.6 184.92,17.2 184.58,16.86 184.25,16.86 183.92,17.19 JDIMM2.2 ; JLPDE1.9 296.7,31.78 296.42,32.06 295.99,32.06 v2(295.63,31.71) ; JNGFF1.7 v2(330.05,85.15) ; 191.67,16.85 191.39,16.85 190.92,17.32 JDIMM2.30 ; 191.67,16.85 v2(191.67,16.86) ; v2(233.51,28.28) 234.11,28.28 234.67,27.71 JDIMM2.197 ; JDIMM1.197 158.39,26.35 158.39,27.19 157.21,28.37 v2(156.97,28.37) ; JDIMM1.89 129.37,27.61 129.39,27.63 v2(129.64,27.91) ; JDIMM1.227 165.87,27.39 165.54,27.76 v2(165.39,27.76) 165.17,27.76 164.89,27.48 164.89,27.3 JDIMM1.223 ; UV1.AB23 UV1.AA22 UV1.Y21 UV1.W20 211.6,80 v2(212.03,79.57) 212.55,79.05 UV1.V19 ; v2(114.89,28.79) 115.3,28.79 115.88,28.22 JDIMM1.35 ; v2(239.66,16.87) 239.66,17.03 239.93,17.3 JDIMM2.218 ; JDIMM1.185 155.37,27.37 155.63,27.63 v2(155.98,27.63) 156.19,27.63 156.39,27.43 156.39,26.35 JDIMM1.189 ; JDIMM1.81 127.37,27.28 v2(127.76,27.67) ; JDIMM1.56 121.12,19.09 120.49,19.73 119.73,19.73 119.38,20.08 119.38,21.81 v2(119.27,21.91) ; v2(111.68,27.56) 111.88,27.37 JDIMM1.19 ; JDIMM2.65 199.67,27.19 199.29,27.58 v2(199.26,27.58) ; UV1.AC15 207.6,75.27 v2(208.07,75.74) 208.38,76.05 UV1.AB16 UV1.AA17 UV1.AA18 UV1.AB19 208.6,79.05 v2(208.18,79.47) 207.6,80.05 UV1.AC20 ; JDIMM2.10 v2(185.92,20.01) ; v2(341,85.28) 341,84.95 341.05,84.9 JNGFF1.43 ; v2(261.61,14.98) 261.61,14.86 261.3,14.54 JNGFF2.33 ; JDIMM2.51 196.18,27.43 v2(195.73,27.88) ; v2(129.64,28.64) 129.69,28.64 130.37,27.96 JDIMM1.93 ; JNGFF2.65 261.74,4.54 v2(261.82,4.63) 261.41,5.04 JNGFF2.63 ; JDIMM2.243 246.18,25.28 v2(245.72,24.83) 245.72,24.83 245.72,24.82 245.18,25.37 JDIMM2.239 ; v2(164.01,21.06) 164.13,21.06 164.63,20.56 164.63,20 163.63,18.99 JDIMM1.218 ; JDIMM1.248 171.12,17.21 171.34,16.99 v2(171.34,16.87) ; v2(114.44,16.66) 114.11,16.66 113.62,17.14 JDIMM1.26 ; JDIMM1.238 168.63,17.13 v2(168.88,16.87) ; JDIMM2.192 233.42,17.31 233.88,16.86 234.04,16.86 v2(234.05,16.86) 234.05,16.86 234.42,17.23 JDIMM2.196 ; JDIMM1.57 121.37,27.61 v2(121.46,27.69) ; JDIMM2.226 241.93,19.75 243.22,21.05 v2(243.48,21.05) ; JDIMM1.107 133.88,27.68 v2(134.28,28.08) ; JDIMM1.243 169.87,25.28 170.35,24.8 170.35,24.27 169.68,23.6 v2(169.47,23.6) ; JDIMM2.23 189.18,27.57 189.19,27.59 189.19,27.64 v2(189.27,27.72) ; JDIMM1.31 114.88,27.61 v2(114.89,27.63) ; JDIMM2.44 194.43,17.21 194.08,16.86 193.95,16.86 v2(193.95,16.86) 193.95,16.86 193.84,16.86 193.43,17.27 JDIMM2.40 ; v2(172.64,21.06) 172.86,21.06 173.17,20.76 173.17,20.23 172.12,19.19 JDIMM1.252 ; JDIMM2.238 244.93,17.18 v2(245.23,16.87) ; JDIMM1.94 130.62,17.17 130.35,16.9 v2(130.32,16.9) 129.97,16.9 129.62,17.24 JDIMM1.90 ; UV1.AB12 208.73,72.05 v2(209.2,72.52) 209.6,72.92 UV1.AA13 ; JNGFF1.1 v2(328.55,85.15) ; JDIMM2.99 208.18,27.45 v2(208.03,27.59) ; v2(202.63,16.86) 202.94,17.17 202.94,18.15 JDIMM2.78 ; v2(153.43,27.68) 154.11,27.68 154.37,27.41 JDIMM1.181 ; JDIMM2.5 184.68,28.84 v2(184.25,29.26) 183.68,28.69 JDIMM2.1 ; JDIMM2.235 244.18,27.38 243.8,27.75 v2(243.53,27.75) 243.18,27.39 JDIMM2.231 ; JDIMM1.102 132.62,17.1 132.83,16.9 v2(133.14,16.9) 133.41,16.9 133.62,17.11 JDIMM1.106 ; UV1.U19 213.85,79.05 v2(214.38,79.57) 214.38,79.83 UV1.T20 215.01,80.46 v2(215.24,80.46) 215.6,80.82 UV1.R21 UV1.P22 216.6,82.25 v2(217.04,82.69) 217.4,83.05 UV1.N23 ; JDIMM1.27 113.88,27.78 113.48,28.17 v2(112.88,28.17)
  BOTTOM w0.356: JDIMM1.6 108.62,20 107.92,20.71 v2(107.65,20.71) 107.39,20.71 107.11,20.43 107.11,19.85 107.62,19.34 JDIMM1.2 ; v2(110.18,20.96) 110.32,20.96 110.76,20.53 110.76,20.17 111.62,19.3 JDIMM1.18 ; 261.96,15.77 261.61,15.41 v2(261.61,14.98) ; 109.62,19.5 109.62,20.42 108.66,21.39 v2(108.66,21.91) ; 109.62,19.5 JDIMM1.10 ; 109.62,19.5 109.64,19.49 110.31,19.49 110.62,19.18 JDIMM1.14 ; RT4.1 RT42.1 35.44,43.53 35.44,44.24 35.46,44.27 35.46,44.36 35.47,44.37 35.47,44.78 35.63,44.94 v2(35.63,45.02) ; RT37.1 31.31,48.24 31.05,48.5 31.05,48.78 v2(30.61,49.22) ; v2(14.1,35.31) 14.1,35.1 CT151.2 ; v2(112.42,21.09) 112.19,21.09 111.81,20.71 111.81,20.1 112.62,19.29 JDIMM1.22
  BOTTOM w0.381: v2(34.48,46.52) 34.29,46.33 34.29,46.05 34.13,45.88 RT41.1 ; RH148.1 RH149.1 173.79,56.99 173.77,57.01 173.77,57.43 173.79,57.45 173.79,57.53 v2(173.84,57.58) ; PC210.1 28.62,31.28 v2(28.62,32.02) 27.9,32.02 CT44.2 ; v2(156.53,9.47) 155.45,9.47 155.02,9.9 CE74.2 154.01,9.9 153.47,9.36 CE73.2 ; RH568.2 v2(60.39,4.14) ; v2(8.85,68.56) 8.13,67.83 CT123.2 ; CH50.1 104.52,3.95 104.96,3.5 v2(104.96,2.83) ; v2(19.5,52.29) 19.39,52.41 19.39,53.68 20.28,54.58 PQ220.3 ; RH150.1 171.58,55.25 v2(171.11,54.78) ; v2(259.02,4.63) 258.7,4.95 UD2.3 ; v2(18.66,35.87) 18.34,35.87 18.04,35.57 18.04,35.06 18.33,34.77 18.71,34.77 18.92,34.55 UT5.4 ; v2(328.73,40.14) 329.06,39.81 CR8.2 ; v2(107.7,1.5) 107.7,1.53 107.29,1.94 CLRP1.2 ; CZ31.2 339.65,43.24 v2(339.22,43.67) 339.35,43.8 CZ29.2 ; PU202.4 15.18,19.65 14.4,20.43 v2(14.4,21) ; v2(29.1,27.15) 29.03,27.08 PU201.4 ; PC1042.2 v2(173.48,108.91)
  BOTTOM w0.457: PR250.1 21.65,27.59 21.93,27.31 v2(22.3,27.31)
  BOTTOM w0.508: v2(328.55,85.15) 327.91,85.15 JNGFF1.68 ; JFAN2.4 323.5,40.23 v2(324.17,40.9) ; v2(8.99,21.01) 9.4,20.6 PC216.2 PC214.1 ; v2(24.56,34.81) 25.25,34.12 YT1.2 ; PC812.2 104.33,62.49 v2(104.9,63.06) ; v2(224.64,8.64) 225.27,8.64 226.4,9.77 JTP.10 ; v2(96.6,37.3) 96.6,37.6 97.2,38.2 JFAN1.4 ; v2(178.79,84.76) 178.88,84.68 180.25,84.68 CZ86.2 ; PR1104.1 110.68,109.04 v2(110.36,108.72) ; PR1104.1 PC1139.1 ; PR1104.1 PR1100.1 ; PR1011.1 172.91,106.12 v2(171.77,104.97) ; v2(137.86,5.22) 137.29,5.22 PC513.2 ; PC503.2 135.05,6.51 v2(134.52,5.98) ; v2(104.91,78.62) 104.73,78.8 PC1302.1 ; v2(25.4,52.37) 25.48,52.46 PQ223.3 ; v2(330.44,51.62) 329.79,50.97 JTS.6 ; JEDP1.41 49.55,31.21 51.14,32.8 v2(51.14,33.11) ; v2(178.79,83.93) 179.6,83.12 CZ88.2 CZ47.2 ; v2(286.45,32.84) 286.64,32.65 PC609.2 ; RH497.1 130.09,81.92 v2(129.55,82.46) ; DE4.1 226.62,13.14 226.24,13.14 225.11,12.01 v2(225.11,11.95) ; RV418.2 233.62,73.63 v2(235.11,73.63) ; JTP.5 219.4,13.69 218.91,14.18 218.91,15.14 218.41,15.64 CE79.2 ; v2(222.03,58.68) 221.63,58.68 221.16,58.21 CV576.2 ; v2(331.83,51.58) 332.19,51.22 JTS.3 ; JTS.7 329.15,52.55 329.72,53.12 v2(330.42,53.12) ; CV709.2 234.05,61.45 233.47,62.04 v2(233.44,62.04) ; v2(102.55,81.23) 102.87,81.55 H24.1 102.87,90.79 v2(102.51,91.15) ; RV309.1 218,60.47 218,61.04 v2(218,61.05) ; PC212.2 PR249.2 20.78,26.68 v2(20.65,26.55) ; JAPS.19 180.24,4.39 v2(179.87,4.02) ; RV354.1 v2(217.11,115.01) ; v2(183.26,29.27) 183.25,29.28 JDIMM2.261 ; v2(120.97,92.57) 120.65,92.89 PC1369.2 PC1368.2 PC1367.2 ; RH109.2 102.78,15.24 CH177.2 102.08,15.72 v2(101.58,16.23) ; v2(313.24,34.61) 313.69,34.16 RZ43.1 ; PC1117.2 v2(124.27,104.34) ; RH59.2 RH58.1 131.79,77.91 132.27,78.39 133.26,78.39 v2(133.64,78.01) ; CV363.2 201.87,58.92 v2(201.27,58.33) 200.78,58.81 QV87.3 ; JFAN2.5 v2(324.8,41.86) ; v2(20.87,91) 21.21,90.66 PC114.2 PC115.2 ; v2(55.47,26.48) 56.1,27.1 JEDP1.43 ; v2(253.5,32.14) 253.5,33.72 252.97,34.25 251.39,34.25 JDIMM2.262 ; PC1000.2 162.18,106.82 v2(162.05,106.94) ; CI2.2 333.58,60.98 334.27,60.3 v2(335.51,60.3) ; RI23.2 317.62,37.04 317.44,37.22 v2(316.74,37.22) ; v2(294.26,29.6) 294.1,29.44 JLPDE1.11 ; PC1134.1 115.63,97.58 v2(116.1,97.11) ; v2(20.41,92.78) 20.77,92.78 20.97,92.58 PQ208.3 ; v2(102.56,56.41) 102.85,56.69 H23.1 102.85,67.95 v2(102.51,68.29) ; v2(254.43,8.19) v1(253.91,7.67) 253.91,5.69 254.27,5.33 CD47.2 ; v2(36.9,31.62) 36.79,31.52 33.93,31.52 33.53,31.12 UT2.4 ; PQ230.3 7.32,19.19 v2(7.64,18.87) ; YT1.4 22.3,31.77 21.9,31.37 CT43.2 20.75,31.37 v2(20.49,31.63) ; CE80.2 CE79.2 ; CE79.2 218.36,15.75 v2(218.36,16.87) ; 19.33,20.11 19.29,20.07 PR273.2 ; 19.33,20.11 19.33,20.84 PC215.1 PC217.2 ; 19.33,20.11 v2(19.33,20.05) ; DI10.1 329.64,68.18 v2(329.48,68.35) ; v2(261.44,26.03) 261.44,25.07 261.26,24.88 JNGFF2.68 ; v2(102.02,51.48) 102.02,51.48 JUART.5 ; v2(109.41,66.11) 109.03,65.73 PC800.2 ; RH466.2 RH472.2 158.22,90.27 158.23,90.28 v2(158.23,90.39) ; CV182.1 CV181.1 14.99,88.07 RV123.2 15.88,87.99 15.88,87.45 v2(15.57,87.14) ; v2(66.48,6.07) 66.48,5.76 66.83,5.41 67.73,5.41 68.05,5.09 UH8.4 ; v2(178.79,88.17) 178.41,88.17 177.01,89.57 RH469.2 ; CT54.2 CT53.2 20.51,41.06 v2(21.09,41.64) ; JFAN2.6 v2(319.2,42.06) ; v2(103.01,21.84) 102.76,21.59 CH179.2 ; v2(73.69,11.7) 73.5,11.88 RH538.2 ; CV575.2 223.85,58.59 223.72,58.72 v2(223.62,58.72) ; PQ206.3 24.43,98.15 24.16,97.88 v2(23.78,97.88) ; PR1106.1 108.59,107.2 108.14,106.75 v2(108.01,106.75) 108.52,106.24 PC1105.1 ; v2(127.94,84.35) 128.42,83.88 RH475.2 ; PC607.1 v2(286.58,25.41) ; CT146.2 13.83,41.88 v2(13.89,41.94) ; v2(104.14,66.04) 104.7,65.48 PC813.2 ; RV300.2 v2(214.87,61.02) ; v2(303,29.56) 302.8,29.37 JLPDE1.12 ; v2(10.65,62.74) 10.65,62.84 9.48,64.02 8.18,64.02 CT122.2 ; RT191.2 14.78,37.35 RT190.2 14.05,37.75 v2(13.63,38.17) ; v2(112.1,3.74) 112.1,4.33 v1(111.68,4.75) 111.34,5.09 v2(110.78,5.09) 110.65,4.96 CH199.2 110.12,4.78 109.41,4.07 CH198.2 ; PC1227.1 v2(137.05,112.91) ; CZ26.2 v2(344.89,44.55) ; v2(304.51,29.61) 304.52,29.61 JDEG1.11 ; RV378.1 233.16,70.43 v2(233.81,70.43) ; PQ222.3 25.92,95.38 26.23,95.68 v2(26.61,95.68) ; CR11.2 v2(340.49,34.17) ; JUART.6 v2(102.02,48.88) ; CR3.2 331.6,41.39 331.09,41.9 330.43,41.9 v2(330.36,41.97) ; RH57.1 131.79,74.4 v1(132.16,74.04) v2(132.86,74.04) ; v2(214.67,8.48) 214.67,8.68 JTP.9 ; CE81.2 CE82.2 166.07,10.16 v2(165.99,10.23) ; CI4.2 314.55,29.73 v2(314.26,30.02) ; JEDP1.44 67.49,30.13 68.04,30.68 v2(68.04,31.71) ; v2(244.58,98.88) 244.58,99.64 244.96,100.02 RV391.1 ; v2(104.45,51.48) 104.31,51.35 JUART.4 ; DI3.1 333.88,46.68 v2(334.44,46.12) ; PC1249.1 154.36,118.86 153.93,118.42 v2(153.93,118.25) ; RH556.1 70.09,9.26 69.5,9.85 v2(69.5,10) ; PR512.2 133.44,2.05 v2(133.95,1.55) ; PC1234.2 v2(151.37,116.91) ; JTS.8 335.09,51.13 v2(335.09,51.13) ; PC1119.2 112.5,101.51 v2(112.5,101.37) ; RI11.2 RI12.2 336.4,61.05 v2(336.45,61.05) ; v2(324.91,34.02) 324.52,34.02 CI3.2 ; H25.1 v2(108.96,54.55) ; PC213.2 PR250.1 ; PQ205.3 21.48,99.69 20.7,100.47 v2(20.7,100.57) ; v2(347.18,44.03) 346.71,44.03 RZ39.2 ; v2(224.6,57.54) 224.6,57.23 YV1.4 ; JHDD.24 237.74,6.58 v2(237.57,6.75) ; CR18.2 v2(349.57,47.06) ; CR16.2 336.82,40.41 v2(338.53,40.41) ; v2(313.37,29.6) 313.22,29.44 JDEG1.12 ; PH1104.1 143.78,103.51 v2(144.34,102.96) ; v2(317.29,27.09) 317.5,27.3 RI25.2 ; v2(227.97,7.63) 228.87,8.53 JHDD.21 ; PC1370.2 124.3,90.5 v2(124.69,90.1) ; CH175.2 121.81,94.55 CH3.2 121.71,94.65 v2(120.96,94.65) ; v2(248.39,62.95) 248.37,62.96 248.37,63.66 RV380.1 ; JNGFF2.69 v2(263.65,2.94) ; PC610.2 290.13,25.15 289.94,25.15 289.33,24.55 287.68,24.55 v2(287.56,24.43) ; H52.1 203.58,117 v2(204.19,117.61) ; v2(120.98,91.1) 121.58,90.5 PC1366.2 ; v2(230.86,7.76) 232.03,6.58 JHDD.23 ; v2(199.12,113.99) 199.39,114.26 RV365.1 ; v2(327.7,29.32) 327.7,30.2 CR5.2 329.26,30.54 329.79,31.07 RR6.1 ; v2(51.03,10.8) 50.61,11.22 PC306.2 ; RV363.1 200.2,97.74 v2(200.01,97.93) ; CV685.2 197.35,99.06 v2(196.25,100.16) ; DV12.2 v2(59.12,26.58) ; PQ211.3 23.38,91.9 v2(22.92,91.44) 23.5,90.86 23.5,90 23.24,89.75 PR217.2 ; PC614.2 v2(293.43,30.23) ; RV341.2 RV352.1 220.08,97.3 220.7,97.93 220.7,99.79 220.69,99.8 v2(220.69,100.16) ; PC113.2 59.23,17.66 59.23,19.19 PQ103.3 60.2,20.03 60.5,19.72 v2(60.5,19.4) ; PC900.2 v2(220.16,55.74) ; RH166.1 132.49,79.38 v2(132.95,79.84) ; PC1011.2 v2(167.32,101.55) ; JFAN1.6 v2(94.6,36.2) ; JEDP1.42 75.03,30.7 75.68,31.36 v2(75.68,31.69) ; CV180.1 v2(14.94,89.68) ; CR2.2 326.63,36.08 v2(326.63,35.86) ; RV290.2 193.28,95.5 v2(192.6,94.81) ; RV389.1 233.22,93.72 v2(234.97,93.72) ; RV324.2 193.55,61.38 v2(194.41,62.24) RV323.2 ; v2(52.59,26.44) 52.59,25.66 CV169.2 53.1,25.15 QV12.3 ; CR12.2 341.57,34.55 v2(341.25,34.24) ; PQ232.3 28.15,98.06 v2(28.39,97.82) ; JFAN1.5 v2(93.33,39.5) ; PQ227.3 6.79,15.89 6.79,16.22 7.06,16.49 7.52,16.49 8.15,17.12 v2(8.31,17.12) ; JNGFF1.69 347.7,85.15 v2(347.05,85.15) ; v2(244.86,6.77) 244.86,7.82 244.15,8.53 JHDD.22 ; v2(238.51,14.04) CS13.2 CS14.2 CS12.2 236.73,13.51 v2(236.18,14.06) ; RV209.2 211.98,60.41 RV299.2 v2(211.99,61.12) ; PR265.1 13.32,22.88 12.68,23.53 v2(12.68,23.91) ; H58.1 125.76,118.1 124.72,119.14 v2(124.72,119.9) ; YV1.2 222.61,53.7 v2(223.93,53.7) ; v2(53.85,24.14) 54.23,23.76 RV135.2 ; PC611.2 v2(262.05,26.04) ; CH178.2 102.16,18.78 101.8,18.78 v2(101.42,19.16) ; PQ228.3 8.08,24.78 7.82,24.52 v2(7.82,24.1) ; PR1005.2 162.73,104.56 v2(163.2,104.09) 163.7,103.58 PC1009.2 ; PC512.2 v2(137.03,3.31) ; v2(104.23,69.97) 104.06,69.97 103.68,70.35 PC1336.1 ; v2(185.46,82.7) 184.91,82.15 CZ82.2 ; RV316.1 v2(220.16,56.64) ; PR607.2 v2(293.54,32.1) ; PC1046.1 v2(162.69,112.59) ; v2(167.11,3.51) 167.99,4.39 JAPS.20 ; PH1100.1 v2(104.27,84.86) ; v2(136.95,107.45) PC1200.1 ; CR17.2 v2(349.57,45.86)
  vias: v1(28.02,57.32) v1(78.49,32.19) v1(85.44,34.02) v1(117.29,56.9) v1(118.26,57.48) v1(119.2,3.15) v1(129.59,10.74) v1(130.3,9.01) v1(132.79,10.75) v1(144.02,108.43) v1(156.03,112.91) v1(171.84,45.53) v1(171.9,50.02) v1(209.09,117.97) v1(212.7,117.06) v1(214.33,118.06) v1(216.23,117.06) v1(241.87,44.83) v1(243.8,12.39) v1(248.01,59.81) v2(0.51,18.6) v2(1.4,93.66) v2(1.42,73.08) v2(1.41,41.41) v2(1.41,34.04) v2(1.41,26.93) v2(1.41,11.29) v2(1.41,4.43) v2(1.65,1.58) v2(1.9,110.76) v2(2.39,2.75) v2(2.54,43.44) v2(2.54,42.55) v2(2.54,41.66) v2(2.54,40.78) v2(2.73,75.57) v2(2.69,25.56) v2(2.72,21.65) v2(2.97,9.76) v2(3.05,6.13) v2(3.11,112.49) v2(3.68,3.26) v2(3.76,25.82) v2(3.84,21.47) v2(4.04,13.47) v2(3.99,10.02) v2(4.07,5.9) v2(4.18,18.48) v2(4.62,18.88) v2(4.72,58.46) v2(4.67,13.47) v2(4.8,25.49) v2(5,21.73) v2(5.08,9.69) v2(5.08,6.23) v2(5.3,112.49) v2(5.27,67.04) v2(5.26,64.56) v2(5.31,2.63) v2(5.63,95.64) v2(5.92,92.29) v2(5.87,1.18) v2(6.03,75.57) v2(6.15,13.51) v2(6.4,0.52) v2(6.74,13.52) v2(6.81,110.74) v2(7.33,37.58) v2(7.42,39.42) v2(7.96,45.29) v2(8.45,11.94) v2(8.45,0.51) v2(8.59,92.29) v2(8.84,61.15) v2(8.97,33.57) v2(9.23,32.63) v2(9.45,95.67) v2(9.41,36.41) v2(9.52,110.76) v2(9.53,75.07) v2(9.8,58.46) v2(10.06,89.44) v2(10.06,78.11) v2(10.1,38.82) v2(10.23,73.65) v2(10.23,71.9) v2(10.19,71.2) v2(10.19,69.41) v2(10.59,61.15) v2(12.24,74.89) v2(12.24,73.95) v2(12.34,58.46) v2(13.11,95.74) v2(13.21,107.01) v2(13.21,104.09) v2(13.21,101.46) v2(13.21,98.21) v2(13.23,89.49) v2(13.79,31.91) v2(14.17,64.93) v2(14.16,10.74) v2(14.23,9.98) v2(14.24,9.31) v2(14.23,8.72) v2(14.8,10.74) v2(14.89,58.42) v2(14.92,10.04) v2(14.87,9.31) v2(14.86,8.72) v2(15.5,10.74) v2(15.55,9.48) v2(15.55,8.9) v2(15.63,56.09) v2(15.63,53.55) v2(15.56,45.93) v2(15.56,10.11) v2(15.56,8.3) v2(15.69,111.83) v2(15.69,94.56) v2(15.95,64.93) v2(16.13,10.74) v2(16.07,0.51) v2(16.22,10.09) v2(16.18,9.48) v2(16.18,8.9) v2(16.18,8.3) v2(16.69,38.08) v2(16.77,10.74) v2(16.82,10.12) v2(16.82,9.48) v2(16.82,8.9) v2(16.83,8.31) v2(17.28,38.08) v2(17.27,37.46) v2(17.27,35.78) v2(17.27,30.23) v2(18.66,37.64) v2(19.51,105.19) v2(19.5,51.09) v2(19.52,50.5) v2(19.56,110.46) v2(20.21,110.46) v2(20.91,110.46) v2(20.87,24.74) v2(21.11,46.12) v2(21.25,85.33) v2(21.2,83.56) v2(21.21,81.42) v2(21.21,79.51) v2(21.33,87.1) v2(21.27,46.74) v2(21.3,25.13) v2(21.53,45.71) v2(22.82,39.04) v2(22.84,37.74) v2(23.32,96.2) v2(23.46,41.64) v2(23.46,40.34) v2(23.46,39.69) v2(23.46,39.04) v2(23.74,105.39) v2(23.71,84.48) v2(23.69,0.51) v2(23.76,103.64) v2(23.78,101.88) v2(23.78,100.44) v2(23.78,98.59) v2(24.11,41.64) v2(24.11,37.74) v2(24.65,50.98) v2(25.4,95.7) v2(25.41,40.34) v2(25.46,107.45) v2(25.64,90.97) v2(26.06,43.61) v2(26.06,37.09) v2(26.33,50.74) v2(26.36,49.14) v2(26.54,92.85) v2(26.62,112.48) v2(26.82,79.76) v2(27.18,105.55) v2(27.36,81.48) v2(27.42,79.76) v2(27.43,49.16) v2(27.36,40.99) v2(27.8,75.61) v2(27.94,106.94) v2(27.94,104.02) v2(27.94,81.47) v2(27.89,59.04) v2(27.97,80.86) v2(27.95,80.26) v2(27.97,79.55) v2(27.99,73.84) v2(28.01,42.29) v2(28.06,59.94) v2(28.17,58.33) v2(28.27,75.99) v2(28.35,59.42) v2(28.45,77.99) v2(28.48,81.73) v2(28.48,81.14) v2(28.48,80.56) v2(28.47,79.94) v2(28.46,79.22) v2(28.5,58.85) v2(28.63,57.95) v2(28.78,59.88) v2(28.93,59.27) v2(28.9,49.47) v2(29.05,58.62) v2(28.97,57.44) v2(29.13,17.01) v2(29.21,57.98) v2(29.22,32.02) v2(29.34,107.32) v2(29.29,66.33) v2(29.31,42.29) v2(29.34,16.2) v2(29.37,111.58) v2(29.43,62.68) v2(29.49,108.62) v2(29.47,103.77) v2(29.49,102.18) v2(29.49,96.55) v2(29.49,88.93) v2(29.49,81.31) v2(29.47,57.01) v2(29.63,49.48) v2(29.66,56.4) v2(29.72,17.01) v2(29.94,40.34) v2(29.92,16.2) v2(30.06,58.75) v2(30.24,32.16) v2(30.3,17.01) v2(30.51,16.2) v2(30.82,55.94) v2(31.29,21.33) v2(31.31,0.51) v2(31.55,32.13) v2(31.88,53.15) v2(31.88,21.33) v2(33.07,50.76) v2(33.8,49.4) v2(35.29,18.92) v2(35.29,18.33) v2(35.29,17.75) v2(35.29,17.17) v2(36.13,46.03) v2(37.2,42.25) v2(38.57,40.24) v2(38.89,0.5) v2(41.16,39.04) v2(41.44,40.69) v2(42.61,21.03) v2(43.19,21.03) v2(44.32,21.09) v2(44.91,21.09) v2(46.46,0.51) v2(47.18,35.7) v2(47.7,27.07) v2(48.2,34.07) v2(48.81,5.66) v2(48.9,4.07) v2(48.9,3.49) v2(49.2,34.29) v2(49.39,5.66) v2(49.48,4.07) v2(49.48,3.49) v2(49.94,1.74) v2(49.98,5.66) v2(50.06,4.07) v2(50.06,3.49) v2(50.12,2.88) v2(50.12,2.29) v2(50.52,1.74) v2(50.56,5.66) v2(50.65,4.07) v2(50.65,3.49) v2(50.7,2.88) v2(50.7,2.29) v2(51.14,5.66) v2(51.11,1.74) v2(51.23,4.07) v2(51.23,3.49) v2(51.28,2.88) v2(51.28,2.29) v2(51.69,1.74) v2(51.82,4.07) v2(51.82,3.49) v2(51.87,2.88) v2(51.87,2.29) v2(53.01,19.49) v2(54.08,0.51) v2(54.26,1.74) v2(54.52,34.57) v2(56.83,4.01) v2(59.28,11.5) v2(61.63,1.56) v2(61.79,20.87) v2(62.3,33.89) v2(63.31,16.3) v2(63.7,20.86) v2(64.58,14.59) v2(65.57,16.23) v2(65.71,8.57) v2(66.51,21.4) v2(69.05,21.4) v2(69.17,0.51) v2(69.92,33.89) v2(70.93,21.38) v2(74.04,22.6) v2(76.29,31.82) v2(76.85,26.08) v2(76.79,0.51) v2(76.88,31.82) v2(77.45,26.12) v2(77.51,34.57) v2(77.47,31.84) v2(77.85,3.34) v2(79.88,24.77) v2(80.27,23.16) v2(83.36,35.19) v2(83.85,35.52) v2(84.41,0.51) v2(84.72,37.04) v2(85.81,16.09) v2(85.81,15.32) v2(85.81,14.54) v2(85.81,12.22) v2(86.58,16.09) v2(86.58,12.22) v2(87.33,24.72) v2(87.29,10.18) v2(87.36,16.87) v2(87.36,12.22) v2(88.13,16.87) v2(88.71,6.17) v2(88.91,16.87) v2(88.91,16.09) v2(88.91,15.32) v2(88.91,14.54) v2(89.74,24.7) v2(89.68,16.87) v2(89.68,16.09) v2(89.68,15.32) v2(89.68,14.54) v2(90.46,12.22) v2(91.13,41.16) v2(91.23,17.64) v2(92.03,0.51) v2(92.14,26.74) v2(93.42,27.03) v2(93.96,26.72) v2(94.21,24.72) v2(95.02,27.15) v2(95.39,23.54) v2(96.18,46.54) v2(97.18,47.89) v2(97.18,24.75) v2(97.4,27.26) v2(98.32,24.76) v2(98.5,50.02) v2(98.87,24.2) v2(99.54,31.97) v2(99.65,0.51) v2(100,5.32) v2(100.11,53.34) v2(100.59,5.38) v2(100.81,24.79) v2(101.51,57.57) v2(102.05,33.4) v2(102.25,32.39) v2(102.51,96.23) v2(102.51,93.69) v2(102.51,78.45) v2(102.51,75.91) v2(102.51,73.37) v2(102.51,70.83) v2(103.67,33.14) v2(104.01,118.94) v2(104.01,116.4) v2(104.01,113.86) v2(104.01,111.32) v2(104.01,108.78) v2(104.01,106.24) v2(104.01,103.7) v2(104.01,101.16) v2(104.01,98.62) v2(104.65,93.04) v2(105.64,117.52) v2(105.91,121.24) v2(106.36,36.92) v2(107.05,119.82) v2(107.01,72.78) v2(107.02,36.92) v2(107.09,74.89) v2(107.09,74.28) v2(107.06,73.62) v2(107.34,24.46) v2(107.27,0.51) v2(107.61,76.65) v2(107.61,75.95) v2(107.62,72.78) v2(107.61,36.92) v2(107.72,80.35) v2(107.67,74.91) v2(107.75,74.3) v2(107.72,73.59) v2(107.82,82.5) v2(107.85,81.9) v2(107.82,81.24) v2(107.76,78.75) v2(107.82,71.21) v2(107.82,70.62) v2(107.95,58.05) v2(107.95,57.41) v2(107.95,56.78) v2(108.21,85.35) v2(108.21,84.72) v2(108.27,74.94) v2(108.33,74.25) v2(108.33,73.59) v2(108.26,72.81) v2(108.28,72.2) v2(108.33,59.38) v2(108.41,82.54) v2(108.36,80.32) v2(108.46,81.87) v2(108.48,81.26) v2(108.5,78.71) v2(108.46,71.21) v2(108.46,70.62) v2(108.66,23.82) v2(108.98,121.24) v2(109.03,117.99) v2(109.03,84.08) v2(109.03,83.45) v2(109.01,82.55) v2(109.04,80.1) v2(109.03,59.66) v2(109.03,59.06) v2(109.03,58.48) v2(109.07,81.87) v2(109.07,81.29) v2(109.07,80.68) v2(109.13,78.74) v2(109.14,78.14) v2(109.07,71.21) v2(109.07,70.62) v2(109.17,77.54) v2(109.17,76.93) v2(109.17,76.3) v2(109.17,75.66) v2(109.56,59.32) v2(109.6,57.73) v2(109.67,71.21) v2(109.67,70.62) v2(109.83,96.14) v2(109.83,95.53) v2(109.83,94.87) v2(109.77,78.74) v2(109.78,78.14) v2(109.81,77.54) v2(109.81,76.93) v2(109.81,76.3) v2(109.81,75.66) v2(109.86,85.8) v2(109.86,85.16) v2(109.86,84.53) v2(109.86,83.89) v2(109.86,83.26) v2(110.05,59.67) v2(110.24,57.73) v2(110.18,23.5) v2(110.18,22.23) v2(110.46,96.14) v2(110.46,95.53) v2(110.46,94.87) v2(110.49,85.8) v2(110.49,85.16) v2(110.49,84.53) v2(110.49,83.89) v2(110.49,83.26) v2(110.59,119.71) v2(110.59,94.23) v2(110.59,93.6) v2(110.59,92.96) v2(111.1,96.14) v2(111.1,95.53) v2(111.1,94.87) v2(111.13,85.8) v2(111.13,85.19) v2(111.13,84.58) v2(111.29,94.23) v2(111.29,93.6) v2(111.29,92.96) v2(111.73,96.14) v2(111.73,95.53) v2(111.7,94.78) v2(111.76,85.8) v2(111.76,85.19) v2(111.76,84.58) v2(111.92,94.23) v2(111.92,93.6) v2(112.17,95.13) v2(112.42,23.63) v2(112.42,22.36) v2(112.61,117.62) v2(113.29,79.07) v2(113.29,78.43) v2(113.29,77.8) v2(113.29,77.16) v2(113.29,76.53) v2(113.29,75.89) v2(113.29,75.26) v2(113.92,79.07) v2(113.92,78.43) v2(113.92,77.8) v2(113.92,77.16) v2(113.92,76.53) v2(113.92,75.89) v2(113.92,75.26) v2(114.37,22.67) v2(114.37,20.77) v2(114.56,79.07) v2(114.56,78.43) v2(114.56,77.8) v2(114.56,77.16) v2(114.56,76.53) v2(114.56,75.89) v2(114.56,75.26) v2(114.62,56.46) v2(114.89,0.51) v2(115.09,117.51) v2(115.06,56.84) v2(115.19,59.79) v2(115.19,59.2) v2(115.19,58.62) v2(115.19,58.02) v2(115.19,57.41) v2(115.64,23.63) v2(115.64,22.36) v2(115.64,21.09) v2(115.83,59.79) v2(115.83,58.07) v2(115.83,57.49) v2(115.92,107.25) v2(115.92,105.85) v2(115.92,104.39) v2(115.99,85.4) v2(116.27,92.08) v2(116.52,93.54) v2(116.62,85.4) v2(116.94,118.22) v2(116.9,92.08) v2(117.15,116.58) v2(117.19,107.25) v2(117.19,105.85) v2(117.19,104.39) v2(117.16,93.54) v2(117.26,85.4) v2(117.54,92.08) v2(117.93,119.95) v2(117.89,85.4) v2(118.03,54.54) v2(118,23.5) v2(118,22.23) v2(118,20.96) v2(118.17,92.08) v2(118.53,107.25) v2(118.53,105.85) v2(118.53,104.39) v2(119.08,118.7) v2(119.27,23.82) v2(119.27,3.78) v2(119.89,120.02) v2(119.89,116.98) v2(119.86,3.78) v2(120.21,68.27) v2(120.21,67.64) v2(120.21,67) v2(120.46,3.78) v2(120.75,23.5) v2(120.75,22.23) v2(120.75,20.96) v2(120.65,3.18) v2(120.84,68.91) v2(120.84,68.27) v2(121.03,120.35) v2(120.96,116.65) v2(121.1,3.78) v2(121.29,3.18) v2(121.73,3.78) v2(121.86,4.42) v2(121.92,3.18) v2(122.12,116.98) v2(122.18,120.02) v2(122.37,3.78) v2(122.49,4.42) v2(122.51,0.51) v2(122.56,3.18) v2(123.16,23.5) v2(123.16,22.23) v2(123.16,20.96) v2(124.43,22.55) v2(124.43,20.64) v2(126.41,23.5) v2(126.41,22.23) v2(126.41,20.96) v2(126.7,62.29) v2(126.82,57.74) v2(126.94,121.24) v2(127.69,62.54) v2(127.81,57.54) v2(128.59,116.09) v2(128.78,57.77) v2(128.84,9.9) v2(128.91,62.29) v2(129.22,116.09) v2(129.43,9.91) v2(129.86,116.09) v2(130.01,9.9) v2(130.13,0.51) v2(130.49,116.09) v2(130.6,9.9) v2(130.68,121.22) v2(130.84,7.81) v2(131.13,116.09) v2(131.19,9.9) v2(131.43,7.81) v2(131.73,28.61) v2(131.79,9.9) v2(132.03,7.81) v2(132.39,9.9) v2(132.69,67.45) v2(133.03,116.09) v2(133,9.9) v2(133.63,9.9) v2(133.67,116.09) v2(133.93,23.75) v2(133.93,22.43) v2(133.93,21.14) v2(133.93,19.9) v2(134.3,116.09) v2(134.75,71.66) v2(134.77,79.39) v2(134.77,75.64) v2(134.94,116.09) v2(135.28,65.59) v2(135.41,78) v2(135.38,74.04) v2(135.37,60.46) v2(135.57,116.09) v2(135.63,59.45) v2(135.57,54.82) v2(135.57,54.18) v2(135.57,53.55) v2(135.57,52.91) v2(135.57,52.3) v2(135.78,23.4) v2(135.78,22.11) v2(135.78,20.74) v2(136.02,64.31) v2(136.68,79.39) v2(136.68,75.64) v2(136.87,56.38) v2(137.69,105.27) v2(137.77,100.9) v2(137.84,23.54) v2(137.82,22.16) v2(137.75,0.51) v2(137.86,20.94) v2(138.09,57.65) v2(138.41,55.12) v2(138.41,54.37) v2(138.41,53.73) v2(138.41,53.1) v2(138.41,52.46) v2(138.41,51.88) v2(138.89,105.6) v2(139.09,100.62) v2(139.48,58.77) v2(139.64,121.27) v2(139.82,56.31) v2(140.08,105.29) v2(140.08,23.59) v2(140.08,22.32) v2(140.08,21.08) v2(140.23,101) v2(141.22,113.36) v2(141.17,57.66) v2(141.34,115.92) v2(141.34,115.34) v2(141.29,110.5) v2(141.26,109.89) v2(141.26,109.29) v2(141.35,116.57) v2(141.76,117.65) v2(141.92,119.19) v2(141.95,115.34) v2(141.9,110.5) v2(141.9,109.89) v2(141.89,109.29) v2(141.99,118.6) v2(141.99,116.57) v2(141.97,115.92) v2(142.18,121.24) v2(142.22,118.05) v2(142.19,55.96) v2(142.3,24.16) v2(142.3,22.25) v2(142.42,107.4) v2(142.53,113.8) v2(142.49,110.5) v2(142.53,109.89) v2(142.49,109.29) v2(142.56,119.19) v2(142.62,118.6) v2(142.62,116.57) v2(142.61,115.92) v2(142.58,115.34) v2(142.74,117.69) v2(142.67,6.38) v2(142.77,2.63) v2(142.86,54.34) v2(142.86,53.71) v2(142.86,53.07) v2(142.86,52.44) v2(143.02,107.4) v2(143.13,113.8) v2(143.19,119.19) v2(143.26,118.6) v2(143.27,117.93) v2(143.27,117.34) v2(143.49,57.24) v2(143.74,55.79) v2(143.71,6.66) v2(143.79,113.8) v2(143.82,2.4) v2(143.89,119.19) v2(143.89,118.56) v2(143.89,117.94) v2(143.92,117.34) v2(144.4,81.48) v2(144.53,119.19) v2(144.53,118.56) v2(144.72,121.24) v2(144.8,22.61) v2(144.8,21.34) v2(144.76,6.36) v2(144.81,2.63) v2(145.16,119.19) v2(145.16,118.56) v2(145.16,81.49) v2(145.37,0.51) v2(145.8,119.19) v2(145.8,118.56) v2(146.43,119.19) v2(146.43,118.56) v2(146.54,53.67) v2(146.47,22.61) v2(146.47,21.34) v2(146.74,81.49) v2(147.07,119.19) v2(147.07,118.56) v2(147.26,121.24) v2(147.36,54.49) v2(147.5,81.5) v2(147.7,119.19) v2(147.7,118.56) v2(148.34,119.19) v2(148.34,118.56) v2(148.45,65.34) v2(148.45,64.7) v2(148.72,117.99) v2(148.97,119.19) v2(148.97,118.56) v2(149.07,81.49) v2(149.18,22.61) v2(149.18,21.34) v2(149.33,117.99) v2(149.53,55.51) v2(149.61,119.19) v2(149.61,118.56) v2(149.8,121.24) v2(149.92,117.99) v2(149.89,81.49) v2(150.05,58.56) v2(150.31,119.19) v2(150.31,118.56) v2(150.31,99.01) v2(150.31,98.37) v2(150.31,97.67) v2(150.31,97.04) v2(150.42,88.4) v2(150.56,117.99) v2(150.74,23.85) v2(150.74,22.58) v2(150.74,21.31) v2(150.95,119.19) v2(151,118.59) v2(151.26,53.64) v2(151.29,51.71) v2(151.5,81.49) v2(152.23,81.5) v2(152.34,121.24) v2(152.39,56.37) v2(152.39,54.4) v2(152.78,7.18) v2(152.85,5.85) v2(152.92,1.55) v2(153.02,66.56) v2(153.29,23.6) v2(153.29,22.33) v2(153.82,81.49) v2(154.24,114.82) v2(154.18,7.18) v2(154.59,81.48) v2(154.88,121.24) v2(154.88,114.82) v2(154.88,114.18) v2(155.07,23.92) v2(155.07,22.01) v2(155.25,52.5) v2(155.25,51.91) v2(155.25,51.33) v2(155.25,50.75) v2(155.6,113.6) v2(155.58,5.85) v2(155.74,121.23) v2(156.14,56.68) v2(156.21,113.75) v2(156.19,81.49) v2(156.16,58.57) v2(156.3,53.87) v2(156.31,52.07) v2(156.46,23.6) v2(156.46,22.33) v2(156.46,21.06) v2(156.94,81.49) v2(157.18,115.02) v2(157.2,114.41) v2(157.16,113.8) v2(157.39,57.84) v2(157.39,56.01) v2(157.5,54.12) v2(157.94,115.05) v2(157.96,114.44) v2(157.99,113.8) v2(158.62,115.02) v2(158.62,114.36) v2(158.62,113.74) v2(158.88,23.6) v2(158.88,22.33) v2(158.88,21.06) v2(159.45,114.44) v2(159.45,113.8) v2(159.45,113.17) v2(159.45,112.53) v2(159.92,56.01) v2(159.94,53.8) v2(160.08,114.44) v2(160.08,113.8) v2(160.08,113.17) v2(160.08,112.53) v2(160.32,22.65) v2(160.32,20.74) v2(160.54,1.56) v2(160.59,98.81) v2(160.59,98.18) v2(160.59,97.54) v2(160.59,96.85) v2(160.72,114.44) v2(160.72,113.8) v2(160.72,113.17) v2(160.72,112.53) v2(161.01,53.4) v2(161.42,115.77) v2(161.42,115.13) v2(161.35,114.44) v2(161.35,113.8) v2(161.35,113.17) v2(161.35,112.53) v2(161.67,98.81) v2(161.67,98.18) v2(161.67,97.54) v2(161.67,96.85) v2(161.69,81.48) v2(161.67,23.6) v2(161.67,22.33) v2(161.67,21.06) v2(161.93,115.45) v2(161.93,114.82) v2(161.86,114.12) v2(161.93,113.42) v2(162.43,57.49) v2(162.5,115.64) v2(162.5,115.01) v2(162.5,114.37) v2(162.5,113.74) v2(163.13,115.64) v2(163.13,115.01) v2(163.13,114.37) v2(163.13,113.74) v2(163.28,81.49) v2(163.3,55.69) v2(164.01,23.6) v2(164.01,22.33) v2(164.06,81.49) v2(164.24,54.22) v2(164.97,121.24) v2(164.96,57.09) v2(165.53,23.92) v2(165.53,22.01) v2(165.62,81.49) v2(165.86,76.34) v2(165.86,75.7) v2(165.86,75.07) v2(165.86,74.43) v2(166.11,117.21) v2(166.31,55.74) v2(166.43,81.5) v2(166.7,65.27) v2(167.06,22.33) v2(167.15,108.35) v2(167.22,106.89) v2(167.34,95.39) v2(167.6,54.44) v2(167.85,107.65) v2(167.94,95.39) v2(168.03,81.5) v2(168.15,99.32) v2(168.15,98.69) v2(168.15,98.05) v2(168.15,97.42) v2(168.16,1.56) v2(168.42,108.35) v2(168.37,57.43) v2(168.49,106.89) v2(169.38,95.39) v2(169.47,22.33) v2(169.47,21.06) v2(169.65,56.18) v2(170.05,95.39) v2(171,48.9) v2(171,48.26) v2(171.01,47.57) v2(171.25,22.65) v2(171.25,20.74) v2(171.33,57.61) v2(171.39,98.55) v2(171.39,97.91) v2(171.39,97.28) v2(171.39,96.64) v2(171.59,48.4) v2(171.59,47.82) v2(171.6,47.21) v2(172.64,23.6) v2(172.64,22.33) v2(172.68,56.26) v2(173.04,97.48) v2(173.08,121.24) v2(175.36,4.29) v2(175.62,121.24) v2(175.78,1.56) v2(175.98,27.76) v2(176.29,27.25) v2(176.59,27.76) v2(176.85,30.18) v2(176.98,105.55) v2(176.98,104.91) v2(177.04,95.67) v2(177.04,95.07) v2(177.1,118.37) v2(177.1,117.74) v2(177.1,117.1) v2(177.36,102.56) v2(177.36,101.93) v2(177.36,100.02) v2(177.36,98.81) v2(177.55,110.12) v2(177.55,109.48) v2(177.55,107.58) v2(177.47,98.21) v2(177.61,106.43) v2(177.74,118.37) v2(177.74,117.74) v2(177.74,117.1) v2(177.67,95.67) v2(177.67,95.07) v2(177.8,114.82) v2(177.93,99.01) v2(177.9,97.65) v2(177.99,102.56) v2(177.99,101.93) v2(177.99,100.02) v2(178.12,112.72) v2(178.12,112.09) v2(178.08,98.26) v2(178.16,121.24) v2(178.18,110.12) v2(178.18,109.48) v2(178.18,107.58) v2(178.25,106.43) v2(178.37,118.37) v2(178.37,117.74) v2(178.37,117.1) v2(178.44,114.82) v2(178.63,102.56) v2(178.63,101.93) v2(178.63,100.02) v2(178.56,98.88) v2(178.61,97.67) v2(178.69,105.93) v2(178.69,105.29) v2(178.69,104.66) v2(178.69,98.26) v2(178.75,112.72) v2(178.75,112.09) v2(178.82,110.12) v2(178.82,109.48) v2(178.82,107.58) v2(178.94,115.39) v2(179.01,118.37) v2(179.01,117.74) v2(179.01,117.1) v2(179.07,114.82) v2(179.32,105.93) v2(179.32,105.29) v2(179.32,104.66) v2(179.26,102.56) v2(179.26,101.93) v2(179.26,100.02) v2(179.39,112.72) v2(179.39,112.09) v2(179.45,110.12) v2(179.45,109.48) v2(179.45,107.58) v2(179.64,118.37) v2(179.64,117.74) v2(179.64,117.1) v2(179.71,114.82) v2(179.88,95.31) v2(179.88,94.7) v2(179.88,94.12) v2(180.02,112.72) v2(180.02,112.09) v2(179.96,105.93) v2(179.96,105.29) v2(179.96,104.66) v2(180.28,121.24) v2(180.32,98.88) v2(180.32,98.24) v2(180.32,97.61) v2(180.32,96.97) v2(180.32,96.34) v2(180.59,105.93) v2(180.59,105.29) v2(180.59,104.66) v2(180.66,112.72) v2(180.66,112.09) v2(181.18,105.93) v2(181.23,105.29) v2(181.23,104.66) v2(181.29,112.72) v2(181.29,112.09) v2(181.76,105.9) v2(181.93,112.72) v2(181.93,112.09) v2(181.86,105.29) v2(181.86,104.66) v2(182.54,56.32) v2(182.56,112.72) v2(182.56,112.09) v2(182.8,54.11) v2(183.28,24.17) v2(183.4,1.56) v2(183.81,53.44) v2(184.62,53.44) v2(185.23,23.84) v2(185.23,21.94) v2(185.6,69.4) v2(186.31,59.42) v2(186.54,55.15) v2(186.64,94.19) v2(186.64,89.75) v2(187.01,23.53) v2(187.01,22.26) v2(187.01,20.99) v2(187.83,94.52) v2(187.78,89.52) v2(187.76,54.82) v2(187.86,59.88) v2(188.93,121.22) v2(188.9,89.77) v2(189.03,72.86) v2(189.1,94.07) v2(189.05,55.2) v2(189.33,59.34) v2(189.42,23.53) v2(189.42,22.26) v2(189.42,20.99) v2(190.89,22.57) v2(190.89,20.67) v2(190.96,53.37) v2(191.02,1.56) v2(191.47,121.22) v2(192.57,23.53) v2(192.57,22.26) v2(192.57,20.99) v2(194.01,121.22) v2(194.93,23.53) v2(194.93,22.26) v2(194.93,20.99) v2(195.52,121.24) v2(196.57,94.18) v2(196.61,23.84) v2(196.61,21.94) v2(197.87,117.74) v2(197.87,117.1) v2(197.87,116.47) v2(197.87,115.83) v2(197.87,115.2) v2(198.06,121.24) v2(198.43,92.62) v2(198.5,117.74) v2(198.5,117.1) v2(198.5,116.47) v2(198.5,115.83) v2(198.5,115.2) v2(198.61,23.53) v2(198.61,22.26) v2(198.61,20.99) v2(198.64,1.56) v2(198.93,93.58) v2(200.24,108.96) v2(200.6,121.24) v2(200.6,71.7) v2(201,23.53) v2(201,22.26) v2(201,20.99) v2(201.4,80.95) v2(201.42,75.04) v2(201.4,73.36) v2(202.65,23.21) v2(202.65,22.57) v2(202.69,94.18) v2(203.14,121.24) v2(203.75,78.45) v2(204.47,6.23) v2(204.7,77.52) v2(204.68,23.53) v2(204.75,115.99) v2(205.68,121.24) v2(206.19,0.51) v2(206.8,97.53) v2(206.93,6.21) v2(206.97,95.44) v2(207.06,2.75) v2(208.03,28.19) v2(208.13,107.64) v2(208.13,107.06) v2(208.22,121.24) v2(208.29,115.92) v2(208.26,6.64) v2(208.43,2.42) v2(209.65,6.18) v2(209.65,2.83) v2(210.06,53.41) v2(210.23,23.48) v2(210.23,22.19) v2(210.23,20.82) v2(210.2,16.86) v2(210.41,52.93) v2(210.76,121.24) v2(210.76,53.41) v2(211.65,115.88) v2(211.66,52.94) v2(212.08,23.4) v2(212.27,52.93) v2(212.92,52.97) v2(213.3,121.24) v2(213.55,52.97) v2(213.67,93.29) v2(213.78,96.15) v2(213.81,0.51) v2(214.14,23.54) v2(214.12,22.16) v2(214.21,94.67) v2(214.25,52.97) v2(214.16,20.89) v2(214.86,87.62) v2(214.95,52.97) v2(215.32,115.85) v2(215.58,52.97) v2(215.84,121.24) v2(216.09,55.74) v2(216.22,52.97) v2(216.38,23.59) v2(216.38,22.32) v2(216.38,21.08) v2(217.45,92.82) v2(218.15,24.16) v2(218.15,22.25) v2(218.19,94.55) v2(218.38,121.24) v2(218.82,115.85) v2(219.75,70.11) v2(220.75,23.38) v2(220.72,21.84) v2(220.92,121.24) v2(221.43,0.51) v2(221.46,70.01) v2(221.69,94.01) v2(222.11,115.92) v2(222.21,92.57) v2(222.65,20.75) v2(222.65,23.58) v2(222.65,22.21) v2(223.46,121.24) v2(224.99,115.88) v2(225.02,20.75) v2(225.21,98.99) v2(226,121.24) v2(226.26,24.08) v2(226.26,22.55) v2(227,94.22) v2(227,93.59) v2(227,92.94) v2(227.94,108.14) v2(227.94,104.4) v2(227.98,79.27) v2(228.51,121.26) v2(228.83,23.57) v2(228.83,22.3) v2(228.83,21.03) v2(229.05,0.51) v2(229.07,78.43) v2(229.26,92.53) v2(229.36,103.92) v2(229.46,108.59) v2(229.64,72.87) v2(229.74,51.48) v2(229.77,116.93) v2(229.95,120.2) v2(230.02,76.22) v2(230.6,23.89) v2(230.6,21.98) v2(230.89,108.01) v2(230.86,104.48) v2(230.96,116.57) v2(231.08,120.4) v2(231.1,76.51) v2(231.33,60.59) v2(231.36,67.23) v2(231.56,52.96) v2(232.21,120.15) v2(232.23,116.98) v2(232.18,78.93) v2(232.37,23.59) v2(232.37,22.32) v2(232.37,21.05) v2(232.44,14.07) v2(233.1,79.84) v2(233.99,120.4) v2(234.42,118.97) v2(234.35,14.04) v2(234.53,116.63) v2(234.67,54.75) v2(234.66,23.59) v2(234.66,22.32) v2(234.66,21.05) v2(234.77,58.68) v2(235.6,50.2) v2(235.99,54.42) v2(236.07,58.99) v2(236.23,50.2) v2(236.28,117.59) v2(236.44,22.63) v2(236.44,20.73) v2(236.67,0.51) v2(236.79,50.78) v2(236.86,50.19) v2(237.21,54.85) v2(237.34,58.58) v2(237.43,50.78) v2(237.75,50.21) v2(237.89,23.59) v2(237.89,22.32) v2(237.89,21.05) v2(238.1,50.77) v2(238.42,50.2) v2(238.67,117.51) v2(238.73,50.77) v2(239.09,50.2) v2(239.37,50.75) v2(239.74,50.2) v2(239.79,9.44) v2(240,50.75) v2(240.18,23.59) v2(240.18,22.32) v2(240.18,21.05) v2(240.39,50.1) v2(240.38,49.49) v2(240.37,9.44) v2(240.73,118.48) v2(240.73,4.52) v2(240.88,45.92) v2(241,9.44) v2(241.64,121.09) v2(241.58,9.44) v2(241.7,23.9) v2(241.7,22) v2(242,45.93) v2(242.16,9.44) v2(242.32,116.98) v2(242.44,4.52) v2(242.57,50.94) v2(242.84,119.59) v2(242.76,45.92) v2(243.08,51.44) v2(243.08,50.43) v2(243.28,114.16) v2(243.49,121.24) v2(243.48,23.59) v2(243.48,22.32) v2(243.59,50.94) v2(243.59,0.49) v2(243.84,45.16) v2(244.1,51.44) v2(244.1,50.43) v2(244.6,50.94) v2(244.98,45.67) v2(245.77,23.59) v2(245.77,22.32) v2(245.77,21.05) v2(246.03,121.26) v2(246.18,117) v2(246.41,119.59) v2(246.38,62.71) v2(246.38,62.11) v2(246.38,61.5) v2(246.38,60.91) v2(246.61,1.28) v2(246.69,0.49) v2(246.86,2.55) v2(247.29,22.63) v2(247.29,20.73) v2(247.89,62.47) v2(247.93,61.88) v2(247.99,120.8) v2(247.99,118.26) v2(247.99,115.72) v2(247.99,113.18) v2(247.99,110.64) v2(247.99,108.1) v2(247.99,105.56) v2(247.99,103.02) v2(247.99,100.48) v2(248.16,97.94) v2(248.16,61.34) v2(248.41,3.44) v2(248.64,62.3) v2(248.64,61.67) v2(248.76,61.08) v2(248.81,23.59) v2(248.81,22.32) v2(248.81,21.05) v2(248.85,19.72) v2(248.86,60.46) v2(248.91,59.86) v2(249.49,95.52) v2(249.49,92.98) v2(249.49,90.44) v2(249.49,87.9) v2(249.49,85.36) v2(249.49,82.82) v2(249.49,80.28) v2(249.49,77.74) v2(249.49,75.2) v2(249.49,72.66) v2(249.49,70.12) v2(249.49,67.58) v2(249.9,2.55) v2(249.96,59.97) v2(250.19,1.2) v2(251.8,1.8) v2(252.3,27.54) v2(252.32,26.9) v2(252.32,26.26) v2(254.73,16.29) v2(255.08,18.09) v2(256.07,46.13) v2(256.08,36.51) v2(256.49,36.03) v2(256.72,12.2) v2(257.05,35.77) v2(257.94,36.2) v2(258.04,42.33) v2(257.95,12.21) v2(258.17,15.16) v2(258.28,21.31) v2(258.45,18.68) v2(259.42,1.81) v2(259.46,35.82) v2(260.15,33.69) v2(260.17,34.88) v2(260.17,34.27) v2(260.76,35.09) v2(260.76,34.5) v2(261.39,36.36) v2(262.03,16.64) v2(262.67,16.65) v2(263.58,15.06) v2(264.01,38.87) v2(264.5,15.28) v2(264.69,22.86) v2(265.78,15.32) v2(267.04,1.81) v2(267.93,36.73) v2(274.26,28.84) v2(274.26,28.2) v2(274.26,27.57) v2(274.66,1.81) v2(274.85,28.84) v2(274.89,28.2) v2(274.89,27.57) v2(275.19,34.43) v2(275.53,28.2) v2(275.53,27.57) v2(276.16,28.2) v2(276.16,27.57) v2(281.43,32.46) v2(281.43,31.86) v2(282.28,1.81) v2(282.79,33.89) v2(287.21,26.74) v2(287.66,27.12) v2(287.82,30.08) v2(287.82,29.19) v2(288.29,29.6) v2(288.71,30.08) v2(288.71,29.19) v2(289.9,1.81) v2(290.41,33.89) v2(293.66,5.77) v2(297.24,17.15) v2(297.24,15.38) v2(297.24,13.6) v2(297.52,1.81) v2(297.99,34.68) v2(299.02,17.15) v2(299.02,15.38) v2(299.02,13.6) v2(300.8,17.15) v2(300.8,15.38) v2(300.8,13.6) v2(305.14,1.81) v2(305.16,37.25) v2(311.51,41.48) v2(312.76,1.81) v2(313.4,25.45) v2(314.4,22.75) v2(314.61,24.85) v2(316.65,47.1) v2(318.77,33.41) v2(318.77,31.38) v2(319.66,32.39) v2(319.84,46.82) v2(319.9,44.96) v2(319.91,38.24) v2(320.29,53.79) v2(320.38,1.81) v2(320.61,31.38) v2(320.68,33.41) v2(322.47,114.42) v2(322.47,106.8) v2(322.47,99.18) v2(322.47,91.56) v2(322.47,83.94) v2(322.47,76.32) v2(322.48,68.91) v2(322.5,61.08) v2(322.52,20.33) v2(323.09,66.76) v2(323.11,63.23) v2(323.15,20.33) v2(323.79,20.33) v2(323.88,90.66) v2(323.85,89.67) v2(323.85,88.72) v2(324.09,82.28) v2(324.11,80.46) v2(324.42,66.49) v2(324.42,20.33) v2(324.74,87.19) v2(324.74,86.56) v2(324.74,84.79) v2(324.66,63.81) v2(324.75,85.49) v2(325.12,65.01) v2(325.06,20.33) v2(325.38,9.69) v2(325.38,9.03) v2(325.38,8.42) v2(325.69,20.33) v2(326.01,37.47) v2(326.01,9.69) v2(326.01,9.03) v2(326.01,8.42) v2(326.71,80.08) v2(326.66,69.14) v2(326.67,33.71) v2(327.85,75.02) v2(328,1.81) v2(328.3,71.13) v2(328.98,58.52) v2(329.55,29.32) v2(329.76,63.25) v2(330.54,70.49) v2(332.03,69.1) v2(332.74,78.49) v2(333.06,36.9) v2(333.76,32.41) v2(333.95,35.95) v2(333.93,29.9) v2(334.37,117.56) v2(334.72,115.96) v2(334.77,36.9) v2(334.77,35.19) v2(335.03,17.41) v2(335.03,16.8) v2(335.34,114.82) v2(335.36,79.07) v2(335.62,1.76) v2(335.66,17.41) v2(335.66,16.8) v2(335.79,29.85) v2(336.04,64.27) v2(336.17,81.54) v2(336.3,17.41) v2(336.3,16.8) v2(336.81,42.69) v2(336.93,101.29) v2(336.93,17.41) v2(336.93,16.8) v2(337.57,17.41) v2(337.57,16.8) v2(337.82,16.14) v2(337.82,15.5) v2(337.92,114.05) v2(338.2,17.41) v2(338.2,16.8) v2(338.52,35.63) v2(338.46,15.44) v2(338.79,73.52) v2(338.84,17.47) v2(338.84,16.86) v2(338.88,65.48) v2(339.07,15.44) v2(339.24,86.98) v2(339.44,37.22) v2(339.47,17.47) v2(339.47,16.84) v2(339.66,15.44) v2(339.92,114.65) v2(339.85,16.26) v2(340.11,17.47) v2(340.11,16.84) v2(340.17,15.74) v2(340.25,86.86) v2(340.55,16.23) v2(340.74,17.47) v2(340.74,16.84) v2(341.1,116.1) v2(341.4,120.2) v2(341.69,119.01) v2(341.83,80.51) v2(342.62,15.68) v2(342.9,42.49) v2(342.88,10.85) v2(343.14,0.51) v2(343.28,118.22) v2(343.95,20.75) v2(343.95,19.86) v2(344.04,16.09) v2(344.17,10.58) v2(344.42,20.27) v2(344.83,120.89) v2(344.81,119.26) v2(344.84,20.75) v2(344.84,19.86) v2(345.09,122.23) v2(345.29,15.68) v2(345.52,11.01) v2(346.79,4.61) v2(346.84,1.41) v2(347.79,59.19) v2(348.03,5.04) v2(348.11,1.15) v2(349.28,4.61) v2(349.43,1.43) v2(350.09,122.28) v2(350.21,80.51) v2(350.59,118.51) v2(350.59,88.04) v2(350.59,32.56) v2(350.59,24.94) v2(350.59,17.32) v2(350.59,9.7) v2(350.59,5.13) v2(350.89,95.66) v2(350.9,62.76) v2(352.19,55.25) v2(352.19,47.63) v2(352.19,40.01) v5(22.84,40.99) v5(24.11,36.48) v5(25.41,44.9) v5(25.4,36.46) v5(26.06,44.85) v5(26.7,36.48) v5(27.35,36.48) v5(28.01,44.85) v5(28.64,36.44) v5(28.65,44.88) v5(31.24,43.6) v5(31.24,39.05) v5(31.21,37.09)
