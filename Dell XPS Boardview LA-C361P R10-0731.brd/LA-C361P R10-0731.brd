# Allegro board LA-C361P R10-0731.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+1.35VSDGPU on TOP (solid shape): 241.4,62.97 241.4,62.43 240.85,62.43 240.85,61.73 241.4,61.73 241.4,61.23 240.85,61.23 240.85,60.53 241.4,60.53 241.4,59.55 241.16,59.32 238.73,59.32 237.54,60.16 236.12,60.49 236.12,60.5 235.99,60.5 235.78,60.49 235.57,60.47 235.49,60.5 235.46,60.57 235.46,63.13 236.02,63.69 240.68,63.69
+1.35VSDGPU on TOP (solid shape): 210.37,85.73 210.6,85.64 210.83,85.73 211.93,85.73 212.57,85.09 212.57,84.4 212.51,84.34 211.56,84.34 211.49,84.4 211.49,84.78 211.37,84.91 210.48,84.91 210.33,84.76 210.33,84.19 210.29,84.15 209.78,84.15 209.68,84.25 209.68,84.34 209.43,84.59 208.82,84.59 208.5,84.27 206.86,84.27 206.69,84.44 206.34,84.44 206.16,84.62 206.16,85.23 206.29,85.35 208.36,85.35 208.62,85.62 208.83,85.62 208.84,85.62 208.94,85.6 209.04,85.62 209.05,85.62 209.19,85.62 209.3,85.73
+1.35VSDGPU on TOP (solid shape): 197.21,113.11 197.21,111.33 197.2,111.32 197.2,111.19 196.88,110.87 196.86,110.86 196.82,110.83 196.79,110.79 196.76,110.75 196.74,110.73 196.64,110.63 196.64,110.44 196.51,110.31 195.99,110.31 195.88,110.42 195.88,110.67 195.53,111.01 194.22,111.01 194.1,111.14 194.1,111.39 195.92,111.39 195.92,111.33 195.93,111.28 195.95,111.23 195.97,111.19 196,111.14 196.04,111.11 196.08,111.08 196.13,111.05 196.18,111.04 196.23,111.03 196.28,111.03 196.33,111.04 196.38,111.05 196.43,111.08 196.47,111.11 196.51,111.14 196.54,111.19 196.56,111.23 196.58,111.28 196.59,111.33 196.59,111.39 196.58,111.44 196.56,111.49 196.54,111.53 196.51,111.57 196.47,111.61 196.43,111.64 196.38,111.67 196.33,111.68 196.28,111.69 196.23,111.69 196.18,111.68 196.13,111.67 196.08,111.64 196.04,111.61 196,111.57 195.97,111.53 195.95,111.49 195.93,111.44 195.92,111.39 194.1,111.39 194.1,113.04 194.29,113.23 197.08,113.23
+1.35VSDGPU on TOP (solid shape): outline of 181 points within 217.11,69.22 220.95,76.15
+1.35VSDGPU on BOTTOM (solid shape): 240.1,62.85 240.1,62.33 240.1,62.32 240.8,62.32 240.8,62.33 240.8,62.85 241.29,62.85 241.29,62.33 241.3,62.32 242,62.32 242,62.85 242.58,62.85 242.66,62.77 242.66,61.79 242.14,61.27 242.14,59.56 241.95,59.37 239.02,59.37 237.71,60.36 236.12,60.74 235.99,60.75 235.7,60.74 235.42,60.71 235.4,60.7 235.21,60.88 235.21,60.9 235.19,60.99 235.14,61.07 235.14,62.34 235.4,62.59 235.7,62.59 235.7,62.6 237.99,62.6 238.24,62.85 239.29,62.85
+1.35VSDGPU on BOTTOM (solid shape): outline of 84 points within 204.91,84.29 218.69,85.74
+1.35VSDGPU on TOP: 215.57,84.71 215.49,84.79 215.49,85.55 215.57,85.63 215.59,85.63 215.94,85.93 215.64,86.29 215.57,86.32 215.55,86.39 215.55,86.48 215.59,86.48 215.89,86.81 215.59,87.14 215.55,87.15 215.55,87.26 215.57,87.29 215.59,87.29 215.82,87.4 215.9,87.64 215.71,87.91 215.38,87.89 215.04,87.89 214.87,87.95 214.69,87.9 214.68,87.89 214.62,87.89 214.46,88.05 214.46,89.53 214.59,89.66 216.16,89.66 216.25,89.6 216.23,89.49 216.26,89 216.74,89.08 217.01,89.08 217.36,88.92 217.62,89.19 218.53,89.19 218.63,89.1 218.63,89.06 218.63,88.79 218.71,88.71 218.71,87.02 218.6,86.78 218.71,86.53 218.71,86.3 218.63,86.21 218.63,85.13 218.2,84.71
+1.35VSDGPU on VCC: 217.51,58.94 216.03,60.42 216.03,83.55 214.86,84.72 201.78,84.72 200.66,85.84 200.66,92.82 196.58,96.91 191.11,96.91 187.83,100.19 187.83,120.48 228.47,120.48 228.81,120.15 228.89,120.07 228.98,120 230.78,115.99 233.25,119.63 233.33,119.63 234.66,117.54 237,116.73 238.5,116.73 241.16,117.83 242.27,120.48 247.23,120.48 247.23,98.5 247.66,97.35 248.73,96.75 248.73,65.4 248.89,62.15 249.38,58.94 237.83,58.94 235.99,59.6 234.16,58.94
+1V_MPHY on TOP (solid shape): 111.03,16 111.91,16 112.52,15.4 112.52,12.78 111.82,12.08 110.34,12.08 108.92,13.5 108.92,15.97 108.96,16 110.12,16 110.13,16.01 111.02,16.01
+1V_MPHY on TOP (solid shape): outline of 2066 points within 75.9,16.57 89.2,32.77
+1V_MPHY on VCC: 104.25,13.22 101.2,16.26 86.21,16.26 86.09,16.39 85.83,16.39 85.35,16.88 85.35,17.68 89.13,21.47 104.42,21.47 107.21,18.68 113.05,18.68 113.79,17.94 113.79,14.47 112.54,13.22
+1V_MPHY_MPHYPLL on TOP (solid shape): outline of 104 points within 75.85,25.13 81.48,31.44
+1V_MPHY_MPHYPLL on BOTTOM (solid shape): 77.91,28.29 77.91,27.32 78.93,26.3 78.93,25.98 78.93,25.98 78.8,25.72 78.97,25.49 78.97,25.25 78.81,25.08 78.66,25.08 78.57,25.17 78.57,25.3 78.36,25.5 78.36,25.9 77.65,26.61 76.74,26.61 76.47,26.34 76.47,25.75 77.1,25.12 77.81,25.12 77.96,24.97 78.19,24.97 78.36,24.81 78.36,24.63 78.22,24.5 77.95,24.5 77.76,24.65 77.52,24.58 76.35,24.58 75.58,25.36 75.58,27.83 76.08,28.34 76.11,28.34 76.49,28.72 77.47,28.72
+1V_PCH on IN2 (solid shape): outline of 426 points within 87.69,9.6 92.97,19.2
+1V_PCH on TOP: 100.08,21.69 100.34,21.42 100.34,20.87 100.31,20.79 100.22,20.77 99.93,20.67 99.84,20.37 100.07,20.13 100.39,20.2 100.46,20.22 100.53,20.2 100.59,20.13 101.21,20.13 102.26,19.08 102.26,18.01 102.82,18.01 102.82,17.83 102.82,17.82 102.27,17.82 102.26,17.81 102.26,16.72 102.11,16.57 101.44,16.57 101.14,16.28 100.86,16.28 100.71,16.43 100.71,17.04 100.61,17.14 100.6,17.14 100.18,17.56 100.17,17.56 100.15,17.57 91.66,17.57 91.59,17.6 91.56,17.67 91.23,17.97 90.9,17.67 90.87,17.6 90.8,17.57 90.22,17.57 89.98,17.33 89.42,17.33 89.28,17.47 89.28,17.81 88.99,18.11 88.99,20.85 89.82,21.68 89.84,21.69 90.61,21.69 90.63,21.68 90.75,21.66 90.87,21.68 90.89,21.69 91.82,21.69 92.07,21.57 92.32,21.69 92.82,21.69 93.09,21.55 93.36,21.69 94.34,21.69 94.42,21.65 94.43,21.55 94.75,21.12 95.06,21.55 95.08,21.65 95.16,21.69 95.55,21.69 95.56,21.62 95.89,21.33 96.21,21.62 96.22,21.69 96.66,21.69 96.74,21.65 96.76,21.57 97.09,21.2 97.42,21.57 97.45,21.65 97.52,21.69
+1V_PCH on IN4: outline of 129 points within 89.22,12.07 104.77,23.73
+1V_PCH_CLK5 on BOTTOM (solid shape): 102.67,17.43 102.67,16.75 102.85,16.57 102.85,16.32 102.79,16.26 102.36,16.26 101.83,16.8 101.83,17.36 102.08,17.61 102.49,17.61
+1V_PCH_PRIM on TOP: outline of 121 points within 86.1,11.95 102.71,17.46
+1V_PCH_USBPLL on BOTTOM (solid shape): 97.5,12.03 97.5,10.76 97.27,10.52 97.27,10.08 97.11,9.93 96.88,9.93 96.76,10.05 96.76,10.64 96.89,10.77 96.89,11.27 97.16,11.53 97.16,12.01 97.26,12.11 97.42,12.11
+1VALW on TOP (solid shape): 182.63,86.07 182.63,85.24 183.2,84.67 184.17,84.67 184.36,84.49 184.36,82.81 184,82.46 179.85,82.46 179.75,82.56 179.75,84.1 179.84,84.2 180.86,84.2 181.14,84.48 181.14,86.07 181.14,86.07 181.31,86.24 181.31,86.26 182.45,86.26
+1VALW on TOP (solid shape): 106.51,16.17 107.84,16.17 108.12,15.89 108.12,14.29 108.21,14.21 108.21,13.22 108.08,13.09 107.57,13.09 106.83,13.83 106.62,13.83 106.51,13.94 106.51,14.59 106.39,14.72 105.39,14.72 105.3,14.63 105.3,14.37 103.63,12.71 102.46,12.71 102.28,12.89 102.29,13.36 102.82,13.36 102.84,13.38 102.84,13.82 102.83,13.83 102.28,13.83 102.27,13.84 102.27,14.61 102.46,14.8 103.63,14.8 103.63,15.95 103.57,15.95 103.13,16.39 103.13,16.55 102.84,16.84 102.49,16.84 102.41,16.92 102.41,17.67 102.42,17.68 102.95,17.68 102.96,17.69 102.96,18.14 102.95,18.15 102.42,18.15 102.41,18.16 102.41,18.7 102.47,18.75 103.92,18.75
+1VALW on BOTTOM (solid shape): 197.22,59.82 197.22,56.18 196.97,55.93 195.09,55.93 194.81,56.22 194.81,59.99 195,60.19 196.85,60.19
+1VALW on BOTTOM (solid shape): 183.35,87.16 184.67,87.16 184.74,87.09 184.74,84.47 183.74,83.47 182.12,83.47 181.39,82.74 181,82.74 180.88,82.86 180.88,84.55 182.12,85.79 182.74,85.79 183.02,86.07 183.02,87.13 183.06,87.17 183.34,87.17
+1VALW on IN4 (solid shape): 184.1,84.34 184.1,83.31 184.82,82.59 184.82,82.22 184.09,81.49 183.58,81.49 182.53,82.55 182.53,84.41 182.8,84.69 183.74,84.69
+1VALW on IN4 (solid shape): 196.05,60.53 196.05,59.22 195.92,59.09 193.8,59.09 193.6,59.29 193.6,60.51 193.8,60.71 195.87,60.71
+1VALW on BOTTOM: 116.99,8.7 116.65,9.03 116.65,14.3 117.41,15.06 124.65,15.06 125.02,14.69 125.02,11.53 124.04,10.55 121.98,10.55 121.73,10.3 121.73,8.96 121.47,8.7 120.46,8.7 120.46,9.22 119.76,9.22 119.76,8.7 119.26,8.7 119.26,9.22 118.56,9.22 118.56,8.7
+1VALW on IN3: 105.64,11.46 102.62,14.49 102.62,15.88 102.66,15.99 102.76,16.04 103.1,16.39 102.76,16.75 102.66,16.79 102.62,16.9 102.62,16.96 102.9,17.25 103.61,17.25 104.04,16.83 105.56,16.83 107.85,14.54 110.51,14.54 110.65,14.45 110.63,14.29 110.66,13.81 111.14,13.79 111.2,13.82 111.49,13.71 111.79,13.82 111.85,13.79 112.33,13.81 112.36,14.29 112.34,14.45 112.48,14.54 113.43,14.54 113.57,14.45 113.55,14.29 113.83,13.71 114.11,14.29 114.09,14.45 114.23,14.54 121.24,14.54 121.73,14.05 121.73,12.58 119.7,10.55 110.62,10.55 109.71,11.46
+1VALW on IN4: 102.74,15.38 102.74,16.03 102.81,16.04 103.1,16.39 102.81,16.74 102.74,16.75 102.74,17.2 103.29,17.75 105.58,17.75 106.24,17.08 106.24,16.37 106.52,16.1 108.66,16.1 108.86,15.9 112.36,15.9 112.56,16.1 121.03,16.1 122.43,14.7 122.43,13.53 122.24,13.34 104.78,13.34
+1VSP on TOP (solid shape): 126.11,6.41 126.11,5.53 125.95,5.37 118.52,5.37 118.25,5.65 118.25,7.45 118.75,7.95 124.57,7.95
+1VSP on BOTTOM (solid shape): 119.13,8.57 119.88,8.57 119.88,9.1 120.33,9.1 120.33,8.57 120.34,8.57 120.34,8.52 124.02,8.52 125.99,6.55 125.99,2.49 125.67,2.17 123,2.17 122.94,2.23 122.94,4.9 122.42,5.41 118.43,5.41 118.21,5.64 118.21,7.99 117.96,8.24 117.96,8.49 117.99,8.52 118.68,8.52 118.68,9.1 119.13,9.1
+2.5V_MEM on TOP (solid shape): 251.71,29.98 251.71,29.19 251.66,29.13 251.5,29.13 251.14,28.77 251.14,28.2 250.65,27.71 250.65,25.65 250.53,25.54 249.57,25.54 249.38,25.35 248.67,25.35 248.63,25.38 248.63,27.12 248.79,27.28 248.79,27.37 248.83,27.45 248.92,27.47 249.34,27.82 248.92,28.17 248.83,28.19 248.79,28.27 248.79,29.09 249.87,30.17 251.52,30.17
+2.5V_MEM on TOP (solid shape): outline of 166 points within 173.51,15.24 180.98,30.96
+2.5V_MEM on BOTTOM (solid shape): 251.81,30.1 251.81,25.59 251.66,25.44 249.62,25.44 249.51,25.55 249.51,27.23 250.05,27.77 250.05,29.97 250.34,30.26 251.64,30.26
+2.5V_MEM on BOTTOM (solid shape): 175.98,30.4 175.98,29.32 175.57,28.9 175.57,27.98 175.57,27.97 175.57,25.65 175.38,25.46 173.3,25.46 173.21,25.55 173.21,30.06 173.85,30.71 175.67,30.71
+2.5V_MEM on IN4 (solid shape): 176.36,30.26 176.36,28.42 176.18,28.23 174.22,28.23 174.08,28.37 174.08,30.25 174.32,30.49 176.13,30.49
+2.5V_MEM on IN4 (solid shape): outline of 535 points within 240.98,19.27 251.18,30.27
+2.5VS_G9141 on TOP (solid shape): 182.65,14.53 182.65,13.42 181.38,12.15 179.88,12.15 179.27,12.76 179.27,14.49 179.36,14.58 181.83,14.58 181.93,14.68 182.5,14.68
+3.3V_GFX_AON on TOP (solid shape): 219.81,59.02 219.81,57.46 219.64,57.28 217.86,57.28 217.77,57.37 217.77,59.02 217.93,59.18 219.65,59.18
+3.3V_GFX_AON on TOP (solid shape): 212.94,65.35 212.94,64.57 212.74,64.37 212.1,64.37 211.81,64.08 211.81,63.51 212.08,63.24 212.69,63.24 212.8,63.13 212.8,62.75 212.66,62.61 211.05,62.61 211.04,62.61 210.53,62.61 210.31,62.84 210.31,65.05 210.71,65.44 212.85,65.44
+3.3V_GFX_AON on TOP (solid shape): 205.77,72.86 205.77,72.34 205.63,72.2 205.37,72.2 205.22,72.04 205.22,70.37 205.08,70.23 205.08,67.34 205.29,67.13 205.69,67.13 205.83,66.99 205.83,66.34 204.29,64.8 203.85,64.8 203.7,64.96 203.7,66.75 204.31,67.36 204.31,67.97 204.3,67.97 204.3,70.46 204.34,70.46 204.34,71.22 204.3,71.22 204.3,72.41 204.87,72.97 205.65,72.97
+3.3V_GFX_AON on BOTTOM (solid shape): 220.36,59.68 220.36,58.88 220.12,58.63 219.75,58.63 219.75,58.63 218.78,58.63 218.63,58.78 218.63,59.7 218.74,59.81 220.23,59.81
+3.3V_GFX_AON on BOTTOM (solid shape): 204.25,61.03 204.25,59.74 204.08,59.56 201.66,59.56 201.58,59.64 201.58,61 201.9,61.32 203.96,61.32
+3.3V_GFX_AON on BOTTOM (solid shape): 220.44,69.83 220.44,69.45 219.97,68.98 219.62,68.98 219.54,69.06 219.29,69.06 218.97,69.38 218.97,69.73 219.09,69.86 219.46,69.86 219.58,69.73 219.9,69.73 220.09,69.92 220.34,69.92
+3.3V_GFX_AON on IN4: 219.16,57.92 218.67,58.42 218.67,59.72 218.15,60.23 210.74,60.23 210.26,60.71 210.26,63.57 210.59,63.9 217.63,63.9 218.52,63.01 221.2,63.01 222.44,61.77 222.44,60.28 222.89,59.84 222.89,58.63 222.88,58.62 222.88,58.15 222.65,57.92
+3.3V_GFX_AON on IN6: outline of 81 points within 218.66,57.54 233.02,69.69
+3.3V_GFX_AON on IN6: 194.63,60.67 193.74,61.56 193.74,66.32 194.33,66.9 197.6,66.9 197.8,66.84 198.01,66.9 198.62,66.9 198.65,66.89 198.79,66.86 198.94,66.89 198.95,66.9 207.71,66.9 213.23,61.38 213.23,60.54 213.13,60.44 210.3,60.44 207.71,57.85 207.69,57.83 207.69,54.86 205.15,52.31 195.58,52.31 194.63,53.26
+3.3V_GFX_RUN on TOP (solid shape): outline of 239 points within 214.41,58.4 227.99,69.73
+3.3V_GFX_RUN on BOTTOM (solid shape): 218.71,69.69 218.71,69.46 218.17,68.93 217.93,68.93 217.7,69.04 217.47,68.93 217.08,68.93 217.04,68.97 216.98,69.01 216.93,69.06 216.93,69.24 216.98,69.29 217.06,69.34 217.11,69.42 217.14,69.45 217.14,69.65 217.31,69.81 218.58,69.81
+3.3V_GFX_RUN on IN4: 222.8,70.42 222.89,70.36 222.88,70.26 223.14,69.72 223.4,70.26 223.39,70.36 223.48,70.42 226.81,70.42 227.44,69.79 228.67,69.79 230.65,67.81 230.65,65.74 231.58,64.81 234.25,64.81 234.8,64.27 234.8,62.01 233.96,61.18 233.86,61.16 233.79,61.24 233.35,61.54 233.11,61.07 233.1,60.98 233.01,60.93 231.43,60.93 231.33,60.94 231.23,60.93 230.37,60.93 227.62,58.19 227.35,58.19 227.27,58.22 227.25,58.31 227.09,58.68 226.68,58.66 226.62,58.64 226.55,58.67 226.32,58.76 226.08,58.67 226.02,58.65 225.95,58.67 225.53,58.71 225.37,58.31 225.35,58.23 225.27,58.19 225.05,58.19 222.77,60.46 222.77,62.06 221.16,63.67 219.15,63.67 218.98,63.73 218.81,63.68 218.8,63.67 218.63,63.67 217.77,64.53 217.77,70.14 218.1,70.46 222.33,70.46 222.4,70.39 222.35,70.34 222.33,70.34 221.99,70.1 222.16,69.72 222.21,69.63 222.17,69.54 222.37,68.94 222.51,69.56 222.45,69.65 222.5,69.73 222.64,69.98 222.54,70.25 222.52,70.36 222.62,70.42
+3.3VDX_SSD on TOP (solid shape): 247.21,9.53 247.21,8.64 246.57,8.01 244.58,8.01 244.34,8.25 242.85,8.25 242.79,8.31 242.79,9.96 243,10.17 246.57,10.17
+3.3VDX_SSD on BOTTOM: 267.41,3.98 267.21,4.19 267.21,5.37 267.3,5.46 270.27,5.46 271.58,6.77 271.58,8.86 271.62,8.95 271.72,8.96 272.23,9.28 271.72,9.6 271.62,9.61 271.58,9.7 271.58,10.36 270.82,11.12 269.11,11.12 268.95,11.29 268.95,13.53 269.3,13.89 269.3,16.9 269.3,16.91 269.3,17.72 268.92,18.09 267.41,18.09 267.13,18.37 267.13,19.81 267.29,19.97 268.73,19.97 268.99,20.23 268.99,21.4 268.75,21.64 267.25,21.64 267.12,21.76 268.1,22.74 273.09,22.74 273.88,21.95 273.88,17.42 276.58,14.73 276.58,10.2 276.55,10.19 276.34,9.86 276.55,9.54 276.58,9.53 276.58,5.55 275.02,3.98 271.48,3.98 271.41,4.01 271.37,4.08 271.02,4.43 270.66,4.08 270.63,4.01 270.56,3.98
+3.3VDX_SSD on IN3: 244.65,7.42 244.15,7.92 244.15,9.61 244.82,10.29 253.01,10.29 254.19,11.46 259.44,11.46 259.91,11.93 262.2,11.93 262.82,12.55 267.48,12.55 268.63,13.7 270.36,13.7 270.77,13.29 270.77,10.65 269.44,9.32 269.44,8.75 269.38,8.7 267.2,8.7 267.07,8.79 267.09,8.95 267.05,9.44 266.56,9.43 266.49,9.4 266.42,9.43 265.93,9.44 265.89,8.95 265.92,8.79 265.78,8.7 264.13,8.7 264.03,8.76 264.06,8.88 264.07,9.37 263.57,9.4 263.5,9.37 263.44,9.4 263.03,9.44 262.85,9.07 262.86,9.03 262.72,8.89 259.4,8.89 257.92,7.42
+3V_PCH on BOTTOM (solid shape): 77.85,6.07 77.85,5.63 78.09,5.39 78.93,5.39 79.44,4.88 79.44,4.69 79.39,4.64 79.12,4.64 78.87,4.9 77.85,4.9 77.77,4.82 77.06,4.82 76.92,4.95 76.92,5.3 77.22,5.6 77.22,5.85 77.51,6.14 77.78,6.14
+3V_PCH on BOTTOM (solid shape): 98.54,4.7 98.54,4.46 98.71,4.28 98.71,3.85 98.81,3.76 98.81,3.44 98.68,3.31 97.83,3.31 97.69,3.44 97.69,3.83 97.83,3.97 97.83,4.17 97.94,4.29 98,4.33 98.05,4.39 98.12,4.47 98.12,4.69 98.22,4.79 98.45,4.79
+3V_PCH on BOTTOM (solid shape): 80.24,11.57 80.24,11.07 80.16,10.99 80.16,10.97 80.15,10.96 80.12,10.9 80.12,10.84 80.09,10.77 80.03,10.74 79.8,10.59 79.76,10.32 79.77,10.29 79.63,10.16 79.63,10.1 79.19,10.1 79.02,10.27 79.02,10.33 79.02,10.55 79.16,10.69 79.18,10.7 79.27,10.75 79.32,10.84 79.33,10.86 79.45,10.98 79.45,12.03 79.53,12.12 79.69,12.12
+3V_PCH on TOP: 80.99,7.53 80.6,7.53 80.59,7.53 79.92,6.86 79.93,6.85 79.88,6.8 79.88,6.21 79.82,6.14 79.3,6.14 79.24,6.19 79.24,7.08 78.95,7.37 78.95,7.9 78.98,7.93 79.57,7.93 79.81,8.17 80.02,8.17 80.28,8.43 80.46,8.43 80.46,8.6 80.57,8.71 80.83,8.71 80.84,8.68 80.89,8.6 80.97,8.54 81.02,8.49 81.03,8.42 81.22,8.04 81.63,8.17 81.71,8.21 81.79,8.18 81.96,8.01 81.96,7.49 81.9,7.43 81.42,7.43 81.32,7.53 81.21,7.53 81.21,7.54 81.1,7.55 81,7.54
+3V_PCH on TOP: 58.57,5.91 59.12,5.91 59.22,5.81 59.63,5.81 59.81,5.99 59.81,6.13 59.81,6.14 59.81,6.2 59.87,6.26 61.57,6.26 61.72,6.1 61.72,5.6 61.66,5.53 61.22,5.53 60.87,5.19 60.87,4.73 60.8,4.66 59.44,4.66 59.31,4.53 59.31,4.14 59.18,4.01 58.36,4.01 58.29,4.07 58.29,5.64
+3V_PCH on IN1: outline of 318 points within 82.16,3.36 100.47,9.34
+3V_PCH on IN2: outline of 100 points within 76.86,4.93 84.58,11.9
+3V_PCH on IN3: 85.28,10.35 84.59,9.65 84.41,9.65 84.32,9.55 84.2,9.55 83.92,9.7 83.65,9.55 83.34,9.55 83.32,9.58 83.08,9.75 82.8,9.66 82.8,9.65 82.72,9.62 82.65,9.65 82.61,9.68 82.56,9.71 82.31,9.72 82.13,9.55 81.98,9.55 81.86,9.69 81.67,9.74 81.49,9.69 81.37,9.55 81.06,9.55 81.05,9.58 80.8,9.75 80.52,9.65 80.45,9.62 80.37,9.65 80.19,9.76 79.97,9.73 79.94,9.71 79.9,9.68 79.85,9.66 79.83,9.68 79.69,9.68 79.11,10.26 77.55,10.26 77.48,10.3 77.45,10.37 77.12,10.72 76.79,10.37 76.77,10.3 76.7,10.26 75.29,10.26 75.29,10.27 75.06,10.27 73.86,10.27 73.78,10.32 73.78,10.42 73.48,10.97 73.18,10.42 73.19,10.32 73.1,10.27 72.41,10.27 71.91,10.77 70.24,10.77 69.83,10.77 69.69,10.91 69.69,12.06 69,12.75 69,13.34 69.97,14.31 69.97,17.15 69.47,17.65 69.47,18.12 69.74,18.39 73.84,18.39 76.34,15.88 77.81,15.88 79.76,13.93 80.13,13.93 80.19,13.88 80.19,13.59 80.4,13.37 84.6,13.37 85.25,12.72 85.25,12.02 85.28,11.99
+3V_PCH on IN6: outline of 89 points within 58.29,1.98 79.35,9.28
+3V_PCH_AZIO on IN5 (solid shape): outline of 277 points within 91.65,6.53 94.92,9.29
+3V_PCH_DSW on BOTTOM (solid shape): 111.72,3.86 111.72,3.71 111.73,3.66 111.75,3.61 111.77,3.56 111.8,3.51 111.84,3.47 111.88,3.43 111.93,3.4 111.98,3.38 112.03,3.37 112.09,3.36 112.14,3.36 112.2,3.37 112.26,3.39 112.29,3.38 112.32,3.37 112.34,3.35 112.35,3.32 112.36,3.28 112.36,1.75 111.94,1.33 109.72,1.33 109.64,1.41 109.64,3.73 109.65,3.74 110.26,3.74 110.26,3.69 110.27,3.64 110.29,3.59 110.31,3.54 110.34,3.49 110.38,3.46 110.42,3.42 110.46,3.4 110.51,3.38 110.56,3.36 110.62,3.36 110.67,3.36 110.72,3.38 110.77,3.4 110.82,3.42 110.86,3.46 110.9,3.49 110.93,3.54 110.95,3.59 110.97,3.64 110.97,3.69 110.97,3.74 110.97,3.8 110.95,3.85 110.93,3.9 110.9,3.94 110.86,3.98 110.82,4.01 110.77,4.04 110.72,4.06 110.67,4.07 110.62,4.07 110.56,4.07 110.51,4.06 110.46,4.04 110.42,4.01 110.38,3.98 110.34,3.94 110.31,3.9 110.29,3.85 110.27,3.8 110.26,3.74 109.65,3.74 110.13,4.22 111.36,4.22
+3V_PCH_DSW on IN5: outline of 105 points within 87.19,1.91 111,6.08
+3V_PCH_SPI on TOP (solid shape): 78.39,4.66 78.39,3.83 78.56,3.65 78.78,3.65 79,3.44 79,2.68 78.8,2.49 78.66,2.49 78.49,2.66 78.49,2.93 78.3,3.11 78.3,3.46 78.05,3.71 77.71,3.71 77.67,3.74 77.67,4.67 77.74,4.73 78.31,4.73
+3V_PCH_SPI on BOTTOM (solid shape): 79.72,4.22 79.72,3.86 79.57,3.71 79.57,2.68 79.38,2.49 78.52,2.49 78.4,2.61 78.4,4.21 78.48,4.29 79.65,4.29
+3V_PS8723 on BOTTOM (solid shape): 315.32,32.9 315.32,30.62 315.26,30.57 314.71,30.57 314.08,31.2 314.08,31.86 314.17,31.94 314.5,31.94 314.67,32.11 314.67,32.89 314.73,32.95 315.28,32.95
+3V_PS8723 on BOTTOM (solid shape): 322.67,36.4 322.84,36.36 323,36.4 323.9,36.4 323.96,36.34 323.96,34.86 323.64,34.55 323.64,34.04 323.55,33.95 322.27,33.95 322.12,34.1 322.12,36.13 322.38,36.4
+3V_PS8723 on IN5 (solid shape): outline of 1154 points within 314.01,27.81 325.66,37.52
+3V_ROM on IN5 (solid shape): outline of 235 points within 64.24,1.36 73.89,3.49
+3V_TBT on TOP (solid shape): 33.4,48.42 33.4,47.94 33.28,47.81 32.97,47.81 32.89,47.89 32.89,48.19 32.64,48.45 32.36,48.45 32.23,48.57 32.23,48.78 32.36,48.9 32.92,48.9
+3V_TBT on IN5 (solid shape): 21.48,45.29 21.58,45.29 21.75,45.11 21.75,44.81 21.63,44.69 20.14,44.69 19.93,44.9 19.93,45.56 20.07,45.7 21.06,45.7
+3V_TBT on IN6 (solid shape): 22.43,45.69 22.43,45.25 21.93,44.75 21.31,44.75 20.82,45.24 20.82,45.49 20.94,45.61 21.15,45.61 21.41,45.36 21.67,45.36 22.06,45.74 22.37,45.74
+3V_TBT on BOTTOM: 17.34,45.47 17.64,45.76 18.82,45.76 19.14,46.08 20.45,46.08 20.65,45.88 20.89,45.88 21.39,45.38 21.68,45.38 21.7,45.4 22.1,45.4 22.16,45.34 22.16,45.09 22.29,44.97 22.51,44.97 22.57,44.91 22.57,44.73 22.52,44.68 22.31,44.68 22.27,44.72 21.54,44.72 21.08,45.18 20.83,45.18 20.64,45.37 19.38,45.37 19.23,45.22 19.23,44.99 19.23,42.73 19.58,42.38 20.32,42.38 20.5,42.2 20.5,41.67 20.36,41.52 17.78,41.52 17.59,41.34 17.59,40.39 17.46,40.27 16.82,40.27 16.71,40.37 16.71,42.92 17.34,43.55
+3V_TBT on IN4: 33.02,48.99 32.28,48.99 32.18,48.9 32.18,48.52 32.31,48.4 32.83,48.4 32.83,47.33 33.4,46.76 33.4,46.29 33.66,46.02 33.66,45.86 33.79,45.73 34.99,45.73 35.18,45.92 35.18,45.98 34.75,46.49 34.75,46.63 33.61,47.77 33.61,48.4
+3V_TBT on IN6: 30.11,47.23 29.95,47.39 29.95,47.97 30.12,48.14 31.73,48.14 32.15,48.56 32.15,48.79 32.3,48.94 32.53,48.94 32.72,48.76 32.72,48.57 32.66,48.45 32.54,48.42 32.19,48.25 32.2,47.86 32.23,47.81 32.06,47.63 31.78,47.63 31.37,47.23
+3V_TBT_PWR on TOP: 18.67,30.36 18.05,30.36 17.95,30.47 17.95,31.12 17.55,31.52 15.98,31.52 15.93,31.57 15.93,32.49 16.05,32.61 19.44,32.61 19.58,32.47 19.58,31.28
+3V_TBT_SPI on BOTTOM: 42.44,27.91 42.23,27.69 42.14,27.69 42.13,27.7 41.6,27.39 42.13,27.07 42.14,27.08 42.48,27.08 43.07,27.67 43.07,27.78 43.08,27.78 43.08,28.44 42.99,28.53 42.62,28.53 42.56,28.59 42.56,29.01 42.88,29.33 42.89,29.34 43.08,29.6 42.9,29.86 42.84,29.88 42.84,30.22 43.12,30.49 43.4,30.49 44.38,29.51 44.38,28.77 44.25,28.49 44.42,28.22 44.42,26.69 44.13,26.4 39.71,26.4 39.25,26.86 39.25,27.15 39.25,27.17 39.29,27.31 39.25,27.46 39.25,27.48 39.25,27.67 39.4,27.83 41.37,27.83 41.84,28.3 42.36,28.3 42.44,28.21
+3V_VC on BOTTOM (solid shape): outline of 100 points within 9.96,21.12 12.32,23.93
+3V_VC on IN2 (solid shape): 12.7,40.52 12.7,40.27 12.34,39.9 12.17,39.9 11.95,39.68 11.91,39.69 11.79,39.69 11.67,39.64 11.65,39.63 11.58,39.63 11.43,39.48 11.41,39.48 11.41,37.07 11.45,37.02 11.46,37.01 11.67,36.81 11.96,36.84 12.02,36.86 12.14,36.74 12.14,36.1 11.84,35.8 11.35,35.8 10.63,36.52 10.62,36.55 10.59,36.63 10.54,36.7 10.52,36.72 10.52,36.79 10.54,36.81 10.64,37.08 10.52,37.34 10.52,37.45 10.53,37.47 10.59,37.68 10.53,37.88 10.52,37.9 10.52,38.01 10.53,38.03 10.62,38.26 10.53,38.49 10.52,38.51 10.52,38.62 10.53,38.64 10.59,38.84 10.53,39.05 10.52,39.1 10.67,39.37 10.61,39.62 10.57,39.68 10.52,39.72 10.52,40.06 10.8,40.35 11.81,40.35 11.92,40.46 12.02,40.54 12.09,40.65 12.16,40.72 12.25,40.74 12.33,40.74 12.41,40.76 12.45,40.77
+3V_VC on IN5: 12.48,33.86 11.49,33.86 11.21,34.15 11.21,35.43 10.8,35.83 10.8,36.62 10.95,36.76 12.22,36.76 12.82,36.16 12.82,34.21
+3VA_TBT on IN6 (solid shape): 24.87,48.73 24.87,48.4 24.74,48.27 22.24,48.27 22.11,48.4 22.11,48.81 22.22,48.93 24.66,48.93
+3VA_TBT on TOP: 14.24,33.93 13.78,33.46 13.78,32.86 13.78,32.86 13.78,32.57 14,32.34 14.4,32.34 15.1,33.05 16.91,33.05 17.04,33.18 17.04,33.87 16.98,33.93
+3VA_TBT on TOP: 31.92,48.98 30.25,48.98 30.23,48.96 30.16,48.96 29.85,48.65 29.85,48.33 30.37,47.81 32.04,47.81 32.14,47.9 32.14,48.76
+3VA_TBT on BOTTOM: 16.05,42.6 16.05,41.74 15.99,41.68 15.24,41.68 14.6,42.32 13.66,42.32 13.41,42.07 13.41,41.91 13.29,41.79 12.99,41.79 12.9,41.89 12.9,42.37 13.57,43.04 15.62,43.04
+3VA_TBT on IN3: 13.82,36.94 14.66,36.1 14.66,35.57 14.69,35.54 14.69,35.53 15.29,34.93 15.29,32.9 15,32.6 12.9,32.6 11.94,33.56 11.94,34.55 11.91,34.62 11.93,34.69 12,35.03 11.75,35.27 11.71,35.28 11.71,35.39 11.72,35.39 12.42,36.09 12.75,36.18 12.85,36.5 12.84,36.53 12.87,36.56 12.87,36.84 12.97,36.94
+3VA_TBT on IN4: 30.08,48.81 30.46,48.81 30.62,48.65 30.62,47.86 30.11,47.35 24.59,47.35 24.28,47.66 24.28,48.6 24.51,48.83 24.77,48.83 24.84,48.75 24.84,48.37 25.05,48.17 25.09,48.12 29.38,48.12
+3VALW on TOP (solid shape): 339.19,101.08 339.19,100.24 338.94,99.98 337.73,99.98 337.63,100.08 337.63,101.09 337.73,101.19 339.08,101.19
+3VALW on TOP (solid shape): 243.85,3.69 243.85,2.17 243.65,1.98 242.32,1.98 242.19,2.1 242.19,2.36 242.28,2.45 242.28,3.8 242.35,3.87 243.67,3.87
+3VALW on TOP (solid shape): 308.87,23.57 308.87,22.55 308.55,22.23 306.26,22.23 306.12,22.38 306.12,22.65 306.66,22.65 306.66,23.09 306.12,23.09 306.12,23.81 306.26,23.95 308.48,23.95
+3VALW on TOP (solid shape): 13.16,19.05 13.16,17.89 13.78,17.27 13.78,13.99 13.64,13.85 11.94,13.85 11.81,13.98 11.81,18.7 12.22,19.1 13.1,19.1
+3VALW on TOP (solid shape): 275.11,9.29 276.09,9.29 276.29,9.5 276.72,9.5 276.93,9.29 276.93,8.86 276.4,8.86 276.4,8.43 276.93,8.43 276.93,7.97 276.61,7.65 273.81,7.65 273.57,7.9 273.57,9.22 273.84,9.5 274.91,9.5
+3VALW on TOP (solid shape): 324.32,29.33 324.32,24.33 323.8,24.33 323.8,23.63 324.32,23.63 324.32,23.13 323.8,23.13 323.8,22.43 324.32,22.43 324.32,21.37 324.04,21.09 320.87,21.09 320.03,21.93 320.03,28.96 321.06,29.99 323.66,29.99
+3VALW on TOP (solid shape): 218.94,49.65 218.76,49.48 218.25,49.48 218.06,49.28 218.06,47.95 218,47.89 216.15,47.89 216.09,47.95 216.09,49.03 216.85,49.79 218.44,49.79 218.67,50.02 218.67,51.09 218.94,51.09
+3VALW on TOP (solid shape): 317.01,36.67 317.01,35.38 316.77,35.14 316.56,35.14 316.26,35.43 316.26,35.44 316.23,35.47 314.78,35.47 314.61,35.3 314,35.3 313.88,35.42 313.88,35.88 314.26,36.26 315.08,36.26 315.42,36.6 316.14,36.6 316.27,36.73 316.95,36.73
+3VALW on BOTTOM (solid shape): 136.02,5.85 136.02,4.96 135.89,4.83 134.43,4.83 134.22,5.04 133.13,5.04 133.13,5.31 134.58,5.31 135.19,5.91 135.95,5.91
+3VALW on BOTTOM (solid shape): 106.17,62.94 106.17,62.56 106.49,62.24 107.76,62.24 107.76,61.92 106.43,61.92 106.05,61.54 105.41,61.54 105.28,61.67 105.28,62.94 105.54,63.19 105.92,63.19
+3VALW on BOTTOM (solid shape): 343.73,44.81 343.73,44.27 343.86,44.14 344.85,44.14 345.13,43.85 345.13,43.41 344.97,43.25 344.81,43.25 344.7,43.15 344.69,43.14 344.55,43.06 344.47,42.92 344.47,42.91 344.36,42.81 344.36,42.68 344.3,42.62 343.73,42.62 343.59,42.76 343.59,43.43 343.47,43.55 343.08,43.55 342.84,43.79 342.84,44.76 342.95,44.87 343.67,44.87
+3VALW on IN1 (solid shape): 308.71,23.4 308.71,22.99 308.13,22.41 307.21,22.41 307.05,22.58 307.05,23.47 307.25,23.67 308.45,23.67
+3VALW on IN1 (solid shape): outline of 108 points within 315.71,30.02 317.79,36.85
+3VALW on TOP: 42.73,30.63 41.05,30.63 40.89,30.47 40.89,30.08 41.26,29.71 41.26,29.12 40.19,28.06 40.19,26.9 40.29,26.8 41.36,26.8 41.56,27 41.56,27.58 42.57,28.58 42.57,29.64 42.78,29.86 42.78,30.58
+3VALW on TOP: 15.93,31.09 16.62,31.09 16.78,30.93 16.78,30.54 16.63,30.4 15.78,30.4 15.5,30.11 14.1,30.11 14.03,30.17 14.03,31.62 14.81,32.39 15.67,32.39 15.75,32.32 15.75,31.27
+3VALW on TOP: 57.91,7.25 58.61,7.25 58.87,6.99 58.87,6.42 58.04,5.6 58.04,4.96 57.79,4.71 57.02,4.71 56.96,4.77 56.96,5.6 57.79,6.42 57.79,7.12
+3VALW on IN2: 67.33,13.68 67.63,13.99 67.63,15.2 66.28,16.56 66.28,19.04 64.42,20.89 64.42,21.6 63.43,22.59 59.62,22.59 54.87,27.34 46.88,27.34 45.4,28.82 43.02,28.82 42.32,29.51 41.03,29.51 40.85,29.69 40.85,30.41 40.98,30.55 45.5,30.55 47.73,28.31 55.7,28.31 60.03,23.98 65.16,23.98 66.19,22.94 67,22.94 67.8,22.15 67.8,21.14 68.18,20.76 68.18,19.92 69.38,18.72 69.38,16.93 69.86,16.45 69.86,12.9 69.37,12.4 67.58,12.4 67.33,12.65
+3VALW on IN4: 46.57,5.97 46.74,5.93 46.91,5.97 46.92,5.98 51.37,5.98 51.63,6.23 54.93,6.23 55.37,6.68 58.8,6.68 58.99,6.49 58.99,2.99 57.47,1.47 8.85,1.47 7.32,3.01 7.32,10.22 5.18,12.35 5.18,13.57 4.87,13.89 3.49,13.89 2.74,14.64 2.74,18.14 3.1,18.5 3.4,18.64 3.45,18.97 3.45,19.28 9.48,25.31 10.47,25.31 12.5,27.34 12.5,29.55 14.05,31.1 14.7,31.1 14.78,31.01 14.78,29.4 15.34,28.85 16.11,28.08 16.11,22.45 15.91,22.26 15.91,20.86 14.7,19.65 14.7,17.11 15.91,15.9 15.91,12.54 18.52,9.94 18.55,9.86 18.5,9.78 18.42,9.22 18.98,9.3 19.03,9.34 19.08,9.35 19.64,9.35 23.01,5.98 46.55,5.98
+3VALW on VCC: outline of 105 points within 57.72,1.27 349,116.85 ; 1 cut-out
+3VALW_5085 on TOP (solid shape): 305.96,23.48 305.96,22.95 306.53,22.95 306.53,22.78 305.96,22.78 305.96,22.33 305.65,22.01 304.08,22.01 303.91,22.17 303.91,23.69 304.04,23.82 305.63,23.82
+3VALW_5085 on TOP (solid shape): 290.22,8.18 290.22,7.35 290.13,7.25 288.55,7.25 288.13,6.84 288.11,6.84 287.82,6.75 287.71,6.46 287.71,6.39 287.73,6.32 287.7,6.26 287.63,6.23 286.81,6.23 286.65,6.39 286.65,6.99 286.51,7.12 286.51,8.2 286.58,8.26 287.96,8.26 288.02,8.21 288.41,8.21 288.42,8.2 288.59,8.16 288.75,8.23 289.46,8.23 289.5,8.28 290.13,8.28
+3VALW_5085 on IN4 (solid shape): outline of 920 points within 304.43,15.17 312.04,27.48
+3VALW_5085 on IN6 (solid shape): outline of 269 points within 298.84,22.14 310.69,27.62
+3VALW_5085 on IN1: outline of 132 points within 286.42,5.69 301.93,15.2
+3VALW_5085 on IN2: outline of 188 points within 288.74,10.43 309.26,19.86
+3VALW_5085 on IN4: 291.69,14.83 291.55,14.74 289.24,14.74 289.05,14.93 289.05,20.23 289.97,21.14 292.52,21.14 293.3,21.92 293.3,24.04 293.94,24.68 293.95,24.68 294.11,24.84 294.14,25.06 294.14,25.09 294.29,25.24 295.07,25.24 295.23,25.09 295.23,22.81 294.72,22.31 294.72,21.78 294.73,21.77 294.73,20.96 294.67,20.9 294.39,20.61 294.55,20.24 294.62,20.13 294.58,20.01 294.09,19.51 294.09,16.19 294.32,15.96 294.32,15.1 293.96,14.74 292.28,14.74 292.13,14.83 292.17,15 292.19,15.03 292.21,15.06 292.27,15.1 292.33,15.09 292.73,15.16 292.81,15.55 292.82,15.64 292.88,15.69 293.16,15.97 293,16.34 292.93,16.47 293,16.59 293.08,17.12 292.56,17.15 292.5,17.13 292.44,17.14 292.06,17.18 291.86,16.86 291.83,16.79 291.77,16.76 291.52,16.15 292.13,16.41 292.16,16.47 292.22,16.51 292.35,16.53 292.46,16.61 292.52,16.63 292.58,16.61 292.61,16.59 292.69,16.46 292.62,16.33 292.47,16.14 292.48,15.9 292.48,15.81 292.41,15.76 292.28,15.71 292.18,15.6 292.13,15.57 292.06,15.57 291.62,15.46 291.65,15
+3VALW_23017 on TOP (solid shape): 277.73,9.58 277.88,9.55 278.03,9.58 278.04,9.58 278.77,9.58 278.82,9.54 278.82,9.43 278.86,9.39 278.86,7.89 278.78,7.81 277.2,7.81 277.07,7.94 277.07,9.4 277.25,9.58 277.72,9.58
+3VALW_23017 on IN3: 277.9,8.1 277.5,8.51 277.5,9.33 277.69,9.52 277.97,9.52 278.02,9.58 278.03,9.58 278.13,9.65 278.2,9.75 278.2,9.76 278.3,9.85 278.3,11.64 278.3,11.64 278.3,12.03 283.31,17.04 283.31,17.86 283.69,18.24 284.77,18.24 285.08,17.93 285.08,17.12 284.95,16.86 285.07,16.59 285.07,16.59 285.55,16.1 285.55,13.26 285.49,13.25 285.45,13.24 285.4,13.22 285.33,13.21 285.27,13.26 284.66,13.26 284.93,12.72 285.01,12.66 285.01,12.56 285.02,12.14 285.42,12.02 285.51,12.01 285.55,11.93 285.55,10.7 284.8,9.94 284.19,9.94 282.98,8.73 282.91,8.7 282.84,8.73 282.38,8.76 282.27,8.32 282.26,8.17 282.14,8.1
+3VALWP on TOP (solid shape): 332.62,27.06 332.62,23.38 332.36,23.12 326.39,23.12 325.02,21.76 324.54,21.76 324.45,21.84 324.45,22.53 324.45,22.53 324.45,22.55 323.94,22.55 323.94,23 324.45,23 324.45,23.03 324.45,23.03 324.45,23.73 324.45,23.73 324.45,23.75 323.94,23.75 323.94,24.2 324.45,24.2 324.45,24.23 324.45,24.23 324.45,25 324.45,25 324.45,26.26 325.38,27.19 332.49,27.19
+3VS on TOP (solid shape): 103.7,6.89 103.7,6.64 103.41,6.35 101.58,6.35 101.5,6.43 101.5,8.06 101.62,8.18 102.41,8.18
+3VS on TOP (solid shape): 311.27,39.27 311.27,36.64 311.1,36.47 309.54,36.47 309.43,36.58 309.43,38.66 310.18,39.4 311.14,39.4
+3VS on TOP (solid shape): 67.64,6.61 67.64,5.17 67.44,4.96 66.7,4.96 66.55,4.81 65.41,4.81 64.52,5.7 64.52,6.13 64.64,6.26 65,6.26 65.63,5.62 66.75,5.62 66.96,5.83 66.96,6.64 67.01,6.69 67.57,6.69
+3VS on TOP (solid shape): 232.16,60.58 232.7,60.58 232.72,60.58 233.81,60.58 233.92,60.47 233.92,59.94 233.92,59.92 233.78,59.78 233.72,59.78 233.35,59.41 232.1,59.41 232.01,59.5 232.01,59.65 232,59.65 232,60.46 232.13,60.58
+3VS on TOP (solid shape): outline of 528 points within 168.26,7.1 174,28.25
+3VS on BOTTOM (solid shape): 326.24,36.19 326.24,35.09 326.06,34.91 325.28,34.91 325.27,34.92 325.16,34.93 325.05,34.92 325.04,34.91 324.81,34.91 324.78,34.95 324.78,36.35 324.85,36.42 326,36.42
+3VS on BOTTOM (solid shape): 302.7,34.02 302.7,33.99 302.72,33.94 302.74,33.89 302.77,33.85 302.81,33.81 302.85,33.78 302.89,33.75 302.94,33.73 303,33.72 303.02,33.71 303.28,33.46 303.28,30.74 302.69,30.16 300.94,30.16 300.15,30.94 300.15,31.43 301.32,31.43 301.32,31.38 301.33,31.32 301.34,31.27 301.37,31.22 301.4,31.18 301.43,31.14 301.48,31.11 301.52,31.08 301.57,31.06 301.62,31.05 301.68,31.05 301.73,31.05 301.78,31.06 301.83,31.08 301.88,31.11 301.92,31.14 301.96,31.18 301.99,31.22 302.01,31.27 302.02,31.32 302.03,31.38 302.03,31.43 302.02,31.48 302.01,31.53 301.99,31.58 301.96,31.63 301.92,31.66 301.88,31.7 301.83,31.72 301.78,31.74 301.73,31.76 301.68,31.76 301.62,31.76 301.57,31.74 301.52,31.72 301.48,31.7 301.43,31.66 301.4,31.63 301.37,31.58 301.34,31.53 301.33,31.48 301.32,31.43 300.15,31.43 300.15,31.44 300.04,31.55 300.04,32.25 300.08,32.29 300.08,33.56 300.53,34.02
+3VS on BOTTOM (solid shape): outline of 83 points within 71.14,1.3 73.51,7.39
+3VS on IN1 (solid shape): 253.66,25.1 253.66,23.21 253.28,22.83 252.05,22.83 251.81,23.07 250.08,23.07 249.64,23.5 249.64,24.25 250.98,24.25 250.98,24.2 250.98,24.14 251,24.09 251.02,24.04 251.05,24 251.09,23.96 251.13,23.93 251.18,23.9 251.23,23.88 251.28,23.87 251.33,23.87 251.39,23.87 251.44,23.88 251.49,23.9 251.53,23.93 251.57,23.96 251.61,24 251.64,24.04 251.66,24.09 251.68,24.14 251.69,24.2 251.69,24.25 251.68,24.3 251.66,24.35 251.64,24.4 251.61,24.44 251.57,24.48 251.53,24.52 251.49,24.54 251.44,24.56 251.39,24.57 251.33,24.58 251.28,24.57 251.23,24.56 251.18,24.54 251.13,24.52 251.09,24.48 251.05,24.44 251.02,24.4 251,24.35 250.98,24.3 250.98,24.25 249.64,24.25 249.64,25.27 250.1,25.73 253.04,25.73
+3VS on IN2 (solid shape): 73.03,7.37 73.28,7.37 73.92,6.74 73.92,6.49 73.85,6.42 73.47,6.42 73.34,6.55 72.96,6.55 72.62,6.89 72.62,7.32 72.78,7.49 72.91,7.49
+3VS on IN2 (solid shape): 67.15,7.51 67.22,7.48 67.25,7.41 67.15,7.33 67.09,7.22 67.03,7.22 66.98,7.25 66.73,7.37 66.47,7.27 66.4,7.24 66.33,7.27 65.74,6.99 66.34,6.74 66.41,6.77 66.48,6.75 66.76,6.66 67.01,6.81 67.09,6.86 67.17,6.82 67.63,6.76 67.76,7.2 67.71,7.31 67.63,7.39 67.65,7.47 67.73,7.51 68.01,7.51 68.21,7.31 68.21,5.9 68.1,5.79 66.9,5.79 66.82,5.84 66.81,5.93 66.48,6.42 66.15,5.93 66.14,5.84 66.06,5.79 64.27,5.79 63.86,6.2 63.86,6.79 64.59,7.51
+3VS on IN3 (solid shape): outline of 1189 points within 300.42,30.72 327.94,40.01
+3VS on IN3 (solid shape): outline of 3438 points within 75.72,6.53 103.7,21.73
+3VS on IN4 (solid shape): 304.37,33.31 304.37,31.48 303.63,30.74 301.62,30.74 301.48,30.83 301.52,31 301.58,31.06 301.62,31.05 301.93,31.66 301.33,31.34 301.33,31.3 301.05,31.02 299.42,31.02 299.29,30.89 299.24,30.89 299.09,30.74 298.75,30.74 298.54,30.95 298.54,32.34 299.33,33.13 299.39,33.13 300.18,33.92 303.76,33.92
+3VS on IN6 (solid shape): outline of 505 points within 62.79,1.3 72.84,5.04
+3VS on TOP: 248.02,9.09 248.03,9.61 247.51,9.6 245.89,11.22 237.36,11.22 236.71,10.57 234.46,10.57 234.27,10.38 233.39,10.38 233.06,10.7 233.06,11.81 230.33,14.53 229.28,14.53 228.73,15.09 228.73,17.96 228.64,18.05 228.21,18.05 228,18.26 228,18.82 228.1,18.92 228.65,18.92 230.18,17.38 230.18,16.92 231,16.1 247.78,16.1 256.68,7.2 256.68,3.88 256.76,3.81 256.76,2.94 256.48,2.66 252.67,2.66 252.1,3.23 252.1,5.01
+3VS on TOP: 75.43,7.82 75.17,7.57 75.12,7.6 74.91,7.65 74.71,7.58 74.61,7.54 74.52,7.58 74.08,7.58 73.97,7.15 73.97,7.02 73.88,6.94 73.63,6.68 73.63,6.17 73.8,6 74.88,6 75.14,6.25 75.72,6.25 75.78,6.19 75.78,5.62 75.65,5.48 71.95,5.48 71.86,5.58 71.86,5.84 72.02,6 72.5,6 72.73,6.23 72.73,6.71 72.51,6.93 71.67,6.93 71.05,7.55 71.05,7.97 70.85,8.17 69.66,8.17 68.52,9.31 68.52,10.05 68.35,10.22 67.86,10.22 67.79,10.29 67.79,12.75 67.88,12.84 68.44,12.84 68.48,12.87 68.49,12.88 68.74,13.17 68.58,13.52 68.54,13.54 68.54,14.4 68.8,14.66 68.8,16.17 67.97,17 67.97,20.52 68.19,20.74 75.4,20.74 76.06,20.07 76.06,18.58 74.6,17.12 74.6,15.53 74.57,15.46 74.5,15.43 74.13,15.07 74.5,14.72 74.57,14.68 74.6,14.61 74.6,14.54 75.41,13.73 75.41,13.2 75.34,13.13 74.86,13.13 74.58,13.41 74.11,13.41 73.72,13.03 74.11,12.64 74.27,12.64 74.71,12.2 75.43,12.2
+3VS on BOTTOM: 15.14,41.09 15.14,39.99 15.49,39.63 15.5,39.63 15.62,39.51 16.36,39.51 16.59,39.74 16.59,40.04 16.37,40.26 16.14,40.26 16.07,40.33 16.07,41.22 16,41.28 15.33,41.28
+3VS on BOTTOM: 202.76,54.86 203.26,55.36 204.25,55.36 204.57,55.04 204.57,54.42 204.27,54.12 200.27,54.12 199.91,54.48 199.91,55.1 200.02,55.22 200.57,55.22 200.92,54.86
+3VS on IN1: 102.53,5.74 102.27,5.99 102.27,6.78 102.61,7.12 103.73,7.12 103.82,7.07 103.82,6.97 104.14,6.45 104.46,6.97 104.46,7.07 104.55,7.12 105.03,7.12 105.12,7.07 105.12,6.97 105.44,6.45 105.75,6.97 105.76,7.07 105.84,7.12 109.36,7.12 110.51,8.27 110.82,8.58 111.24,8.58 111.35,8.47 111.35,6.38 110.71,5.74
+3VS on IN1: 201.32,56.3 205.72,51.9 205.72,50.77 204.93,49.99 204.16,49.99 203.82,50.33 203.82,50.33 199.53,54.62 199.53,55.64 200.19,56.3
+3VS on IN4: 244.82,15.35 244.27,15.9 244.27,18.49 245.85,20.06 245.86,20.07 246.02,20.16 246.11,20.32 246.11,20.33 246.14,20.35 246.14,25.6 246.76,26.22 251.12,26.22 251.52,25.81 253.11,25.81 253.66,25.27 253.66,19.02 251.98,17.34 249.02,17.34 248.86,17.19 248.85,17.18 248.59,16.89 248.76,16.54 248.76,15.73 248.38,15.35
+3VS on VCC: 172.83,8.58 170.6,10.8 115.08,10.8 114.07,9.79 102.6,9.79 100.06,12.33 70.21,12.33 68.45,14.08 68.45,15.27 68.94,15.76 100.99,15.76 104.04,12.71 112.76,12.71 114.3,14.25 114.3,17.43 114.83,16.9 123.85,16.9 126.26,14.49 243.06,14.49 243.84,15.27 243.84,18.32 244.45,18.93 246.28,18.93 247.14,18.06 247.14,12.31 245.64,10.8 177,10.8 174.77,8.58
+3VS_CAM on TOP (solid shape): 61.15,31.7 61.15,31.53 61.36,31.31 62.42,31.31 62.51,31.22 62.51,30.71 62.42,30.62 60.99,30.62 60.73,30.36 60.73,29.96 60.59,29.82 59.79,29.82 59.69,29.92 59.69,31.31 60.3,31.92 60.92,31.92
+3VS_CR on BOTTOM (solid shape): 328.38,35.36 328.38,34.9 328.26,34.78 327.63,34.78 327.22,34.36 326.65,34.36 326.52,34.49 326.52,35.31 326.65,35.44 328.3,35.44
+3VS_CR on BOTTOM (solid shape): 343.46,37.8 343.46,35.96 343,35.51 338.98,35.51 338.9,35.54 338.88,35.61 338.65,35.96 338.25,35.87 338.18,35.83 338.1,35.86 338.01,35.95 337.59,35.95 337.19,36.36 337.19,36.52 337.23,36.56 339.33,36.56 339.42,36.65 339.82,36.65 340,36.83 340,37.44 340.64,38.08 343.19,38.08
+3VS_CR on IN3 (solid shape): outline of 379 points within 326.55,33.68 343.31,36.67
+3VS_FFS on TOP (solid shape): 233.22,54.18 233.94,53.57 234.79,53.16 234.8,53.16 234.85,53.11 234.85,52.12 234.72,51.99 233.77,51.99 233.67,51.89 232.7,51.89 232.44,51.62 232.44,50.75 232.3,50.61 231.58,50.61 231.51,50.67 231.51,51.66 231.28,51.89 230.71,51.89 230.66,51.94 230.66,52.43 230.75,52.52 231.85,52.52 232.06,52.73 232.06,54 232.24,54.18
+3VS_FFS on IN6 (solid shape): outline of 177 points within 227.18,53.3 233.82,58.33
+3VS_TP on TOP (solid shape): 220.6,14.39 220.6,13.63 221.08,13.15 221.43,13.15 222,12.58 222,11.92 221.97,11.9 221.08,11.9 221.01,11.82 221.01,10.46 220.61,10.06 220.61,8.66 220.35,8.4 219.61,8.4 219.43,8.58 219.43,8.61 219.41,8.73 219.34,8.83 219.34,9.04 219.35,9.06 219.41,9.18 219.43,9.32 219.43,9.5 219.41,9.64 219.34,9.78 219.34,10.45 219.11,10.68 219.11,12.73 218.69,13.15 218.69,14.45 218.82,14.58 220.42,14.58
+3VS_TPM on BOTTOM (solid shape): outline of 603 points within 148.56,2.35 160.34,11.36
+3VS_WLAN on TOP (solid shape): 333.5,101.07 333.5,99.84 333.8,99.54 334.68,99.54 335.13,99.09 335.13,95.03 334.21,94.12 332.77,94.12 331.9,94.98 331.9,97.11 332.55,97.76 332.55,101.04 332.67,101.16 333.41,101.16
+3VS_WLAN on BOTTOM (solid shape): outline of 84 points within 325.14,84.37 347.78,95.79
+5V_CHGUSB_1 on TOP (solid shape): 333.99,70.2 333.99,69.5 335.34,68.14 335.34,65.67 335.04,65.36 333.12,65.36 333.03,65.43 333.05,65.54 333.07,66.03 332.58,66.07 331.67,66.07 331.57,66.18 331.57,68.04 332.46,68.93 332.46,70.63 332.7,70.87 333.31,70.87
+5V_CHGUSB_1 on BOTTOM (solid shape): 332.16,68.03 332.16,66.02 332.02,65.88 331.39,65.88 331.28,66 331.28,68.04 331.57,68.33 331.85,68.33
+5V_CHGUSB_1 on IN3 (solid shape): outline of 308 points within 331.03,65.21 337.82,72.4
+5V_CHGUSB_1 on IN5 (solid shape): outline of 281 points within 331.03,65.16 337.82,72.4
+5V_CHGUSB_1 on VCC: 331.45,65.03 330.96,65.52 330.96,69.37 333.99,72.4 338.03,72.4 338.03,67.57 336.57,67.57 334.03,65.03
+5V_CHGUSB_2 on TOP (solid shape): 24.77,93.42 24.77,92.89 24.76,92.88 24.76,92.26 24.76,92.23 24.77,92.18 24.77,91.87 24.68,91.78 23.6,91.78 23.29,92.08 23.29,92.9 23.43,93.04 23.43,93.47 23.57,93.61 24.58,93.61
+5V_CHGUSB_2 on TOP (solid shape): 18.42,108.47 22.67,108.47 22.68,108.46 23.38,108.46 23.67,108.16 23.67,106.49 22.63,105.44 22.18,105.44 22.18,105.42 22.02,105.42 22.02,105.45 21.26,105.45 21.26,105.42 20.39,105.42 20.39,105.49 20.15,105.82 19.77,105.72 19.68,105.68 19.57,105.7 18.92,105.7 18.77,105.85 18.77,106.08 17.02,107.83 16.65,107.83 15.59,107.72 15.62,106.65 15.62,106.18 15.37,105.93 14.35,105.93 14.03,106.24 14.03,107.54 14.1,107.63 14.21,107.61 15.05,107.52 15.29,108.33 15.28,108.35 15.28,108.56 15.57,108.85 18.04,108.85
+5V_CHGUSB_2 on IN1 (solid shape): outline of 261 points within 19.88,91.58 25.36,106.37
+5V_CHGUSB_2 on IN3 (solid shape): outline of 101 points within 14.03,105.55 23.31,109.04
+5V_CHGUSB_2 on IN4 (solid shape): outline of 113 points within 13.98,105.41 23.23,108.71
+5V_CHGUSB_2 on IN5 (solid shape): outline of 110 points within 13.98,105.41 23.23,108.71
+5VALW on TOP (solid shape): 240.89,3.8 240.89,3.13 239.88,2.12 239.28,2.12 239.08,2.32 239.08,3.64 239.29,3.86 240.84,3.86
+5VALW on TOP (solid shape): 243.28,49.55 243.28,48.64 244.35,47.57 244.35,47 244.29,46.94 243.4,46.94 243.33,47 243.33,47.76 243.08,48.01 243.08,49.54 243.14,49.6 243.23,49.6
+5VALW on TOP (solid shape): 316.45,33.85 316.45,33.35 316.36,33.26 314.53,33.26 314.52,33.27 314.35,33.31 314.18,33.27 314.17,33.26 313.97,33.26 313.87,33.36 313.87,33.88 313.96,33.97 315.76,33.97 316.34,33.97
+5VALW on TOP (solid shape): 23.62,89.71 24.6,89.71 24.78,89.53 24.78,89.29 24.76,89.22 24.76,89.16 24.76,88.26 24.84,88.18 24.84,87.26 22.9,87.26 22.68,87.47 22.68,89.11 22.82,89.25 22.82,89.61 22.92,89.71 23.51,89.71
+5VALW on TOP (solid shape): 319.84,7.12 320.07,7.03 320.29,7.12 322.9,7.12 323.06,6.96 323.06,6.29 322.53,6.29 322.53,5.59 323.06,5.59 323.06,5.09 322.53,5.09 322.53,4.39 323.06,4.39 323.06,2.96 322.71,2.61 316.55,2.61 315.98,3.18 315.98,5.66 317.44,7.12
+5VALW on BOTTOM (solid shape): 331.85,62.49 331.85,62.24 332.18,61.91 332.98,61.91 332.98,60.96 332.11,60.08 330.71,60.08 330.45,60.34 330.45,62.21 330.45,62.25 330.44,62.3 330.44,62.58 330.59,62.73 331.61,62.73
+5VALW on IN2 (solid shape): 316.41,34.05 316.41,33.48 316.32,33.39 314.18,33.39 314.12,33.46 314.12,34.05 314.25,34.19 316.28,34.19
+5VALW on IN3 (solid shape): 316.55,34.49 316.55,33.47 316.36,33.28 314.81,33.28 314.67,33.42 314.67,34.01 315.66,35 316.04,35
+5VALW on TOP: 14.19,15.99 14.04,16.14 14.04,17.87 14.27,18.09 14.77,18.09 15.29,18.61 15.87,18.61 16.21,18.95 16.44,18.95 16.55,18.84 16.55,18.57 16.4,18.43 16.2,18.43 15.48,17.71 15.48,14.1 15.48,14.1 15.48,14.03 15.33,13.89 14.28,13.89 14.23,13.94 14.23,13.95 14.19,13.99
+5VALW on TOP: 3.19,35.91 3.19,35.91 3.49,35.6 4.89,35.6 5.04,35.45 5.04,34.44 5.04,33.55 4.92,33.43 3,33.43 2.17,34.26 2.17,35.84 2.33,36 3.11,36
+5VALW on IN4: outline of 997 points within 2.21,1.27 350.29,115.76 ; 1 cut-out
+5VALWP on TOP (solid shape): 331.47,7.82 331.47,3.82 330.26,2.61 323.47,2.61 323.18,2.9 323.18,2.91 323.18,4.52 322.66,4.52 322.66,4.97 323.18,4.97 323.18,5.72 322.66,5.72 322.66,6.17 323.18,6.17 323.18,6.9 323.41,7.12 323.85,7.12 324.87,6.1 327.79,6.1 328.36,6.68 328.36,7.5 328.8,7.95 331.34,7.95
+5VS on TOP (solid shape): 307.48,34.13 307.48,33.4 307.81,33.08 308.14,33.08 308.31,32.91 309.08,32.91 309.14,32.85 309.14,31.45 308.99,31.3 306.99,31.3 306.78,31.51 306.78,32.75 305.65,33.89 305.65,34.44 306.17,34.96 306.65,34.96
+5VS on TOP (solid shape): 95.45,36.93 95.45,36.12 95.64,35.93 96.07,35.93 96.23,35.77 96.23,35.28 96.43,35.08 96.43,34.66 96.6,34.49 98.38,34.49 98.55,34.32 98.55,33.66 98.34,33.45 93.7,33.45 93.5,33.65 93.5,36.23 94.24,36.23 94.24,36.18 94.25,36.12 94.27,36.07 94.29,36.03 94.32,35.98 94.36,35.94 94.4,35.91 94.45,35.88 94.49,35.86 94.55,35.85 94.6,35.85 94.65,35.85 94.71,35.86 94.75,35.88 94.8,35.91 94.84,35.94 94.88,35.98 94.91,36.03 94.93,36.07 94.95,36.12 94.96,36.18 94.96,36.23 94.95,36.28 94.93,36.33 94.91,36.38 94.88,36.43 94.84,36.47 94.8,36.5 94.75,36.53 94.71,36.54 94.65,36.56 94.6,36.56 94.55,36.56 94.49,36.54 94.45,36.53 94.4,36.5 94.36,36.47 94.32,36.43 94.29,36.38 94.27,36.33 94.25,36.28 94.24,36.23 93.5,36.23 93.5,36.89 93.85,37.24 95.15,37.24
+5VS on IN6 (solid shape): 307.33,34.26 307.33,33.57 306.15,32.39 305.46,32.39 304.69,33.17 304.69,33.75 305.74,34.81 306.78,34.81
+5VS on TOP: 18.47,89.15 18.96,89.15 19.24,88.87 19.24,87.72 18.92,87.4 17.11,87.4 16.89,87.63 16.89,89.1 17.17,89.38 18.24,89.38
+5VS on IN1: 136.01,106.1 135.68,106.43 135.68,114.24 136.49,115.05 138.86,115.05 140.17,113.74 140.17,110.96 140.09,110.83 139.94,110.83 139.48,110.75 139.49,110.28 139.51,110.23 139.48,110.18 139.37,109.92 139.47,109.66 139.5,109.61 139.47,109.56 139.48,109.05 139.99,109.07 140.11,109.12 140.22,109.07 140.49,108.95 140.75,109.07 140.87,109.12 140.98,109.06 141.14,108.95 141.33,108.94 141.37,108.94 141.73,108.58 141.73,106.66 141.73,106.66 141.73,106.34 141.49,106.1 140.33,106.1 140.15,106.18 139.95,106.15 139.55,106.25 139.14,106.31 138.86,106.44 138.58,106.3 138.23,106.24 137.89,106.15 137.7,106.18 137.52,106.1
+5VS on VCC: 48.92,17.73 48.92,19.84 48.96,19.88 50.29,19.88 51.37,18.8 56.2,18.8 57.66,20.27 59.37,20.27 59.69,19.95 59.69,19.19 60.07,18.8 78.97,18.8 85.7,25.54 102.09,25.54 103.13,26.57 103.13,32.67 103.87,33.41 107.52,33.41 107.7,33.23 107.7,32.11 110.84,28.96 113.23,28.96 113.59,28.61 113.59,26.47 114.27,25.79 115.85,25.79 116.71,24.92 116.71,20.48 117.75,19.44 127.28,19.44 127.78,18.93 242.72,18.93 243.33,18.32 243.33,15.48 242.85,14.99 126.47,14.99 124.06,17.41 115.04,17.41 113.26,19.19 107.42,19.19 104.63,21.98 88.92,21.98 84.84,17.89 84.84,16.75 84.35,16.26 53.74,16.26 53.62,16.14 50.5,16.14
+5VS on VCC: 16.24,12.33 15.88,12.69 15.88,21.2 11.01,26.07 11.87,30.4 7.62,31.6 7.62,39.27 9.27,40.92 9.27,44.53 14.62,44.53 15.87,45.05 16.39,46.3 16.39,57.45 16.35,57.82 16.23,58.17 17.65,59.59 17.65,87.49 16.89,88.25 16.89,89.31 17.25,89.67 18.69,89.67 19.43,88.93 19.43,78.9 19.94,78.39 19.94,58.24 17.27,55.57 17.27,34.3 19.94,31.63 19.94,24.16 30.86,13.24 30.86,12.63 30.56,12.33
+5VS on IN6: 47.5,19.95 49.79,19.95 49.91,19.82 49.91,19.57 49.28,18.93 47.31,18.93 47.05,19.19 47.05,19.5
+5VS on IN6: 242.06,15.88 241.63,16.31 241.63,18.25 242.7,19.31 253.81,19.31 254.32,19.82 254.32,21.09 255.08,21.85 257.11,21.85 258.32,23.06 261.37,23.06 262,22.42 262,20.96 259.74,18.7 259.64,18.68 259.57,18.75 259.07,19.01 258.95,18.46 258.97,18.39 258.95,18.33 258.86,18.11 258.93,17.89 256.92,15.88 255.76,15.88 255.68,15.92 255.66,16 255.31,16.42 254.96,16 254.93,15.92 254.86,15.88 246.86,15.88 246.67,15.94 246.49,15.88 246.22,15.88 246.04,15.94 245.85,15.88 245.64,15.88 245.45,15.94 245.27,15.88
+5VS on IN6: 28.64,13.28 30.54,13.28 30.8,13.03 30.8,12.33 30.61,12.14 28.83,12.14 28.58,12.39 28.58,13.22
+5VS_HDD on TOP (solid shape): 239.93,10.57 239.93,9.94 239.8,9.81 239.51,9.81 239.38,9.69 239.38,9.18 239.47,9.09 239.72,9.09 239.79,9.01 239.79,8.25 239.71,8.17 238.24,8.17 237.99,7.91 237.28,7.91 237.17,8.03 237.17,8.44 237.25,8.53 237.25,9.58 237.25,9.58 237.25,10.68 237.45,10.87 239.62,10.87
+5VS_HDD on BOTTOM (solid shape): 240.26,13.43 240.26,11.66 240.04,11.44 238.76,11.44 238.48,11.16 238.48,9.94 238.76,9.66 239.02,9.66 239.08,9.6 239.08,9.15 238.95,9.03 237.49,9.03 237.36,9.15 237.36,9.62 237.22,9.76 237.22,11.37 236.43,12.16 236.43,12.78 236.54,12.89 238.96,12.89 239.21,13.13 239.21,13.49 239.29,13.57 240.13,13.57
+VBUS_1 on TOP (solid shape): 5.08,32.75 5.08,31.63 4.78,31.33 3.46,31.33 2.97,30.84 2.97,27.95 2.87,27.85 2.34,27.85 2.21,27.97 2.21,32.7 2.36,32.85 4.98,32.85
+VBUS_1 on BOTTOM (solid shape): 4.28,31.91 4.28,30.86 4.17,30.75 4.17,28.58 3.72,28.13 3.64,28.05 3.34,28.05 3.12,27.83 2.26,27.83 2.17,27.92 2.17,31.77 2.37,31.96 4.22,31.96
+VBUS_1 on TOP: 8.94,67.36 8.73,67.36 8.64,67.27 6.82,67.27 6.71,67.37 6.39,67.37 6.19,67.17 6.19,66.86 6.4,66.65 6.69,66.65 6.89,66.85 8.87,66.85 9.06,67.04 9.06,67.24
+VBUS_1 on TOP: 8.91,64.87 8.71,64.87 8.62,64.78 6.95,64.78 6.75,64.97 6.37,64.97 6.19,64.79 6.19,64.47 6.39,64.26 6.75,64.26 6.82,64.32 8.84,64.32 9.04,64.52 9.04,64.73
+VBUS_1 on BOTTOM: 11.76,59.43 10.92,60.27 10.92,61.43 10.95,61.5 11.01,61.53 11.31,61.86 11.01,62.19 10.95,62.22 10.92,62.29 10.92,62.47 11,62.59 11.03,62.74 11.03,63 10.92,63.11 10.92,63.13 9.65,64.39 8.53,64.39 8.41,64.52 8.41,64.58 7.6,64.58 7.6,64.57 6.31,64.57 6.22,64.65 6.22,64.75 6.24,64.77 6.38,64.91 7.11,64.91 7.37,65.16 7.37,66.3 6.99,66.68 6.44,66.68 6.22,66.9 6.22,67.15 6.35,67.29 8.52,67.29 8.61,67.38 8.61,67.81 9,68.2 9.41,68.2 9.72,67.89 9.72,67.17 10.61,66.28 12.72,66.28 13.07,65.93 13.07,65.18 15.18,63.07 17.28,63.07 17.34,63 17.34,60.64 16.65,59.95 15.92,59.95 15.39,59.43
+VBUS_1 on IN1: outline of 99 points within 2.17,23 19.94,70.65
+VBUS_1 on IN4: 7.19,59.22 6.74,59.67 6.74,60.69 6.95,61 6.96,61.38 6.99,61.47 7.08,61.5 7.6,61.63 7.84,62.12 7.84,62.3 7.62,62.77 7.12,62.93 7.05,62.95 7.01,63.02 6.82,63.38 6.42,63.45 6.34,63.46 6.29,63.52 6.29,63.53 6.24,63.64 6.17,63.74 6.14,63.81 6.17,63.88 6.29,64.1 6.29,64.35 6.24,64.45 6.17,64.54 6.14,64.61 6.17,64.68 6.24,64.78 6.29,64.89 6.29,64.9 6.34,64.96 6.42,64.97 6.95,65.18 6.87,65.74 6.84,65.81 6.87,65.88 6.98,66.06 7,66.27 6.8,66.59 6.34,66.66 6.29,66.72 6.25,66.84 6.17,66.94 6.14,67.01 6.17,67.08 6.24,67.17 6.29,67.27 6.29,67.52 6.17,67.74 6.14,67.81 6.17,67.88 6.22,67.94 6.26,68.01 16.65,68.01 17.89,66.77 17.89,60.63 16.8,59.54 14.54,59.54 14.22,59.22
