# Allegro board LA-C361P R10-0731.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM: 47.44,6.42 48.32,6.42 48.64,6.1 48.64,5.98 48.71,5.91 53.71,5.91 53.91,5.72 53.91,4.56 53.78,4.43 52.5,4.43 52.07,4.01 52.07,1.6 51.94,1.47 49.85,1.47 49.71,1.61 49.71,1.9 49.85,2.04 49.85,2.74 49.66,2.93 47.44,2.93 47.25,3.12 47.25,6.23
GND on BOTTOM: outline of 119 points within 7.06,36.1 10.35,40.09
GND on BOTTOM: 12.37,66.48 10.6,66.48 9.86,67.23 9.86,67.81 10.39,68.34 12.04,68.34 12.5,67.88 12.5,66.61
GND on GND1, GND2, GND3: outline of 328 points within 0.2,0.2 352.5,122.6
GND on IN2: outline of 182 points within 191.72,57.76 247.22,114.44
GND on IN2: outline of 364 points within 132,19.5 250.17,67.5
GND on IN4: outline of 318 points within 114.19,19.48 251.02,67.57
GND on VCC: 331.2,70.87 330.96,71.11 330.96,98.46 331.96,99.45 339.2,99.45 339.6,99.85 339.6,101.21 339.07,101.74 331.2,101.74 330.96,101.97 330.96,113.7 332.85,115.58 348.98,115.58 349.51,116.11 349.51,116.83 348.98,117.36 333.62,117.36 332.89,117.95 332.15,117.36 323.23,117.36 323.23,118.93 327.7,118.93 328.37,119.35 328.82,120 340.78,119.99 343.3,117.58 345.62,120.17 345.62,121.53 349.83,121.53 349.83,117.76 349.96,117.08 350.35,116.51 350.53,116.32 350.53,116.08 350.35,115.89 349.96,115.32 349.83,114.64 349.83,111.06 349.88,110.63 350.03,110.24 349.03,108.59 350.13,107 350.13,106.98 349.03,105.34 350.13,103.7 350.13,103.38 349.03,101.74 350.13,100.1 350.13,99.78 349.03,98.14 350.13,96.5 350.13,96.18 349.03,94.54 350.13,92.9 350.13,92.58 349.04,91.11 349.83,89.46 349.83,81.27 341.03,81.27 339.11,81.63 338.03,80 338.03,72.91 333.78,72.91 331.75,70.87
GND on VCC: outline of 101 points within 43.44,11.95 189.5,120.48
GND on VCC: 15.88,1.27 15.88,11.46 16.24,11.82 31.01,11.82 41.56,1.27
GND on VCC: 6.52,1.27 4.98,3.62 2.17,3.42 2.17,12.39 2.04,13.07 1.65,13.64 1.27,14.03 1.27,20.37 1.65,20.76 2.04,21.33 2.17,22.01 2.17,25.54 4.72,25.54 5.84,24.41 5.84,23.4 9.53,19.72 9.53,1.27
GND on VCC: 15.95,58.61 15.35,59.06 14.62,59.22 2.17,59.22 2.17,74.81 8.32,74.81 10.8,74.83 10.82,77.31 10.82,90.55 10.8,93.03 8.32,93.05 2.17,93.05 2.17,94.88 10.97,94.88 12.89,94.52 13.97,96.15 13.97,110.25 13.76,111.09 13.17,111.73 28,111.73 28.52,111.52 28.73,111 28.73,110.77 27.42,111.31 26.38,110.34 26.29,109.97 27.11,108.43 28.73,109.07 28.73,107.9 26.58,105.5 28.73,103.1 28.73,78.75 20.3,78.75 19.94,79.11 19.94,89.14 18.9,90.18 17.04,90.18 16.38,89.52 16.38,88.04 17.15,87.28 17.15,59.8
GND on VCC: 337.01,1.27 336.93,1.49 336.82,1.7 339.73,4.6 339.73,27.99 346.15,28.7 339.73,29.41 339.73,36.35 341.23,37.85 344.15,37.85 346.08,39.78 346.08,58.15 344.78,59.44 332.47,59.44 330.96,60.95 330.96,64.8 331.24,64.52 334.24,64.52 336.78,67.06 338.03,67.06 338.03,65.9 339.11,64.27 341.03,64.63 349.83,64.63 349.83,63.6 350.28,62.31 351.43,61.58 351.43,34.62 350.28,33.89 349.83,32.6 349.83,4.72 346.27,4.83 346.17,1.27
GND on IN5: outline of 823 points within 105.16,1.27 351.43,121.53
GND on IN5: outline of 488 points within 192.78,61.53 246.61,111.9
GND on IN6: 20.33,39.21 18.87,39.21 18.36,38.7 18.36,37.49 18.46,37.39 18.9,37.39 19.04,37.26 19.04,36.22 18.91,36.1 18.55,36.1 18.39,35.94 18.39,35.81 18.53,35.67 20.14,35.67 20.57,36.1 20.57,37.38 20.58,37.39 20.58,38.96
GNDA_CHG on BOTTOM (solid shape): 54.84,18.73 55.27,18.73 55.27,19.26 55.87,19.26 56.39,18.74 56.96,18.74 57.18,18.53 57.18,17.94 57.34,17.77 57.34,15.35 57.56,15.13 57.94,15.13 58.21,14.85 58.28,14.85 58.61,14.53 58.61,12.52 58.42,12.33 58.04,12.33 57.91,12.45 57.91,13.22 58.1,13.41 58.1,13.64 58.03,13.72 57.97,13.79 57.91,13.84 57.41,14.33 56.83,14.33 56.11,15.06 53.02,15.06 52.95,15.13 52.95,17.84 54.37,19.26 54.84,19.26
VBATT on BOTTOM: 24.6,21.34 24.61,21.35 24.45,21.97 24.07,21.45 24.08,21.37 24.03,21.31 23.99,21.29 23.95,21.26 21.16,21.26 21.09,21.33 21.09,22.49 21.15,22.55 21.76,22.55 21.95,22.74 21.95,24.69 22.89,25.64 22.89,25.77 22.93,25.82 26.25,25.82 26.49,25.58 26.49,23.57 26.49,23.17 26.37,22.68 26.86,22.57 26.87,22.57 27.03,22.57 27.14,22.47 27.14,20.03 27.07,19.96 24.79,19.96 24.73,20.02 24.73,20.9 24.6,21.04
VCC0V9_LVR_OUT on TOP (solid shape): 22.52,41.34 22.52,39.18 22.51,39.17 22.65,38.76 23.07,38.82 23.14,38.85 23.21,38.82 23.62,38.76 23.77,39.14 23.76,39.17 23.94,39.34 24.31,39.34 24.52,39.56 24.52,40.46 25.34,41.28 26.12,41.28 26.33,41.07 26.33,40.74 26.28,40.66 26.19,40.65 25.98,40.67 25.81,40.56 25.73,40.53 25.66,40.56 25.18,40.58 25.18,40.1 25.18,38.3 25.02,38.13 22.83,38.13 22.83,38.13 22.64,38.13 22.47,37.96 21.94,37.96 21.86,38.04 21.86,41.3 21.95,41.39 22.46,41.39
VCC0V9_LVR_OUT on IN4 (solid shape): 26.37,41.16 26.37,40.77 26.28,40.67 26.04,40.67 26,40.67 25.47,40.67 25.41,40.67 25.27,40.67 25.17,40.58 25.08,40.47 25.08,39.49 25.67,38.89 25.67,38.4 25.24,37.96 24.44,37.96 24.31,38.1 23.93,38.1 23.85,38.18 23.85,38.78 23.92,38.85 24.22,38.85 24.45,39.09 24.45,40.67 24.63,40.85 24.82,40.85 25.21,41.24 26.29,41.24
VCC0V9_SVR on TOP (solid shape): outline of 234 points within 21.53,39.46 26.95,48.22
VCC0V9_SVR on BOTTOM (solid shape): 27.17,42.07 27.17,41.62 27.09,41.54 27.06,41.55 26.93,41.52 26.83,41.43 26.61,41.43 26.45,41.6 26.3,41.6 26.18,41.47 26.18,41.46 26.13,41.41 25.99,41.41 25.83,41.56 25.64,41.56 25.58,41.62 25.58,42.07 25.65,42.13 27.11,42.13
VCC0V9_SVR on BOTTOM (solid shape): 22.25,50.94 22.25,50.79 21.79,50.45 22.25,50.11 22.25,47.76 22.73,47.28 22.73,46.48 22.57,46.31 22.27,46.31 21.78,46.81 21.75,46.83 21.73,46.86 21.27,47.31 21.25,47.32 20.64,47.32 20.64,47.32 20.58,47.32 20.43,47.47 20.43,49.78 20.6,49.94 20.6,51.08 20.65,51.14 22.05,51.14
VCC0V9_SVR on BOTTOM (solid shape): 24.5,41.43 24.55,41.39 24.63,41.3 24.63,39.14 24.44,38.95 24.42,38.95 24.32,38.92 24.24,38.85 24.23,38.83 23.99,38.83 23.96,38.86 23.93,38.9 23.88,38.93 23.88,39.12 24.02,39.26 24.02,39.47 23.83,39.67 23.83,39.8 23.65,39.97 23.65,40.08 23.79,40.37 23.62,40.63 23.62,40.92 23.78,41.09 23.8,41.09 23.85,41.1 23.9,41.12 23.97,41.18 24.01,41.27 24.01,41.29 24.05,41.32 24.07,41.32 24.23,41.34 24.36,41.43
VCC0V9_SVR on IN2: 26.93,41.44 26.8,41.31 26.76,41.32 26.66,41.32 26.56,41.29 26.55,41.28 26.23,41.28 26.21,41.29 26.05,41.34 25.89,41.29 25.87,41.28 25.57,41.28 25.54,41.29 25.4,41.32 25.26,41.29 25.17,41.23 25.12,41.17 25.06,41.11 25.06,40.85 25.07,40.84 25.07,39.25 24.46,38.64 24.3,38.64 24.28,38.65 24.01,38.69 23.81,38.52 23.8,38.5 23.66,38.37 21.43,38.37 21.14,38.66 21.14,39.46 21.16,39.48 21.16,41.11 21.51,41.46 21.51,43.73 21.67,43.89 21.67,44.78 21.71,44.8 21.85,45.15 21.58,45.41 21.55,45.41 21.51,45.46 21.51,45.9 21.52,45.96 21.57,45.99 21.88,46.03 22.02,46.31 21.91,46.58 21.63,46.65 21.54,46.67 21.51,46.75 21.51,47.25 21.62,47.36 23.22,47.36 23.49,47.1 23.49,43.27 23.15,42.82 23.71,42.73 23.78,42.76 23.86,42.73 23.97,42.64 24.1,42.61 24.24,42.64 24.36,42.73 24.43,42.76 24.51,42.72 24.69,42.62 24.9,42.64 24.95,42.66 24.96,42.65 26.28,42.65 26.93,42.01
VCC0V9_SVR on IN4: 23.19,39.32 22.37,40.14 22.37,42.31 21.53,43.15 21.53,44.75 21.86,45.08 21.53,45.41 21.53,45.87 21.56,45.95 21.64,45.97 22.02,46.3 21.64,46.63 21.56,46.65 21.53,46.73 21.53,47.25 21.65,47.38 23.23,47.38 23.37,47.24 23.37,47.23 23.61,47 23.61,46.11 23.92,45.8 23.92,44.52 23.79,44.33 23.82,44.1 23.83,44.09 23.83,43.28 23.77,43.19 23.66,43.2 23.13,42.92 23.71,42.73 23.78,42.76 23.86,42.73 23.93,42.67 23.97,42.64 24,42.61 24.08,42.61 24.45,42.24 25.7,42.24 25.76,42.29 26.88,42.29 26.99,42.19 26.99,41.48 26.86,41.35 25.18,41.35 25.17,41.34 24.79,40.96 24.6,40.96 24.59,40.95 24.35,40.71 24.33,40.69 24.33,39.55 24.1,39.32 23.79,39.32 23.7,39.38 23.71,39.49 23.79,39.72 23.68,39.94 23.64,40.02 23.68,40.1 23.46,40.68 23.24,40.1 23.27,40.02 23.24,39.94 23.13,39.67 23.28,39.41 23.31,39.4 23.31,39.34 23.27,39.32
VCC3V3_FLASH on BOTTOM: 12.09,40.98 11.83,41.24 11.83,43.12 13.22,44.51 13.8,44.51 13.97,44.33 13.97,43.64 12.76,42.42 12.76,41.85 13,41.6 13.4,41.6 13.45,41.55 13.45,41.06 13.4,41.01 12.92,41.01 12.88,40.97 12.17,40.97 12.16,40.98
VCC3V3_FLASH on BOTTOM: 15.37,25.79 14.86,25.79 14.1,26.55 12.45,26.55 12.32,26.68 12.32,27.44 12.7,27.82 15.11,27.82 15.5,27.44 15.5,25.92
VCC3V3_FLASH on IN5: 18.24,39.34 18.24,35.77 18.47,35.54 18.75,35.54 18.91,35.38 18.91,34.97 18.68,34.73 14.84,34.73 14.51,35.06 14.51,35.43 14.2,35.74 13.46,35.74 12.85,36.36 12.85,36.41 12.82,36.59 12.69,36.73 12.63,36.8 12.63,36.9 12.7,37.02 12.73,37.16 12.65,37.39 12.43,37.52 12.14,37.44 12.01,37.16 12.02,37.1 12.03,37.04 11.99,36.93 11.88,36.89 11.14,36.89 10.88,37.14 10.88,40.97 11.5,41.59 15.71,41.59 16.75,40.54
VCC5V0_SYS on TOP: 2.95,42.75 3.73,43.53 5.59,43.53 5.59,43.53 6.05,43.53 6.3,43.27 6.3,41.63 5.58,40.91 5.58,38.81 5.14,38.37 5.14,36.16 4.96,35.99 3.39,35.99 3.36,36.02 3.36,36.74 2.95,37.16
VCC5V0_SYS on BOTTOM: 6.11,38.85 6.06,38.9 5.68,38.9 5.4,39.18 4.45,39.18 4.26,39.37 4.26,43.52 4.26,43.53 4.26,43.82 4.34,43.9 6.1,43.9 6.31,43.69 6.31,43.11 6.18,42.98 6.18,42.35 6.31,42.22 6.31,41.46 6.02,41.17 6.02,40.78 6.38,40.42 6.38,39.58 6.43,39.54 6.43,38.88 6.4,38.85
VCCGT_B+ on BOTTOM (solid shape): 107.7,85.86 107.7,83.61 107.32,83.23 107.32,80.46 106.81,79.96 106.81,78.81 106.82,78.8 106.82,78.78 106.92,78.5 107.2,78.39 107.22,78.4 107.25,78.37 107.51,78.37 107.51,78.37 107.78,78.37 107.9,78.25 107.9,77.77 107.15,77.02 107.15,75.99 106.55,75.39 106.55,72.72 106.05,72.21 106.05,71.32 106.55,70.81 106.69,70.81 107.51,69.99 109.03,69.99 109.16,69.86 109.16,68.59 109.03,68.46 106.17,68.46 105.67,68.97 105.67,70.97 105.79,71.1 105.79,72.14 105.05,72.88 105.05,77.12 106.1,78.16 106.1,78.48 106.43,78.81 106.43,78.87 106.52,78.97 106.52,79.8 105.92,80.4 105.92,85.86 106.05,85.99 107.57,85.99
VCCGT_B+ on IN3 (solid shape): 107.67,85.86 107.67,83.6 107.29,83.22 107.29,80.45 106.78,79.94 106.78,78.62 107.06,78.34 107.72,78.34 107.87,78.19 107.87,77.76 107.09,76.97 107.09,76.01 106.48,75.4 106.48,72.68 106.02,72.22 106.02,71.43 107.54,69.91 108.71,69.91 108.99,69.63 108.99,69 108.46,68.46 106.27,68.46 105.64,69.1 105.64,70.98 105.74,71.08 105.74,72.2 105.08,72.86 105.08,77.12 106.5,78.55 106.5,79.84 105.92,80.43 105.92,85.91 106.02,86.01 107.52,86.01
VCCGT_B+ on IN4 (solid shape): 107.67,85.86 107.67,83.6 107.29,83.22 107.29,80.45 106.78,79.94 106.78,78.62 107.06,78.34 107.72,78.34 107.87,78.19 107.87,77.76 107.09,76.97 107.09,76.01 106.48,75.4 106.48,72.68 106.02,72.22 106.02,71.43 107.54,69.91 108.71,69.91 108.99,69.63 108.99,69 108.46,68.46 106.27,68.46 105.64,69.1 105.64,70.98 105.74,71.08 105.74,72.2 105.08,72.86 105.08,77.12 106.5,78.55 106.5,79.84 105.92,80.43 105.92,85.91 106.02,86.01 107.52,86.01
VCCGT_B+ on IN6 (solid shape): 107.67,85.86 107.67,83.6 107.29,83.22 107.29,80.45 106.78,79.94 106.78,78.62 107.06,78.34 107.72,78.34 107.87,78.19 107.87,77.76 107.09,76.97 107.09,76.01 106.48,75.4 106.48,72.68 106.02,72.22 106.02,71.43 107.54,69.91 108.71,69.91 108.99,69.63 108.99,69 108.46,68.46 106.27,68.46 105.64,69.1 105.64,70.98 105.74,71.08 105.74,72.2 105.08,72.86 105.08,77.12 106.5,78.55 106.5,79.84 105.92,80.43 105.92,85.91 106.02,86.01 107.52,86.01
VCCGT_B+ on TOP: outline of 83 points within 103.32,68.39 110.43,86.43
+AC_IN on BOTTOM: 25.02,55.72 24.95,55.79 24.95,57.24 24.69,57.51 24.25,57.51 23.55,58.2 21.85,58.2 21.49,58.56 21.49,60.28 21.48,60.29 21.48,60.33 21.44,60.33 21.42,60.35 20.97,60.35 20.87,60.45 20.87,60.49 20.87,60.65 20.79,60.78 20.79,62.57 20.44,62.93 20.08,62.57 20.08,61.24 20.04,61.2 19.82,61.2 19.74,61.19 19.67,61.16 19.67,61.15 19.43,60.92 19.43,59.9 19.28,59.75 19.28,58.13 18.97,57.82 18.4,57.82 18.28,57.93 18.28,59.59 18.47,59.77 18.47,59.78 19.03,60.33 19.03,61.05 18.91,61.16 18.11,61.16 17.93,61.34 17.93,63.24 18.04,63.35 18.73,63.35 18.86,63.48 19.5,63.48 19.5,63.49 21.97,63.49 22.21,63.25 22.21,61.3 22.21,61.29 22.58,60.92 22.58,60.43 22.76,60.25 22.76,60.25 22.91,60.11 24.18,60.11 24.31,59.98 24.31,58.86 24.88,58.3 24.97,58.3 25.7,57.56 25.7,55.78 25.64,55.72
+AC_IN on IN1: 26.32,64.44 26.44,64.4 26.72,64.12 26.72,61.83 26.29,61.4 19.38,61.4 18.67,62.11 18.67,63.26 20.11,64.7 20.13,64.7 20.27,64.84 23.24,64.84 23.38,64.7 25.4,64.7 25.51,64.66 25.55,64.55 25.81,64.22 26.21,64.37
+CLK_PLLVDD on TOP (solid shape): 207.81,71.93 207.81,71.38 206.92,70.49 206.92,69.13 207.49,68.56 207.53,68.56 207.53,66.32 207.34,66.13 207.34,65.32 207.25,65.24 207.19,65.24 206.88,64.92 206.88,64.91 206.57,64.59 206.57,63.45 206.38,63.25 204.53,63.25 204.48,63.31 204.48,64.69 206.43,66.63 206.43,66.81 206.87,67.26 206.87,68.51 206.29,69.1 206.29,71.58 206.95,72.25 207.49,72.25
+CLK_PLLVDD on BOTTOM (solid shape): 207.52,71.3 207.52,70.33 207.34,70.15 207.34,69.41 207.92,68.82 207.92,68.35 207.84,68.27 207.56,68.27 207.33,68.04 206.98,68.04 206.87,68.15 206.87,68.46 206.91,68.46 207.14,68.77 206.87,69.04 206.44,69.47 206.44,70.4 206.22,70.62 206.22,71.24 206.44,71.46 207.36,71.46
+DC_IN on BOTTOM (solid shape): 22.48,88.53 22.48,86.81 22.4,86.74 21.89,86.74 21.72,86.91 21.72,88.55 21.82,88.65 22.35,88.65
+DC_IN on BOTTOM (solid shape): 18.26,77.22 18.26,70.14 18.1,69.99 16.67,69.99 16.45,69.77 16.45,68.34 16.22,68.11 14.54,68.11 14.07,68.59 14.07,70.56 14.07,77.12 14.2,77.25 15.15,77.25 15.96,78.06 17.41,78.06
+DC_IN_SS on BOTTOM (solid shape): 20.76,69.14 20.76,66.89 20.41,66.54 18.3,66.54 18.04,66.28 18.04,65.48 17.84,65.29 14.66,65.29 14.6,65.35 14.6,66.06 14.69,66.16 14.69,67.67 14.86,67.84 17.03,67.84 17.04,67.85 17.35,67.85 17.65,68.15 17.65,68.84 18.04,69.23 20.66,69.23
+EDPVDD on TOP (solid shape): 59.35,33.32 65.15,33.32 65.48,32.99 65.48,32.1 65.36,31.97 65.23,32.05 64.74,31.96 64.77,31.45 64.83,31.38 64.83,30.17 64.62,29.96 63.77,29.96 63.66,30.07 63.66,31.22 63.64,31.31 63.7,31.37 63.85,31.9 63.3,31.95 63.23,31.92 63.16,31.95 62.74,32 62.57,31.61 62.55,31.52 62.47,31.48 61.49,31.48 61.41,31.57 61.41,31.79 60.98,32.21 59.59,32.21 59.44,32.36 54.01,32.36 54.01,32.36 53.18,32.36 52.36,31.54 51,31.54 48.22,28.76 47.42,28.76 47.3,28.87 46.46,28.87 46.35,28.76 45.67,28.76 45.58,28.85 45.58,30.12 45.78,30.33 48.15,30.33 50.5,32.68 51.38,32.68 52.19,33.5 59.18,33.5
+EDPVDD on BOTTOM (solid shape): 62.69,33.31 62.69,32.28 62.51,32.1 62.51,31.53 62.4,31.42 61.58,31.42 61.43,31.56 61.43,33.3 61.52,33.38 62.62,33.38
+FBA_DLL_AVDD on TOP (solid shape): 230.86,96.15 230.86,95.47 230.14,94.75 225.67,94.75 224.97,95.45 224.97,96.03 225.14,96.21 229.46,96.21 229.49,96.24 230.77,96.24
+FBA_DLL_AVDD on IN4 (solid shape): outline of 329 points within 218.76,84.65 223.2,91.1
+FBA_PLL_AVDD on IN4 (solid shape): outline of 841 points within 212.8,84.54 218.58,88.91
+FBA_VREFD_H on TOP (solid shape): 207.67,111.2 207.67,107.91 207.56,107.79 206.61,107.79 206.33,108.07 206.33,110.53 207.1,111.3 207.57,111.3
+GPU_CORE on TOP (solid shape): 184.21,99.02 184.21,97.09 184.15,97.02 183.58,97.02 183.33,96.77 183.33,96.15 183.07,95.89 180.99,95.89 180.73,96.15 180.73,99.4 180.79,99.45 183.78,99.45
+GPU_CORE on TOP (solid shape): 187.29,119.29 194.99,119.29 195.23,119.06 195.23,114.69 194.82,114.28 192.1,114.28 191.26,113.44 191.26,97.48 190.63,96.85 186.09,96.85 185.74,97.2 185.74,98.9 185.9,99.07 185.9,119.01 186.21,119.31 187.27,119.31
+GPU_CORE on TOP (solid shape): outline of 386 points within 207.81,72.27 219.98,84.57
+GPU_CORE on BOTTOM (solid shape): 195.01,119.2 195.01,113.55 194.63,113.17 193.29,113.17 191.26,111.13 191.26,96.73 189.52,94.99 185.81,94.99 185.32,94.5 180.98,94.5 180.73,94.74 180.73,97.23 180.86,97.35 180.86,97.41 181.18,97.72 184.63,97.72 184.65,97.74 185.09,97.74 185.47,97.86 185.5,98.26 185.5,98.67 186.88,100.05 186.88,118.88 187.29,119.29 194.91,119.29
+GPU_CORE on IN1 (solid shape): 194.72,119.03 194.72,114.64 191.24,111.16 191.24,97.65 189.54,95.94 182.6,95.94 182.25,96.3 182.25,97.98 182.47,98.21 184.86,98.21 185.26,97.73 185.46,98.32 185.46,98.7 186.87,100.11 186.87,118.98 187.17,119.29 194.46,119.29
+GPU_CORE on IN2 (solid shape): 194.72,119.03 194.72,116.11 191.24,112.63 191.24,97.65 189.54,95.94 182.6,95.94 182.25,96.3 182.25,97.98 182.47,98.21 184.86,98.21 185.25,97.73 185.47,98.31 185.47,98.71 186.87,100.11 186.87,118.98 187.17,119.29 194.46,119.29
+GPU_CORE on IN4 (solid shape): 194.72,119.03 194.72,114.64 191.24,111.16 191.24,97.65 189.54,95.94 182.6,95.94 182.25,96.3 182.25,97.98 182.47,98.21 184.66,98.21 184.84,98.02 185.3,97.74 185.51,98.24 185.51,98.75 186.87,100.11 186.87,118.98 187.17,119.29 194.46,119.29
+GPU_CORE on IN5 (solid shape): 194.72,119.03 194.72,114.64 191.24,111.16 191.24,97.65 189.54,95.94 182.6,95.94 182.25,96.3 182.25,97.98 182.47,98.21 184.68,98.21 184.79,98.16 184.84,98.06 185.37,97.77 185.39,98.37 185.32,98.49 185.37,98.61 186.87,100.11 186.87,118.98 187.17,119.29 194.46,119.29
+GPU_CORE on IN6 (solid shape): outline of 7371 points within 181.36,69.92 219.44,119.03
+GPU_CORE on IN3: outline of 366 points within 182.02,69.93 236.6,119.02
+GPU_CORE on VCC: 175.75,60.46 175.52,60.69 175.52,84.7 173.48,86.73 173.48,93.46 172.25,94.69 168.76,94.69 167.2,96.25 167.2,105.16 167.24,105.16 167.62,105.55 169.21,105.55 170.05,106.39 170.05,119.63 171.79,119.63 172.47,119.76 173.04,120.15 173.38,120.48 187.33,120.48 187.33,99.98 190.9,96.4 196.36,96.4 200.15,92.61 200.15,85.63 201.57,84.21 214.65,84.21 215.52,83.34 215.52,60.71 190.67,60.71 190.42,60.46 188.56,60.46 187.78,60.56 187,60.46
+INV_PWR_SRC on BOTTOM (solid shape): 53.16,33.3 53.16,32.27 53.53,31.9 53.53,31.58 53.57,31.54 53.62,31.48 53.67,31.42 54.1,30.99 54.1,29.84 53.67,29.41 53.67,28.15 52.03,26.51 52.03,25.31 51.94,25.21 51.89,25.24 51.46,25.18 51.4,24.76 51.43,24.7 51,24.28 51,24.06 50.86,23.92 47.25,23.92 47.06,24.11 47.06,25.65 50.03,28.62 50.28,28.62 51.63,29.97 51.63,30.08 52,30.7 51.63,31.32 51.63,33.28 51.75,33.41 53.05,33.41
+ODR_PWR on TOP (solid shape): 326.37,50.84 328.14,50.84 328.31,50.67 328.31,49.72 327.88,49.28 324.68,49.28 324.3,49.67 324.3,50.94 324.63,51.27 325.95,51.27
+ODR_PWR on IN3 (solid shape): 330.06,51.47 330.29,51.16 330.66,51.23 330.69,51.25 330.73,51.23 332.36,49.6 332.36,45.16 331.28,44.08 330.07,44.08 329.57,44.59 329.57,48.27 328.55,49.28 325.5,49.28 325.06,49.73 324.55,49.73 324.23,50.05 324.23,51 324.8,51.57 329.96,51.57
+ODR_PWR on IN6 (solid shape): 332.11,44.01 332.11,43.51 331.79,43.19 331.22,43.19 331.03,43.38 331.03,43.7 330.71,44.01 329.82,44.01 329.63,44.2 329.63,44.78 329.88,45.03 331.09,45.03
+ODR_PWR on IN6 (solid shape): 332.3,36.9 332.3,35.7 331.53,34.93 330.2,34.93 330.01,35.12 330.01,35.63 330.2,35.82 331.09,35.82 331.22,35.95 331.22,36.58 331.09,36.71 331.09,37.09 331.22,37.22 331.98,37.22
+PLLVDD on TOP (solid shape): 210.15,70.24 210.29,70.24 210.92,69.6 210.92,66.43 210.59,66.1 209.6,66.1 209.52,66.18 209.52,69.76 208.79,70.49 208.19,70.49 208.13,70.56 208.13,71 208.19,71.07 209.33,71.07
+PWR_SRC_AC on BOTTOM: 55.79,7.22 55.56,6.99 55.25,6.99 55.06,7.18 55.06,8.64 54.8,8.9 54.29,8.9 54.04,8.64 54.04,7.12 53.98,7.06 52.39,7.06 51.88,7.57 51.88,10.17 52.16,10.45 53.71,10.45 54.62,9.53 55.56,9.53 55.79,9.31
+RTCVCC on TOP (solid shape): 96.56,5.33 96.56,4.17 96.43,4.05 95.94,4.05 95.78,4.2 95.78,4.35 95.68,4.45 94.82,4.45 94.64,4.28 94.64,4.1 94.49,3.95 93.9,3.95 93.75,4.1 93.75,4.5 94.01,4.76 94.36,4.76 94.62,5.01 94.62,5.2 94.87,5.46 96.43,5.46
+RTCVCC on IN5 (solid shape): 99.57,6.54 99.57,5.95 99.19,5.57 98.12,5.57 97.51,6.18 98.06,6.18 98.06,6.13 98.08,6.08 98.09,6.03 98.12,5.98 98.15,5.94 98.19,5.91 98.24,5.88 98.29,5.86 98.34,5.85 98.39,5.84 98.44,5.84 98.49,5.85 98.54,5.87 98.59,5.89 98.63,5.93 98.66,5.96 98.69,6.01 98.72,6.05 98.73,6.1 98.74,6.15 98.74,6.21 98.73,6.26 98.72,6.31 98.69,6.36 98.66,6.4 98.63,6.44 98.59,6.47 98.54,6.49 98.49,6.51 98.44,6.52 98.39,6.52 98.34,6.52 98.29,6.5 98.24,6.48 98.19,6.45 98.15,6.42 98.12,6.38 98.09,6.33 98.08,6.28 98.06,6.23 98.06,6.18 97.51,6.18 97.41,6.28 97.41,6.61 97.61,6.82 99.29,6.82
+RTCVCC on IN5: 301.83,12.16 301.3,12.7 301.3,13.89 301.64,14.23 301.78,14.23 301.88,14.18 301.86,14.07 301.95,13.55 302.46,13.68 302.55,13.73 302.64,13.68 303.14,13.55 303.23,14.07 303.22,14.18 303.31,14.23 307.52,14.23 307.61,14.18 307.6,14.07 307.9,13.52 308.2,14.07 308.19,14.18 308.28,14.23 312.18,14.23 312.56,13.85 312.56,12.52 312.21,12.16 310.29,12.16 310.06,12.25 309.82,12.16 307.65,12.16 307.56,12.22 307.57,12.33 307.29,12.9 307.01,12.33 307.02,12.22 306.93,12.16 306.71,12.16 306.61,12.22 306.63,12.33 306.38,12.94 306.12,12.33 306.14,12.22 306.05,12.16 305.76,12.16 305.67,12.21 305.67,12.32 305.71,12.55 305.59,12.77 305.55,12.83 305.57,12.91 305.26,13.48 305.06,12.85 305.1,12.79 305.08,12.71 305,12.52 305.05,12.32 305.05,12.21 304.96,12.16 303.17,12.16 302.9,12.28 302.64,12.16 302.52,12.16 302.22,12.32 301.93,12.16
+SD_VDD2 on IN3 (solid shape): 331.67,37 331.67,36.76 330.86,35.95 330.56,35.95 330.22,36.29 330.22,36.66 331,37.44 331.23,37.44
+SDC_IN on BOTTOM (solid shape): 26.66,75.21 26.66,72.59 27.08,72.17 27.08,71.18 26.99,71.1 24.74,71.1 24.59,71.24 24.59,75.09 24.78,75.28 26.58,75.28
+SDC_IN on BOTTOM: 56.14,2.42 55.18,1.47 52.39,1.47 52.26,1.6 52.26,3.82 52.79,4.35 54,4.35 54,5.97 54.13,6.11 55.94,6.11 56.14,5.91
+SDC_IN on VCC: outline of 298 points within 17.78,1.27 57.21,78.24
+VCHGR on TOP (solid shape): 30.95,20.99 30.95,19.33 30.77,19.14 30.77,18.66 30.25,18.14 29.55,18.14 29.47,18.23 29.47,21 29.59,21.12 30.82,21.12
+VCHGR on BOTTOM: 29.34,19.51 29.34,19.93 28.66,20.62 27.53,20.62 27.43,20.71 27.43,22.81 26.64,23.6 26.64,25.82 26.76,25.95 35.25,25.95 35.97,25.23 35.97,23.95 32.61,23.95 32.61,23.19 35.97,23.19 35.97,22.87 35.97,22.83 35.97,21.94 34.48,20.46 31.18,20.46 31.05,20.33 31.05,18.61 30.74,18.3 30.74,18.3 30.23,17.79 29.41,17.79 29.34,17.87
+VDISPLAY_VCC on TOP (solid shape): outline of 258 points within 13.42,88.52 19.5,92.91
+VGA_B+ on TOP (solid shape): outline of 507 points within 171.51,95.41 176.47,116.66
+VGA_B+ on BOTTOM (solid shape): 173.67,118.94 173.67,116.79 174.18,116.28 175.83,116.28 176.02,116.09 176.02,112.07 175.91,111.96 172.85,111.96 171.96,112.85 171.96,118.76 172.27,119.07 173.55,119.07
+VGA_B+ on BOTTOM (solid shape): 175.9,100.97 175.9,98.62 176.21,98.31 176.21,95.58 176.09,95.45 174.5,95.45 174.37,95.58 174.37,97.72 174.25,97.85 174.25,99.13 174.69,99.58 174.69,100.92 175.1,101.33 175.54,101.33
+VGA_B+ on BOTTOM (solid shape): 175.83,108.56 175.83,106.75 176.49,106.09 176.49,104.54 175.98,104.03 173.64,104.03 173.5,104.18 173.5,104.75 174.31,105.56 174.31,108.34 174.75,108.78 174.76,108.78 174.79,108.82 175.57,108.82
+VGA_B+ on IN5 (solid shape): outline of 623 points within 171.4,95.19 175.58,116.66
+VLDOIN_1.2V on BOTTOM (solid shape): 285.31,30.17 287.2,30.17 287.29,30.08 287.29,29.96 287.25,29.92 286.07,29.92 286.07,29.92 283.97,29.92 283.97,30.33 283.4,30.33 283.4,30.52 283.94,30.52 283.94,30.52 283.97,30.52 283.97,30.93 284.04,31 284.48,31
+VSBP on TOP (solid shape): 31.31,15.63 31.31,13.53 31.05,13.28 28.07,13.28 27.75,13.6 27.75,15.12 27.81,15.19 28.45,15.19 29.02,15.76 31.18,15.76
+VSBP on TOP: 14.38,18.28 13.44,19.23 13.44,20.59 13.6,20.75 15.13,20.75 15.37,20.52 15.37,19.44 15.5,19.31 15.81,19.31 15.99,19.14 15.99,18.95 15.84,18.81 15.28,18.81 14.75,18.28
+VSBP on IN5: 13.91,19.19 14.03,19.31 15.88,19.31 18.04,17.15 31.03,17.15 31.24,16.94 31.24,13.79 31.05,13.6 16.13,13.6 13.91,15.82
B+ on TOP (solid shape): 213.79,49.42 213.79,48.15 213.65,48.01 210.17,48.01 209.95,48.23 209.95,49.32 210.19,49.57 213.65,49.57
B+ on TOP (solid shape): 105.32,68.73 105.32,68.32 105.41,68.24 106.3,68.24 106.3,67.71 107,67.71 107,68.24 107.5,68.24 107.5,67.71 108.2,67.71 108.2,68.24 109.19,68.24 109.35,68.08 109.35,66.75 109.09,66.49 104.08,66.49 103.95,66.62 103.95,68.79 104.1,68.94 105.11,68.94
B+ on TOP (solid shape): 236.58,45.55 236.6,45.55 236.6,45.54 237.11,45.54 237.11,45.55 237.13,45.55 237.13,46.07 237.38,46.07 237.38,46.07 237.38,45.55 237.4,45.55 237.4,45.54 237.43,45.54 240.04,45.54 240.29,45.3 240.29,43.77 235.02,43.77 234.95,43.84 234.95,45.17 235.33,45.55 235.73,45.55 235.73,45.54 236.31,45.54 236.31,45.55 236.33,45.55 236.33,46.07 236.58,46.07
B+ on TOP (solid shape): outline of 150 points within 314.11,8.84 319.33,18.8
B+ on BOTTOM (solid shape): 106.05,57.98 106.05,56.02 105.73,55.7 104.84,55.7 104.52,56.02 104.52,57.98 104.65,58.11 105.92,58.11
B+ on BOTTOM (solid shape): 138.3,9.97 138.3,8.39 138.11,8.2 136.21,8.2 136.08,8.33 136.08,9.79 136.49,10.19 138.08,10.19
B+ on BOTTOM (solid shape): 253.47,21.75 253.47,19.22 253.24,19 252.39,19 252.26,19.12 252.26,21.83 252.54,22.11 253.11,22.11
B+ on BOTTOM (solid shape): 106.05,68.08 108.84,68.08 109.03,67.89 109.03,66.62 108.84,66.43 104.01,66.43 103.82,66.62 103.82,68.97 104.01,69.16 104.97,69.16
B+ on BOTTOM (solid shape): 171.66,118.8 171.66,115.34 171.26,114.94 169.02,114.94 168.47,115.5 168.47,115.51 168.06,115.92 168.06,117.98 168.05,117.99 168.05,118.83 168.29,119.07 171.39,119.07
B+ on BOTTOM (solid shape): 111.38,100.08 111.38,98.43 111.2,98.24 111.17,98.22 110.24,98.22 110.24,98.74 109.53,98.74 109.53,98.22 109.04,98.22 109.04,98.74 108.33,98.74 108.33,98.22 107.1,98.22 106.3,97.42 106.3,96.72 106.06,96.48 104.97,96.48 104.78,96.67 104.78,99.2 105.79,100.21 111.25,100.21
B+ on BOTTOM (solid shape): 136.06,107.91 136.06,106.65 134.65,105.24 127.52,105.24 127.19,105.57 127.19,107.19 127.36,107.36 128.95,107.36 128.97,107.36 128.97,107.88 129.42,107.88 129.42,107.36 129.44,107.36 130.15,107.36 130.17,107.36 130.17,107.88 130.62,107.88 130.62,107.36 130.64,107.36 131.42,107.36 132.16,108.1 135.86,108.1
B+ on BOTTOM (solid shape): 280.1,32.41 280.1,26.03 279.97,25.9 278.88,25.9 278.7,26.08 278.7,28.2 279.02,28.52 279.02,28.53 279.37,28.88 279.37,29.86 279.32,29.92 278.84,29.92 278.84,29.92 278.84,30.37 278.84,30.37 279.37,30.37 279.39,30.38 279.39,31.11 279.37,31.12 278.84,31.12 278.84,31.57 279.37,31.57 279.39,31.58 279.39,32.48 279.49,32.58 279.92,32.58
B+ on IN4 (solid shape): outline of 6752 points within 31.83,15.63 113.06,50.15
B+ on IN6 (solid shape): 280.04,26.3 280.04,25.79 279.66,25.41 279.08,25.41 278.83,25.15 278.26,25.73 278.26,26.04 278.64,26.42 279.91,26.42
B+ on IN6 (solid shape): 254.26,22.68 254.26,21.85 253.75,21.34 253.75,20.58 253.49,20.33 252.86,20.33 252.48,20.71 252.48,21.98 253.24,22.74 254.19,22.74
B+ on TOP: 30.59,11.86 31.53,12.8 31.53,14.65 32.01,15.12 32.83,15.12 33.02,15.31 33.02,16.01 32.89,16.14 32.89,16.39 32.7,16.58 32.07,16.58 32.01,16.65 32.01,17.41 32.13,17.53 32.77,17.53 32.89,17.66 32.89,20.33 34.42,21.85 36.96,21.85 37.59,22.49 40.74,22.49 41.39,23.14 45.68,23.14 45.98,22.85 45.98,21.79 45.66,21.47 42.1,21.47 41.02,20.39 39.59,20.39 38.61,19.41 38.61,15.69 33.37,10.45 33.37,9.82 32.97,9.42 30.73,9.42 30.59,9.57
B+ on BOTTOM: 32.83,15.88 32.83,16.43 33.15,16.75 35.46,16.75 35.66,16.95 35.66,21.19 36.07,21.6 36.58,21.6 37.19,22.21 37.19,23.19 40.54,23.19 40.54,23.95 37.19,23.95 37.19,25.21 37.22,25.24 43.14,25.24 44.18,24.2 45.88,24.2 46.6,23.47 48.4,23.47 48.55,23.33 48.55,22.61 48.12,22.18 48.12,20.32 48.01,20.2 47.37,20.2 46.13,21.44 42.07,21.44 41.78,21.15 41.78,17.34 38.8,14.36 38.8,14.35 38.51,14.06 38.51,9.53 37.94,8.96 31.83,8.96 31.43,9.36 31.43,14.99 31.75,15.31 32.26,15.31
B+ on IN3: 148.69,111.2 144.3,106.8 141.35,106.8 141.22,106.92 141.04,106.96 140.86,106.9 140.73,106.76 140.7,106.68 140.36,106.34 139.11,106.34 138.86,106.44 138.62,106.34 137.51,106.34 136.2,105.03 127.89,105.03 127.52,105.39 127.52,119.52 128.32,120.32 164.66,120.32 165.39,119.59 170.65,119.59 170.9,119.33 170.9,112.98 170.02,112.1 168.13,112.1 167.22,111.2
B+ on VCC: 316.31,14.11 315.81,14.61 286.34,14.61 286.26,14.7 286.26,16.09 285.45,16.9 284.4,16.9 283.21,15.71 283.21,14.82 283,14.61 260.94,14.61 260.61,14.95 260.61,22.95 253.58,29.98 111.26,29.98 108.71,32.53 108.71,43.74 112.48,47.51 112.95,47.51 113.16,47.3 113.16,46.15 114.6,44.71 116.04,44.71 116.97,45.65 116.97,48.57 117.43,49.03 128.57,49.03 128.65,48.95 128.65,46.66 129.46,45.86 130.77,45.86 132.08,47.17 132.08,48.57 132.55,49.03 180.42,49.03 190.22,58.83 190.22,58.83 186.02,54.63 189.32,54.49 191.01,57.33 190.87,58.25 190.48,59.09 191.09,59.7 192.87,59.7 193.98,58.59 196.67,58.59 197.78,59.7 215.31,59.7 217.09,57.92 233.38,57.92 235.99,53.86 238.6,57.92 249.61,57.92 261,40.08 281,33.13 291,33.13 302.7,35.32 312.8,41.61 312.8,30.79 318.64,24.94 318.64,14.7 318.05,14.11
B+ on IN5: outline of 509 points within 32.83,13.98 171.27,120.48
B++ on TOP (solid shape): 332.8,20.39 332.8,17.98 332.74,17.92 332.11,17.92 331.66,17.47 331.66,12.26 331.34,11.95 321.82,11.95 321.25,11.38 321.25,8.77 321.06,8.58 319.15,8.58 318.96,8.77 318.96,8.78 318.93,8.81 318.93,9.85 319.46,9.85 319.46,10.56 318.93,10.56 318.93,11.05 319.46,11.05 319.46,11.76 318.93,11.76 318.93,13.09 319.47,13.63 319.47,17.98 320.49,19 329.31,19 329.95,19.63 329.95,20.39 330.07,20.52 332.68,20.52
B+_0.95V on TOP (solid shape): 107.7,59.13 107.7,58.43 107.47,58.21 107.47,56.68 107.32,56.52 106.43,56.52 105.86,57.1 105.86,60.14 106.05,60.33 106.49,60.33
B+_0.95V on BOTTOM (solid shape): 107.76,61.41 107.76,58.43 107.51,58.17 107.51,56.65 107.38,56.52 106.49,56.52 106.36,56.65 106.36,58.43 105.98,58.81 104.9,58.81 104.71,59 104.71,60.65 105.22,61.16 106.36,61.16 106.81,61.6 107.57,61.6
B+_1.05V on TOP (solid shape): 216.45,51.08 218.48,51.08 218.48,50.17 216.92,50.17 215.77,49.03 215.77,48.4 215.65,48.27 214.44,48.27 214.19,48.52 214.19,49.35 213.74,49.79 210.88,49.79 210.63,50.05 210.63,51.13 210.76,51.25 216.28,51.25
B+_1V on BOTTOM (solid shape): 135.83,9.53 135.83,8.14 136.05,7.91 138.15,7.91 138.37,7.69 138.37,5.98 138.11,5.72 137.73,5.72 137.26,6.2 136.05,6.2 135.76,6.49 135.76,6.87 135.64,6.99 134.94,6.99 134.11,6.17 134.11,5.6 134.11,5.54 134.07,5.49 133.13,5.49 133.12,5.5 133.12,7.51 133.43,7.82 133.86,7.82 134.3,8.26 134.3,9.47 134.49,9.66 135.7,9.66
B+_IN on TOP (solid shape): 28.35,9.97 28.35,7.95 27.81,7.41 27.81,6.93 27.16,6.28 24.85,6.28 24.64,6.49 24.17,6.49 23.87,6.79 22.44,6.79 22.4,6.84 22.4,7.93 22.48,8.01 24.18,8.01 25.3,9.13 25.3,10.41 25.36,10.47 27.86,10.47
BATBTN# on BOTTOM (solid shape): 350.58,113.36 349.57,113.36 349.57,115.01 350.58,115.01
BATBTN# on BOTTOM (solid shape): 350.58,109.48 349.57,109.48 349.57,111.13 350.58,111.13
BATDRV# on BOTTOM (solid shape): 29.21,19.88 29.21,19.57 29.15,19.5 29.14,19.5 29.1,19.46 28.85,19.46 28.36,19.95 27.88,19.95 27.75,20.07 27.75,20.28 27.86,20.39 28.7,20.39
BATT++ on BOTTOM (solid shape): outline of 97 points within 21.08,10.99 28.78,20.61
BOOT_1.2V on BOTTOM (solid shape): 287.29,29.68 287.29,29.59 287.23,29.54 285.43,29.54 284.87,28.97 284.87,28.21 284.82,28.16 284.16,28.16 284.11,28.21 284.11,29.36 284.5,29.74 287.23,29.74
BQ24777_REGN on TOP (solid shape): 51.75,20.84 51.75,19.27 51.37,18.89 51.37,18.36 52.13,17.6 53.34,17.6 53.47,17.47 53.4,17.41 51.88,17.41 51.12,18.17 50.62,18.17 50.52,18.27 50.52,19.59 50.42,19.69 50.42,20.91 50.48,20.97 51.62,20.97
BST1_3V on TOP (solid shape): 342.64,24.52 342.64,23.62 342.52,23.51 340.73,23.51 340.62,23.62 340.62,24.52 340.68,24.58 342.58,24.58
BST1_5V on TOP (solid shape): 344.55,16.77 344.49,16.71 343.03,16.71 342.96,16.77 342.96,17.66 344.55,17.66
BST_0.95V on TOP (solid shape): 107.7,62.42 107.7,61.86 107.57,61.73 106.7,61.73 106.36,62.07 106.36,62.94 106.49,63.06 107.05,63.06
BST_1.05V on TOP (solid shape): 220.54,49.73 220.54,48.29 220.54,48.28 220.54,48.01 220.51,47.98 219.66,47.98 219.63,48.01 219.63,49.68 219.16,50.15 219.16,50.5 219.25,50.59 219.68,50.59
BST_3V on TOP (solid shape): 343.99,24.56 343.99,23.64 343.85,23.5 343.85,22.74 344.11,22.49 344.11,21.34 344.04,21.28 343.96,21.28 343.88,21.36 343.88,22.34 343.26,22.96 343.26,24.49 343.35,24.58 343.97,24.58
BST_5V on TOP (solid shape): 344.1,19.28 344.1,18.04 343.85,17.79 342.9,17.79 342.9,17.79 342.71,17.79 342.52,17.6 342.52,16.84 342.39,16.71 341.63,16.71 341.5,16.84 341.5,17.73 341.95,18.17 343.72,18.17 343.89,18.34 343.89,19.28 343.93,19.31 344.07,19.31
BST_+1.35VRUN on TOP (solid shape): 244.86,54.75 244.86,54.17 244.67,53.98 244.29,53.98 243.71,53.41 243.71,52.33 243.65,52.27 243.52,52.27 243.48,52.31 243.48,53.68 243.84,54.05 243.84,54.68 243.97,54.81 244.79,54.81
CHAGER_SRC on TOP: 44.01,17.79 44.01,7.5 44.26,7.25 48.2,7.25 48.9,6.55 48.9,6.1 53.21,6.1 53.28,6.17 53.28,6.68 53.15,6.8 52.39,6.8 51.56,7.63 51.56,9.72 47.79,13.5 47.79,17.99 47.55,18.23 44.45,18.23
CHAGER_SRC on BOTTOM: 44.01,17.79 44.01,7.5 44.26,7.25 48.2,7.25 48.9,6.55 48.9,6.1 53.21,6.1 53.28,6.17 53.28,6.68 53.15,6.8 52.39,6.8 51.56,7.63 51.56,9.72 49.47,11.82 49.47,17.85 49.09,18.23 44.45,18.23
CHAGER_SRC on IN2: 44.01,17.79 44.01,7.5 44.26,7.25 48.2,7.25 48.9,6.55 51.16,6.55 51.56,6.96 51.56,9.72 49.47,11.82 49.47,17.85 49.09,18.23 44.45,18.23
CHAGER_SRC on IN3: 44.01,17.79 44.01,7.5 44.26,7.25 48.2,7.25 48.9,6.55 51.45,6.55 51.56,6.66 51.56,9.72 49.47,11.82 49.47,17.85 49.09,18.23 44.45,18.23
CHAGER_SRC on IN6: 44.01,17.79 44.01,7.5 44.26,7.25 48.2,7.25 48.9,6.55 51.39,6.55 51.56,6.73 51.56,9.72 49.47,11.82 49.47,17.85 49.09,18.23 44.45,18.23
CHG_BTS on TOP (solid shape): 51.88,17.22 53.4,17.22 53.47,17.15 53.47,17.09 53.4,17.03 50.55,17.03 50.42,17.15 50.42,17.92 50.55,18.04 51.06,18.04
CHG_BTS_C on TOP (solid shape): 49.82,17.91 49.82,15.88 49.69,15.76 49.05,15.76 48.99,15.82 48.99,17.91 49.08,17.99 49.73,17.99
CHG_LGATE on TOP (solid shape): 52.45,18.36 52.45,18.17 52.64,17.98 53.4,17.98 53.47,17.92 53.47,17.85 53.4,17.79 52.13,17.79 51.59,18.33 51.59,18.71 51.69,18.8 52.01,18.8
CHG_LGATE on IN5 (solid shape): 48.83,2.74 49.47,2.74 49.72,2.49 49.72,2.16 49.29,1.72 48.32,1.72 47.63,2.42 47.63,2.8 47.94,3.12 48.45,3.12
CHG_LGATE on IN5 (solid shape): 52.41,18.19 52.41,17.89 52.35,17.83 50.38,17.83 50.17,18.04 50.17,18.55 50.32,18.7 51.9,18.7
CHG_LGATE on BOTTOM: 47.37,2.49 48.52,2.49 48.71,2.68 49.53,2.68 49.69,2.52 49.69,1.95 49.53,1.79 47.44,1.79 47.25,1.98 47.25,2.36
CHG_SW on TOP (solid shape): 51.18,16.65 51.18,16.46 51.44,16.2 52.26,16.2 52.45,16.39 53.4,16.39 53.47,16.33 53.47,16.26 53.4,16.2 52.64,16.2 52.39,15.95 52.39,15.82 52.26,15.69 50.55,15.69 50.42,15.82 50.42,16.65 50.55,16.77 51.06,16.77
CHG_SW on TOP (solid shape): 43.24,16.52 43.24,13.66 43.05,13.47 41.91,13.47 41.53,13.09 41.53,11.12 41.78,10.87 42.99,10.87 43.18,10.68 43.18,6.99 43.63,6.55 46.17,6.55 46.42,6.3 46.42,1.85 46.17,1.6 37.75,1.6 36.15,3.2 35.33,3.2 35.12,3.41 35.12,8 35.76,8.64 38.09,8.64 38.85,9.41 38.85,13.95 41.67,16.77 42.99,16.77
CHG_SW on IN1 (solid shape): 43.12,8.85 43.12,7.11 42.93,6.92 42.17,6.92 41.97,7.11 41.97,8.85 42.09,8.97 43,8.97
CHG_SW on IN1 (solid shape): 51.25,16.2 52.26,16.2 52.45,16.01 52.45,15.63 52.13,15.31 50.48,15.31 50.42,15.38 50.42,16.2 50.55,16.33 51.12,16.33
CHG_SW on BOTTOM, IN2, IN3: 42.99,16.77 43.24,16.52 43.24,13.66 43.05,13.47 41.91,13.47 41.53,13.09 41.53,11.12 41.78,10.87 42.99,10.87 43.18,10.68 43.18,6.99 43.63,6.55 46.17,6.55 46.42,6.3 46.42,1.85 46.17,1.6 30.16,1.6 29.4,2.36 29.4,7.57 30.48,8.64 38.09,8.64 38.85,9.41 38.85,13.95 41.67,16.77
CHG_SW on IN6: 42.99,16.77 43.24,16.52 43.24,13.66 43.05,13.47 41.91,13.47 41.53,13.09 41.53,11.12 41.78,10.87 42.99,10.87 43.18,10.68 43.18,6.99 43.63,6.55 46.17,6.55 46.42,6.3 46.42,1.85 46.17,1.6 33.81,1.6 32.84,2.57 29.56,2.57 29.4,2.73 29.4,7.57 30.48,8.64 38.09,8.64 38.85,9.41 38.85,13.95 41.67,16.77
CHG_UGATE on TOP (solid shape): 53.47,16.77 53.47,16.65 53.4,16.58 52.45,16.58 52.2,16.33 51.5,16.33 51.37,16.46 51.37,16.77 51.44,16.84 53.4,16.84
CHG_UGATE on IN1 (solid shape): 43.12,18.42 43.12,17.22 42.93,17.03 42.23,17.03 42.1,17.15 42.1,18.49 42.23,18.61 42.93,18.61
CHG_UGATE on IN1 (solid shape): 43.05,14.11 43.05,13.22 43.37,12.9 44.07,12.9 44.26,12.71 44.26,12.14 44.07,11.95 42.17,11.95 42.04,12.07 42.04,14.04 42.23,14.23 42.93,14.23
CHG_UGATE on IN1 (solid shape): 51.51,17.22 52.2,17.22 52.39,17.03 52.39,16.46 52.26,16.33 51.42,16.33 51.23,16.52 50.42,16.52 50.36,16.58 50.36,17.47 50.42,17.53 51.19,17.53
CHG_UGATE on BOTTOM: 42.17,18.61 43.18,18.61 43.37,18.42 43.37,17.53 43.18,17.34 42.23,17.34 42.04,17.53 42.04,18.49
CHG_UGATE on BOTTOM: 42.04,12.84 42.93,12.84 43.12,12.65 43.12,11.63 42.99,11.5 42.04,11.5 41.85,11.69 41.85,12.65
DAUL_IN on TOP (solid shape): 27.09,70.63 27.09,69.02 26.91,68.84 24.39,68.84 24.14,69.08 24.14,70.55 24.47,70.87 26.85,70.87
DAUL_IN on BOTTOM (solid shape): 27.23,66.13 27.23,63.89 27.17,63.83 26.52,63.83 26.45,63.89 26.45,65.33 25.99,65.79 25.99,66.12 26.11,66.25 27.11,66.25
DAUL_IN on BOTTOM: 20.09,63.65 20.09,64.75 19.2,64.75 19.2,64.1 19.11,64 18.7,64 18.61,64.07 18.51,64.1 18.47,64.11 18.47,64.83 18.99,65.35 18.99,66.18 19.11,66.3 20.7,66.3 21.27,66.87 21.27,69.67 21.53,69.92 24.34,69.92 24.54,70.11 24.54,70.63 24.77,70.87 26.89,70.87 27.2,70.56 27.2,69.01 27.07,68.87 24.79,68.87 24.79,68.87 24.54,68.87 24.05,68.39 24.05,68.16 22.67,68.16 22.31,67.8 22.67,67.45 24.05,67.45 24.05,66.92 23.01,65.87 22.43,65.87 21.44,64.88 21.44,63.79 21.3,63.65
DH_1.2V on BOTTOM (solid shape): 271.34,33.85 271.34,32.76 271.24,32.66 270.75,32.66 270.16,33.25 270.16,34.2 270.26,34.3 270.89,34.3
DH_1.2V on BOTTOM (solid shape): 287.29,29.28 287.29,29.18 287.24,29.14 286.18,29.14 285.37,28.33 285.18,28.33 285.05,28.46 285.05,28.88 285.51,29.35 287.22,29.35
DH_1.2V on IN6 (solid shape): 271.27,34.24 271.27,31.95 271.15,31.82 270.32,31.82 270.07,32.08 270.07,34.24 270.26,34.43 271.08,34.43
DH_1.2V on IN6 (solid shape): 285.31,29.41 285.81,29.41 286.01,29.22 286.01,28.96 285.37,28.33 284.99,28.33 284.29,29.03 284.29,29.16 284.86,29.73 284.99,29.73
DL_1.2V on BOTTOM (solid shape): 287.57,28.6 287.57,27.74 286.83,27 286.26,27 286.16,27.09 286.16,27.41 287.41,28.66 287.51,28.66
DL_1.2V on BOTTOM (solid shape): 275.27,27 275.27,26.27 275.09,26.09 273.39,26.09 273.24,26.23 273.24,26.45 273.37,26.58 273.94,26.58 274.42,27.06 275.21,27.06
DL_1.2V on IN6 (solid shape): 276.29,26.81 276.29,26.36 276.1,26.17 274.13,26.17 274,26.3 274,27 274.07,27.06 276.04,27.06
DL_1.2V on IN6 (solid shape): 287.28,27.82 287.28,27.5 286.58,26.81 286.58,26.3 286.32,26.04 286.11,26.04 285.6,26.55 285.6,26.72 285.62,26.74 285.62,26.87 286.77,28.01 287.08,28.01
GPU_PVCC on BOTTOM (solid shape): 172.47,110.24 172.47,107.51 172.34,107.39 171.56,107.39 171.05,107.9 170.67,107.9 170.54,107.77 169.25,107.77 169.17,107.85 169.17,107.95 169.24,108.03 170.29,108.03 170.49,108.23 171.41,108.23 171.66,108.47 171.66,110.26 171.77,110.37 172.34,110.37
LG_3V on TOP (solid shape): 341.95,22.04 342.11,22.04 342.89,21.26 343.3,21.26 343.41,21.15 343.41,21.06 343.36,21 342.37,21 342.09,21.28 341.69,21.28 341.44,21.54 341.44,21.92 341.56,22.04 341.95,22.04
LG_3V on TOP (solid shape): 338.46,20.92 338.46,18.8 338.39,18.74 337.95,18.74 337.57,18.36 337.57,17.98 337.38,17.79 336.49,17.79 336.36,17.92 336.36,18.42 336.49,18.55 337,18.55 337.19,18.74 337.19,20.91 337.37,21.1 338.28,21.1
LG_3V on IN1 (solid shape): 338.46,21.54 338.46,20.52 338.39,20.46 337.31,20.46 337.19,20.58 337.19,21.41 337.38,21.6 338.39,21.6
LG_3V on IN1 (solid shape): 342.52,21.6 342.52,21.34 342.33,21.15 340.49,21.15 340.42,21.22 340.42,22.11 340.49,22.17 341.95,22.17
LG_5V on TOP (solid shape): 333.69,17.34 333.69,15.31 333.44,15.06 332.49,15.06 332.31,15.24 332.31,17.42 332.42,17.53 333.5,17.53
LG_5V on TOP (solid shape): 343.4,19.58 343.4,19.42 343.36,19.38 342.66,19.38 342.25,18.97 341.37,18.97 341.28,19.06 341.28,19.41 341.44,19.57 342.43,19.57 342.46,19.59 343.38,19.59
LG_5V on IN1 (solid shape): 333.31,17.92 333,17.6 333,16.39 332.74,16.14 332.17,16.14 331.92,16.39 331.92,18.11 332.61,18.8 333.31,18.8
LG_5V on IN1 (solid shape): 342.39,19.44 342.39,19.12 342.23,18.96 341.72,18.96 341.3,18.55 340.11,18.55 340.11,19.44 340.23,19.57 342.27,19.57
LX_0.95V on TOP (solid shape): 110.87,61.54 110.87,60.52 110.75,60.4 109.54,60.4 109.41,60.52 109.41,61.54 109.6,61.73 110.68,61.73
LX_0.95V on BOTTOM (solid shape): 114.36,61.73 114.36,58.94 114.75,58.56 114.75,57.03 114.62,56.9 113.73,56.9 113.48,57.16 113.48,58.62 112.78,59.32 111.38,59.32 110.05,60.65 108.97,60.65 108.97,61.67 109.03,61.73 109.98,61.73 110.43,62.18 113.92,62.18
LX_1.05V on TOP (solid shape): 219.39,49.16 219.39,47.95 219.27,47.82 218.31,47.82 218.25,47.89 218.25,49.22 218.38,49.35 219.2,49.35
LX_1.05V on TOP (solid shape): 219.58,55.39 219.58,53.77 219.34,53.54 218.69,53.54 218.47,53.32 218.47,52.16 218.45,52.14 217.33,52.14 217.28,52.18 217.28,53.24 216.54,53.98 216.54,55.51 216.73,55.7 219.27,55.7
LX_1.05V on BOTTOM (solid shape): 219.58,57.73 219.58,48.71 219.46,48.59 218.44,48.59 218.19,48.84 218.19,53.67 218.06,53.79 216.79,53.79 216.47,54.11 216.47,57.92 216.6,58.05 219.27,58.05
LX_1V on TOP (solid shape): 131.51,6.24 131.51,5.61 131.36,5.45 130.49,5.45 130.28,5.66 130.28,6.15 130.48,6.35 131.4,6.35
LX_1V on BOTTOM (solid shape): 127.76,9.09 127.76,7.82 128.52,7.06 130.49,7.06 130.88,6.67 132.07,6.67 132.07,5.47 130.75,5.47 129.92,4.64 129.92,2.23 129.67,1.98 127.45,1.98 127.16,2.26 127.16,6.14 126.35,6.95 126.36,6.98 126.36,7.24 126.18,7.44 126.15,7.45 126.15,9.18 126.31,9.34 127.51,9.34
LX_3V on TOP (solid shape): 344.62,23.63 344.62,22.74 344.49,22.61 344.49,21.66 344.3,21.66 344.3,22.55 344.04,22.81 344.04,23.5 344.12,23.58 344.12,23.67 344.21,23.76 344.49,23.76
LX_3V on TOP (solid shape): 339.31,29.75 339.31,25.54 340.24,24.62 340.24,23.63 340.08,23.47 338.17,23.47 336.93,22.23 336.93,19 336.74,18.8 334.27,18.8 333.95,19.12 333.95,20.52 333.63,20.84 331.03,20.84 330.9,20.96 330.9,22.17 331.22,22.49 333.5,22.49 334.33,23.31 334.33,27.5 334.65,27.82 336.49,27.82 336.86,28.2 336.86,29.94 337.03,30.11 338.95,30.11
LX_3V on IN6 (solid shape): 339.6,28.67 339.6,27.26 341.45,25.41 343.07,25.41 344.73,23.76 344.73,22.74 344.46,22.48 343.72,22.48 342.38,23.81 340.25,23.81 337.82,26.24 337.82,28.67 338.16,29.01 339.26,29.01
LX_5V on TOP (solid shape): 344.49,19.19 344.49,18.3 345.06,17.73 346.77,17.73 347.28,17.22 347.28,16.71 347.16,16.58 345.12,16.58 344.74,16.96 344.74,17.66 344.62,17.79 344.43,17.79 344.3,17.92 344.3,19.19 344.36,19.25 344.43,19.25
LX_5V on TOP (solid shape): 337.69,14.04 337.69,12.14 338.14,11.69 340.11,11.69 340.42,11.38 340.42,10.17 340.11,9.85 338.33,9.85 338.01,9.53 338.01,4.01 337.82,3.82 333.19,3.82 332.87,4.14 332.87,7.82 332.3,8.39 327.47,8.39 326.87,8.99 326.87,11.05 330.71,11.05 330.71,9.93 330.97,9.66 332.16,9.66 332.42,9.93 332.42,11.05 332.22,11.25 330.91,11.25 330.71,11.05 326.87,11.05 326.87,11.41 327.09,11.63 331.6,11.63 332.3,12.33 332.3,14.11 332.61,14.42 337.31,14.42
LX_5V on IN1 (solid shape): 338.77,8.71 338.27,8.2 337.88,8.2 337.38,8.71 336.68,8.71 336.36,9.03 336.36,9.47 336.55,9.66 337.82,9.66
LX_5V on IN1 (solid shape): 348.81,16.9 348.81,16.33 348.5,16.02 348.37,16.02 348.27,15.92 347.45,16.74 346.93,16.74 346.4,17.27 346.4,17.59 346.57,17.76 346.58,17.76 346.74,17.92 347.79,17.92
Net_97 on BOTTOM (solid shape): 241.69,29.93 226.69,29.93 226.69,39.93 241.69,39.93
Net_98 on BOTTOM (solid shape): 210.38,30.43 202.38,30.43 202.38,38.43 210.38,38.43
Net_98 on BOTTOM (solid shape): 222.19,30.3 214.19,30.3 214.19,38.3 222.19,38.3
PP_HV on TOP (solid shape): 8.53,41.36 8.53,39.84 8.44,39.75 7.8,39.75 7.38,40.17 7.38,41.69 7.56,41.87 8.03,41.87
PP_HV on BOTTOM (solid shape): 8.59,41.76 8.59,40.81 8.88,40.51 8.88,40.28 8.71,40.11 8.65,40.11 8.47,39.94 8.47,39.87 8.39,39.79 8.17,39.79 8.12,39.84 8.12,40.02 7.97,40.17 7.81,40.17 7.59,40.4 7.59,40.62 7.46,40.75 7.46,41.79 7.6,41.93 8.41,41.93
PP_HV on VCC: 10.03,1.27 10.03,19.93 6.35,23.61 6.35,24.63 4.93,26.04 2.17,26.04 2.17,44.53 8.76,44.53 8.76,41.14 7.11,39.48 7.11,31.27 6.35,26.97 10.56,25.79 15.37,20.99 15.37,1.27
PSID on BOTTOM (solid shape): 19.75,77.42 19.75,73.41 19.69,73.35 19.05,73.35 18.93,73.47 18.93,77.21 18.85,77.29 18.61,77.29 18.42,77.48 18.42,77.8 18.48,77.86 19.31,77.86
SD_REG2 on BOTTOM (solid shape): 337.38,39.75 337.38,38.78 337.08,38.49 336.28,38.49 335.47,37.68 335.24,37.68 335.18,37.74 335.18,38.54 335.27,38.64 335.62,38.64 336.3,39.32 336.3,39.81 336.37,39.89 337.24,39.89
SNB_0.95V on BOTTOM (solid shape): 112.14,58.62 112.14,57.03 112.02,56.9 111,56.9 110.81,57.1 110.81,57.86 110.55,58.11 109.54,58.11 109.48,58.17 109.48,58.81 109.54,58.87 111.89,58.87
SNB_1.05V on TOP (solid shape): 215.14,55.44 215.14,53.92 215.01,53.79 212.98,53.79 212.92,53.86 212.92,54.81 213.68,55.57 215.01,55.57
SNB_1V on BOTTOM (solid shape): 130.94,9.19 130.94,8.39 130.87,8.32 130.22,8.32 130.03,8.14 130.03,7.58 129.83,7.37 128.84,7.37 128.72,7.5 128.72,9.09 128.91,9.28 130.84,9.28
SNUB_1.2V on BOTTOM (solid shape): 267.46,27.76 267.46,26.11 267.27,25.92 266.32,25.92 266.19,26.04 266.19,26.74 265.94,27 265.05,27 264.86,27.19 264.86,27.76 265.05,27.95 267.27,27.95
SNUB_3V on TOP (solid shape): 338.73,32.5 338.73,31.4 338.56,31.23 336.65,31.23 336.44,31.44 335.41,31.44 335.24,31.61 335.24,32.47 335.42,32.65 338.58,32.65
SNUB_5V on TOP (solid shape): 340.3,14.74 340.3,12.9 340.17,12.77 338.46,12.77 338.27,12.96 338.27,14.87 338.46,15.06 339.98,15.06
SW_1.2V on BOTTOM (solid shape): 287.29,28.88 287.29,28.79 287.15,28.65 286.77,28.65 284.93,26.81 284.29,26.81 284.16,26.93 284.16,27.82 284.23,27.89 285.18,27.89 286.24,28.95 287.22,28.95
SW_1.2V on BOTTOM (solid shape): 269.8,33.51 269.8,32.85 270.22,32.43 271.24,32.43 271.32,32.35 271.32,30.23 271.5,30.04 272.37,30.04 272.99,29.43 272.99,26.23 272.54,25.79 268.86,25.79 268.54,26.11 268.54,27.82 266.96,29.41 266.96,33.44 267.14,33.63 269.68,33.63
SW_1.2V on IN6 (solid shape): 272.86,29.39 272.86,28 272.6,27.73 270.82,27.73 270.61,27.94 270.61,29.74 270.75,29.88 272.37,29.88
SW_1.2V on IN6 (solid shape): 286.45,28.45 286.45,28.11 285.59,27.25 283.5,27.25 283.4,27.36 283.4,28.22 283.54,28.36 284.56,28.36 284.77,28.16 285.46,28.16 285.93,28.63 286.28,28.63
SW_+1.35VRUN on TOP (solid shape): 243.87,58.57 243.87,56.69 243.78,56.6 242.47,56.6 242.27,56.4 242.27,55.32 242.77,54.81 243.52,54.81 243.59,54.75 243.59,54.05 243.29,53.75 243.29,52.34 243.22,52.27 240.88,52.27 240.37,51.76 240.37,51.37 240.13,51.13 238.85,51.13 238.7,51.28 238.7,54.11 239.72,56.2 239.32,58.49 239.32,58.72 239.57,58.97 243.46,58.97
SW_+1.35VRUN on BOTTOM (solid shape): 243.86,58.57 243.86,52.87 243.67,52.68 240.04,52.68 239.92,52.8 239.92,55.89 240.01,56.73 239.92,57.57 239.92,58.59 240.29,58.96 243.46,58.96
TBT_SVR_IND on BOTTOM: 23.37,45.51 23.24,45.51 23.11,45.37 23.11,45.22 23.03,45.14 22.82,45.14 22.72,45.25 22.72,46.28 22.86,46.42 22.86,46.53 22.86,47.33 22.44,47.75 22.44,50.77 22.76,51.09 24.25,51.09 24.25,49.89 24.01,49.65 24.01,47.65 23.35,46.99 23.35,46.08 23.45,45.98 23.45,45.59
TBTA_VBUS_L on BOTTOM: 6.88,36.71 6.97,36.62 6.97,36.34 6.97,36.29 6.83,36.16 6.75,36.16 6.74,36.15 6.7,36.15 6.57,36.01 6.57,35.92 6.48,35.84 6.27,35.84 6.27,35.84 6.03,35.84 5.55,35.36 5.55,34.14 5.66,34.03 5.66,32.86 5.6,32.81 3.2,32.81 3.09,32.92 3.09,33.73 3.94,34.58 3.94,34.62 3.92,34.63 3.92,35.27 4.36,35.7 4.36,36.19 4.75,36.58 5.85,36.58 6.27,37 6.49,37 6.56,36.98 6.59,36.91 6.66,36.77 6.81,36.71
TPM_VDD on TOP: 158.37,8.76 158.52,8.91 158.52,10.89 158.87,11.24 158.87,11.98 158.76,12.09 157.5,12.09 157.4,11.99 157.4,9.99 157.63,9.76 157.63,9.23 157.5,9.1 156.33,9.1 156.25,9.02 156.25,8.82 156.31,8.76
U2_BOOT1 on BOTTOM (solid shape): 169.12,106.11 169.12,105.28 169.86,104.54 169.86,103.38 169.85,103.38 169.8,103.32 169.04,103.32 168.97,103.39 168.97,104.95 168.84,105.08 168.84,106.12 168.92,106.2 169.03,106.2
U2_BOOT2 on BOTTOM (solid shape): 170.01,111.61 170.01,110.89 169.12,110.01 169.12,109.17 169.04,109.09 168.92,109.09 168.84,109.17 168.84,110.13 168.87,110.16 168.87,110.74 169.04,110.92 169.04,111.66 169.07,111.68 169.93,111.68
U2_BOOT3 on BOTTOM (solid shape): 174.5,100.59 174.5,99.58 173.95,99.03 173.95,98.23 173.86,98.14 173.71,98.14 173.64,98.21 173.64,99.04 173.74,99.13 173.74,99.77 173.55,99.96 173.55,100.59 173.61,100.66 174.44,100.66
U2_LGATE1 on BOTTOM (solid shape): 182.69,111.13 182.69,110.69 182.5,110.5 180.53,110.5 180.28,110.75 180.28,111.13 180.53,111.39 182.44,111.39
U2_LGATE1 on BOTTOM (solid shape): 172.28,107.07 172.28,106.56 172.15,106.43 170.71,106.43 170.37,106.77 169.23,106.77 169.17,106.83 169.17,106.96 169.25,107.03 170.44,107.03 170.57,107.16 172.19,107.16
U2_LGATE1 on IN6 (solid shape): 182.69,111.32 182.69,110.63 182.5,110.44 180.85,110.44 180.72,110.56 180.72,111.45 180.79,111.51 182.5,111.51
U2_LGATE1 on IN6 (solid shape): 172.29,107.06 172.29,106.39 172.09,106.2 170.52,106.2 170.37,106.34 170.37,107.02 170.51,107.16 172.2,107.16
U2_LGATE2 on BOTTOM (solid shape): 182.82,118.69 182.82,118.18 182.69,118.06 180.66,118.06 180.53,118.18 180.53,118.63 180.66,118.75 182.75,118.75
U2_LGATE2 on BOTTOM (solid shape): 171.46,109.52 171.46,108.53 171.28,108.35 170.34,108.35 170.24,108.25 169.25,108.25 169.17,108.33 169.17,108.46 169.25,108.53 170.21,108.53 170.41,108.74 170.41,108.99 171,109.57 171.4,109.57
U2_LGATE2 on IN6 (solid shape): 172.22,109.39 172.22,108.53 172.09,108.4 171.04,108.4 170.9,108.54 170.9,109.35 171.07,109.52 172.09,109.52
U2_LGATE2 on IN6 (solid shape): 182.75,118.51 182.75,117.8 182.56,117.61 180.85,117.61 180.66,117.8 180.66,118.5 180.88,118.73 182.54,118.73
U2_LGATE3 on BOTTOM (solid shape): 182.75,103.77 182.75,103.2 182.63,103.07 180.47,103.07 180.28,103.26 180.28,103.7 180.47,103.89 182.63,103.89
U2_LGATE3 on BOTTOM (solid shape): 172.91,96.78 172.91,95.97 172.97,95.91 172.97,94.7 172.83,94.55 172.57,94.55 172.46,94.67 172.46,95.79 172.66,95.98 172.66,96.78 172.72,96.85 172.85,96.85
U2_LGATE3 on IN6 (solid shape): 174.4,94.95 174.4,94.74 173.91,94.26 172.88,94.26 172.47,94.67 172.47,95.5 172.62,95.64 173.71,95.64
U2_LGATE3 on IN6 (solid shape): 182.69,103.77 182.69,102.82 182.56,102.69 180.21,102.69 180.02,102.88 180.02,103.7 180.28,103.96 182.5,103.96
U2_PHASE1 on BOTTOM (solid shape): 175.8,111.16 175.8,110.86 175.57,110.63 173.93,110.63 173.7,110.85 173.7,111.22 173.87,111.4 175.56,111.4
U2_PHASE1 on BOTTOM (solid shape): 171.32,105.54 171.32,103.45 171.2,103.32 170.31,103.32 170.12,103.51 170.12,105.4 169.17,106.34 169.17,106.46 169.25,106.53 170.33,106.53
