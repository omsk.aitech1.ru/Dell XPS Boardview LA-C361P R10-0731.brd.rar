# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N122409296: length 2.6
  TOP w0.127: UE1.4 158.29,6.93 RE14.2 RE13.1
N122409328: length 2.3
  TOP w0.14: UE1.28 153.93,4.24 154.61,3.56 v2(154.78,3.56) 155.14,3.2 RE77.2
N122409465: length 10.3
  TOP w0.14: UE1.21 151.01,6.93 150.72,6.65 RE114.2 150.18,6.65 149.68,6.16 148.08,6.16 146.48,7.76 146.48,8.75 146.64,8.91 146.64,9.4 146.38,9.66 v1(144.27,9.66)
N122409468: length 5.7
  TOP w0.127: RE113.2 151.19,4.66 151.13,4.72 151.13,5.2 151.36,5.43
  TOP w0.14: RE113.2 151.17,3.34 150.46,2.63 148.98,2.63 v1(148.5,3.11) ; 151.36,5.43 UE1.24
N122409512: length 6
  TOP w0.127: UE1.27 153.43,4.2 153.06,3.83 153.06,3.3 RE85.2
  TOP w0.14: v3(149.79,1.73) 151.42,1.73 152.19,2.5 152.87,2.5 RE85.2
N122409618: length 0.9
  TOP w0.14: RE11.2 150.22,8.64 CE8.1
N122463812: length 3.9
  TOP w0.14: JXDP.1 129.28,85.51 129.54,85.26 v2(129.54,84.79) 129.73,84.79 v3(130.09,85.15)
  BOTTOM w0.14: RH475.1 v2(129.54,84.79) 130.1,84.79 RH474.1
N122476680: length 29.2
  TOP w0.14: v2(129.91,100.1) 129.91,100.58 v1(130.15,100.82)
  IN1 w0.254: v2(149.16,104.91) 149.16,104.1 147.09,102.03 147.09,101.34 143.26,97.51 131.57,97.51 129.91,99.17 v2(129.91,100.1)
  BOTTOM w0.254: PR1218.2 148.91,105.16 v2(149.16,104.91) ; PR1201.1 128.79,99.25 PR1202.1 129.68,99.25 129.96,99.53 129.96,100.05 v2(129.91,100.1)
N122477585: length 33.7
  TOP w0.14: v2(149.16,112.59) v1(148.46,112.59)
  IN1 w0.254: v2(149.16,112.59) 149.16,111.97 145.96,108.76 144.26,108.76 143.68,108.19 143.68,106.11 143.05,105.48 143.05,101.81 140.75,99.51 133.05,99.51 131.53,101.02 129.52,101.02 v2(128.95,101.6)
  BOTTOM w0.254: PR1206.1 129.2,101.18 128.95,101.43 v2(128.95,101.6) 128.6,101.6 PR1205.1 ; PR1220.2 v2(149.16,112.59)
N122517438: length 2.9
  TOP w0.14: v3(112.42,5.1) 112.61,5.29 113.37,5.29 113.54,5.46 RH536.2 113.98,4.28 SW4.1
N122528028:
  vias: v1(231.12,48.69)
N122536166:
  vias: v1(27.26,67.12) v2(27.74,66.66) v2(28.04,67.22) v2(28.3,66.43) v2(28.3,65.82) v2(28.3,65.16) v2(28.3,64.47) v2(28.35,63.89) v2(28.47,61.91)
N122563835: length 8.2
  BOTTOM w0.076: UH1.BR33 137.75,82.37 136.07,82.37 135.99,82.45 134.62,82.45
  BOTTOM w0.14: RH519.2 131.33,83.96 v3(131.98,83.31) 131.98,82.93 132.46,82.45 133.66,82.45 133.77,82.56 134.38,82.56 134.49,82.45 134.62,82.45
N122630698: length 3.8
  TOP w0.254: D122.1 333.25,77.59 333.25,79.63 v3(333.19,79.69) 333.12,79.75 332.41,79.75 RH67.1
N122638318: length 24.8
  TOP w0.14: v2(106.81,9.9) 106.33,9.9 v1(105.75,9.33) 105,8.58 105,8.14 105.44,7.71 v2(105.44,6.8)
  IN6 w0.089: v2(90.74,7.97) 90.75,7.97 91.25,8.48 91.25,8.65 91.84,9.24 92.24,9.24 92.58,8.9 92.58,8.39 92.76,8.21 94.25,8.21 94.98,8.95 96.31,8.95 96.61,9.25 96.61,9.46 96.86,9.71 99.17,9.71 99.61,10.15 101.98,10.15
  IN6 w0.099: v2(106.81,9.9) 106.64,9.9 106.55,9.99 102.25,9.99 102.09,10.15 101.98,10.15
  BOTTOM w0.089: v2(90.74,7.97) 90.68,7.97 90.29,7.59 UH2.AV19
  BOTTOM w0.14: v2(105.44,6.8) 105.46,6.78 RH428.1
N122687725: length 13.3
  TOP w0.14: UZ11.1 177.71,4.47 177.42,4.76 177.42,5.47 177.31,5.58 RZ58.1 176.96,4.66 v2(176.79,4.48) ; v2(183.49,4.21) 183.19,3.9 182.25,3.9 UZ20.4 181.53,3.18 RZ85.1
  IN2 w0.099: v2(176.79,4.48) 183.22,4.48 v2(183.49,4.21)
N122698769: length 2
  TOP w0.089: v2(141.23,84.08) 140.81,84.5 T49.1
  BOTTOM w0.076: v2(141.23,84.08) 140.9,83.76 UH1.BL34
N122698770: length 2.2
  TOP w0.089: v2(176.51,58.63) 176.84,58.3 T39.1
  BOTTOM w0.076: v2(176.51,58.63) 176.51,59.31 UH1.D1
N122698771: length 1.4
  TOP w0.089: T44.1 137.42,60.39 v2(136.94,59.91)
  BOTTOM w0.076: UH1.BT2 137.34,60.31 v2(136.94,59.91)
N122698772: length 2.1
  TOP w0.089: T42.1 176.39,59.41 v2(176.02,59.04)
  BOTTOM w0.076: UH1.E2 175.71,60.28 175.71,59.34 v2(176.02,59.04)
N122698773: length 1.2
  TOP w0.089: v2(167.66,67.89) 167.98,68.21 T51.1
  BOTTOM w0.076: UH1.R14 167.97,68.2 v2(167.66,67.89)
N122698774: length 1.1
  TOP w0.089: T47.1 174.14,76.77 v2(173.86,77.05)
  BOTTOM w0.076: UH1.H24 173.48,76.67 v2(173.86,77.05)
N122698775: length 1.1
  TOP w0.089: v2(139.08,83.93) 138.72,84.29 T45.1
  BOTTOM w0.076: v2(139.08,83.93) 139.08,83.97 UH1.BN35
N122698776: length 2.1
  TOP w0.089: T50.1 169.59,81.18 v2(169.59,81.48)
  BOTTOM w0.076: v2(169.59,81.48) 169.59,80.83 UH1.N29
N122698777: length 1.2
  TOP w0.089: T53.1 162.75,68.21 v2(163.09,68.55)
  BOTTOM w0.076: v2(163.09,68.55) 163.44,68.2 UH1.AA14
N122698778: length 1.3
  TOP w0.089: v2(175.33,59.22) 175.1,58.98 T40.1
  BOTTOM w0.076: v2(175.33,59.22) 175.3,59.25 UH1.E1
N122698779: length 2.4
  TOP w0.089: T43.1 136.79,59 v2(136.65,59.14)
  BOTTOM w0.076: v2(136.65,59.14) 137.12,59.14 137.71,59.74 UH1.BR1
N122698780: length 1.6
  TOP w0.089: T41.1 175.66,60.85 v2(176.16,60.36)
  BOTTOM w0.076: v2(176.16,60.36) 176.16,60.42 175.61,60.97 UH1.E3
N122698781: length 1.7
  TOP w0.089: T48.1 139.09,82.33 v2(139.73,82.33)
  BOTTOM w0.076: UH1.BN33 139.4,82.65 v2(139.73,82.33)
N122698782: length 1.7
  TOP w0.089: v2(160.92,81.5) 160.91,81.5 T52.1
  BOTTOM w0.076: v2(160.92,81.5) 160.92,80.86 UH1.AE29
N122698783: length 2.2
  TOP w0.089: T46.1 172.41,75.35 v2(172.41,75.48)
  BOTTOM w0.076: UH1.J24 172.41,76.24 v2(172.41,75.48)
N122698814: length 5.5
  BOTTOM w0.076: UH1.E30 175.48,81.17 175.62,81.03 179.27,81.03 179.48,81.24 179.9,81.24
  BOTTOM w0.14: 179.9,81.24 180.43,81.24 T58.1
N122698815: length 4.1
  BOTTOM w0.076: UH1.BR35 137.75,84.63 136.65,84.63 136.43,84.85 134.62,84.85
  BOTTOM w0.14: T63.1 134.62,84.85
N122698816: length 1.2
  TOP w0.089: T65.1 143.22,81.07 v2(142.8,81.49)
  BOTTOM w0.076: UH1.BH30 142.42,81.11 v2(142.8,81.49)
N122698817: length 1.1
  TOP w0.089: T62.1 173.35,61.05 v2(173.72,61.41)
  BOTTOM w0.076: UH1.J3 173.34,61.04 v2(173.72,61.41)
N122698818: length 5.3
  TOP w0.089: T59.1 177.99,80.58 179.05,81.63 179.05,82.1 v2(178.74,82.41)
  BOTTOM w0.076: v2(178.74,82.41) 179.07,82.07 179.07,81.67 178.66,81.26 177.54,81.26 UH1.B30
N122698819: length 1.8
  TOP w0.089: v2(139.09,81.56) 138.81,81.28 T64.1
  BOTTOM w0.076: v2(139.09,81.56) 138.48,81.56 UH1.BR31
N122698820: length 1.5
  TOP w0.089: v2(173.76,60.73) 174.21,60.28 T61.1
  BOTTOM w0.076: v2(173.76,60.73) 174.07,61.04 UH1.G3
N122698821: length 1.2
  TOP w0.089: T57.1 174.42,81.67 v2(174.54,81.79)
  BOTTOM w0.076: UH1.F30 174.83,81.5 v2(174.54,81.79)
N122698822: length 1
  TOP w0.089: v2(177.09,81.76) 176.77,81.44 T60.1
  BOTTOM w0.076: v2(177.09,81.76) 176.78,81.45 UH1.C30
N122698841: length 1.1
  TOP w0.089: T82.1 142.29,83.16 v2(142.01,83.43)
  BOTTOM w0.076: UH1.BJ33 141.69,83.11 v2(142.01,83.43)
N122698842: length 5.5
  BOTTOM w0.14: UH1.C38 178.04,87.65 178.93,87.65 179.64,88.37 T90.1
N122698843: length 3.8
  BOTTOM w0.127: UH1.B2 177.71,60.11 177.71,56.97 T85.1
N122698844: length 4.9
  TOP w0.089: v2(173.83,68.41) 174.22,68.79 177.89,68.79 T83.1
  BOTTOM w0.076: UH1.G13 174.18,68.07 v2(173.83,68.41)
N122698845: length 4.3
  TOP w0.089: v2(136.21,58.69) 136.32,58.58 T88.1
  BOTTOM w0.076: v2(136.21,58.69) 137.28,58.69 137.85,59.25 138.1,59.25 138.39,59.54 138.39,60.21 UH1.BR2
N122698846: length 1.1
  TOP w0.089: v2(142.01,84.08) 142.29,84.36 T81.1
  BOTTOM w0.076: v2(142.01,84.08) 141.69,83.76 UH1.BJ34
N122698847: length 6.5
  BOTTOM w0.14: UH1.B38 178.37,87.21 178.99,87.21 180.04,88.25 180.04,90.79 T86.1
N122698848: length 4.1
  BOTTOM w0.127: T89.1 176.39,57.64 177.21,58.47 177.21,59.34 UH1.C1
N122698849: length 2.7
  TOP w0.089: T84.1 156.38,62.07 156.74,62.44 v2(156.74,63.97)
  BOTTOM w0.076: v2(156.74,63.97) 157.07,64.3 UH1.AJ8
N122698850: length 5.1
  TOP w0.089: v2(135.75,58.27) 135.75,57.68 135.3,57.22 T87.1
  BOTTOM w0.076: UH1.BP1 138.74,59.62 138.07,58.95 137.86,58.95 137.78,58.95 137.1,58.27 v2(135.75,58.27)
N122698871: length 1.1
  TOP w0.089: v2(141.01,73.67) 141.38,74.04 T77.1
  BOTTOM w0.076: UH1.BK21 141.35,74.02 v2(141.01,73.67)
N122698872: length 1.1
  TOP w0.089: v2(142.46,69.87) 142.5,69.91 T73.1
  BOTTOM w0.076: UH1.BJ16 142,70.12 142.26,69.87 v2(142.46,69.87)
N122698873: length 1.1
  TOP w0.089: v2(141.01,70.52) 140.98,70.49 T74.1
  BOTTOM w0.076: UH1.BK16 141.35,70.17 v2(141.01,70.52)
N122698874: length 3.4
  BOTTOM w0.076: UH1.BR17 137.82,71.19 137.28,71.19 137.02,70.94 T80.1
N122698875: length 1.1
  TOP w0.089: v2(140.98,76.02) 141.36,76.4 T75.1
  BOTTOM w0.076: UH1.BK24 141.35,76.39 v2(140.98,76.02)
N122698876: length 1.3
  TOP w0.089: T78.1 142.48,74.35 v2(142.45,74.32)
  BOTTOM w0.076: UH1.BJ21 142.19,74.06 v2(142.45,74.32)
N122698877: length 1.3
  TOP w0.089: v2(142.54,76.16) 142.91,76.53 T76.1
  BOTTOM w0.076: UH1.BJ24 142.28,76.42 v2(142.54,76.16)
N122698878: length 1
  TOP w0.089: v2(137.72,70.51) 138.09,70.14 T79.1
  BOTTOM w0.076: UH1.BT17 137.45,70.78 v2(137.72,70.51)
N122698895: length 1.1
  TOP w0.089: v2(139.73,83.12) 140.12,82.73 T66.1
  BOTTOM w0.076: v2(139.73,83.12) 140.05,82.79 UH1.BM33
N122698896: length 1.5
  TOP w0.089: T68.1 142.17,69.26 v2(142.52,68.92)
  BOTTOM w0.076: UH1.BJ14 142.15,68.59 142.48,68.92 v2(142.52,68.92)
N122698897: length 1.5
  TOP w0.089: T71.1 142.71,78.9 v2(142.49,79.12)
  BOTTOM w0.076: UH1.BJ28 142.04,79.57 v2(142.49,79.12)
N122698898: length 2.2
  TOP w0.089: v2(143.09,68.97) 143.41,69.29 T69.1
  BOTTOM w0.076: v2(143.09,68.97) 142.68,68.56 142.45,68.56 141.96,68.07 UH1.BJ13
N122698899: length 1.5
  TOP w0.089: T67.1 141.04,83.43 v2(141.23,83.43)
  BOTTOM w0.076: v2(141.23,83.43) 140.9,83.11 UH1.BL33
N122698900: length 1.6
  TOP w0.089: T70.1 140.76,80.3 v2(140.42,79.96)
  BOTTOM w0.076: UH1.BK28 141.22,79.57 140.84,79.96 v2(140.42,79.96)
N122706757: length 80.9
  TOP w0.254: v2(104.52,64.78) 104.52,64.91 105.04,65.43 PR806.2 ; v2(128.7,64.96) 125.39,64.96 123.15,62.72 119.12,62.72 115.58,66.25 111.16,66.25 110.86,66.56 v2(110.55,66.56) ; v2(170.01,71.23) 170.33,71.55 PR810.2 PR809.1
  IN1 w0.254: v2(104.52,64.78) 104.86,65.12 106.25,65.12 107,65.87 107,66.37 107.38,66.75 109.86,66.75 110.05,66.56 v2(110.55,66.56)
  IN6 w0.254: v2(170.01,71.23) 169.19,70.4 166.02,70.4 165.45,70.98 165.45,72.55 164.5,73.5 160.44,73.5 158.55,71.61 151.86,71.61 151.54,71.29 151.17,71.29 149.01,73.45 145.29,73.45 142.9,71.07 142.02,71.07 141.34,71.75 138.33,71.75 137.14,70.56 133.62,70.56 131.45,68.39 131.45,67.66 128.77,64.98 128.68,64.98 v2(128.7,64.96)
N122715521: length 5.2
  BOTTOM w0.254: PQ206.1 25.08,100.71 24.82,100.97 23.55,100.97 23.24,100.67 v3(23.24,100.38) 23.17,100.3 23.17,98.15 PR206.2
N122716785: length 12.3
  TOP w0.254: v2(24.01,54.84) 24.08,54.77 24.76,54.77 25.04,55.05 v3(25.04,56.07) 25.04,57.21 23.85,58.4 23.85,60.82 24.74,61.71 25.65,61.71 25.91,61.96 25.91,62.63
  BOTTOM w0.254: PR220.2 23.01,55.11 PR229.1 23.36,54.77 23.95,54.77 v2(24.01,54.84)
N122717029: length 7.1
  TOP w0.14: PQ216.1 24.94,59.18 v1(24.39,58.62)
  TOP w0.254: PR227.1 26.68,64.21 26.68,61.61 25.63,60.55 PQ216.1
N122717226: length 4.2
  BOTTOM w0.14: PR206.1 22.76,98.66 v3(22.76,99.03)
  BOTTOM w0.254: PR206.1 PR202.2 21.16,96.96 PQ204.2
N122717329: length 2.6
  BOTTOM w0.254: PQ219.3 28.4,95.96 v3(28.24,96.12) 27.74,96.12 27.5,96.36 PQ232.1
N122717720: length 1.5
  BOTTOM w0.254: PR230.2 25.27,92.43 PQ222.1
N122717744: length 3
  BOTTOM w0.254: PQ217.2 25.11,91.35 PR230.1 PR223.2
N122719403: length 9.6
  BOTTOM w0.254: PR225.2 19.03,57.42 19.75,56.7 19.75,55.43 19.34,55.03 19.34,54.48 v1(19.21,54.35) 19.21,54.21 18.75,53.74 18.75,51.45 18.67,51.38 18.67,50.41 17.77,49.51 PQ218.1
N122719762: length 1.4
  BOTTOM w0.14: PC221.2 17.29,59.51 v3(16.09,59.51)
N122728389: length 9.3
  TOP w0.14: v3(28.65,8.4) 28.83,8.58 v2(29.24,8.58)
  TOP w0.254: PQ202.4 29.86,9.69 30.13,9.42 30.13,8.56 PR210.1 29.53,8.33 29.27,8.58 v2(29.24,8.58)
  BOTTOM w0.254: v2(29.24,8.58) 27.28,10.54 v2(24.09,10.54)
N122728402: length 4.8
  TOP w0.14: v1(33.53,5.86) 32.59,5.86 31.5,4.77 PQ210.1
  TOP w0.254: PQ207.3 31.05,6.03 31.23,5.85 31.23,5.5 31.05,5.32 PQ210.1
N122729223:
  vias: v3(27.91,12.66)
N122733349: length 13.3
  TOP w0.14: v3(13.08,22.65) 12.08,22.65 11.99,22.55 v2(11.01,22.55)
  TOP w0.254: PR263.1 PR259.1 10.77,22.79 v2(11.01,22.55)
  IN3 w0.254: v2(10.95,17.8) 11.13,17.8 12.12,18.79 12.12,21.71 11.28,22.55 v2(11.01,22.55)
  BOTTOM w0.254: PU202.5 10.4,19.65 10.31,19.57 PC214.2 PR261.2 10.31,18.44 v2(10.95,17.8)
N122733365: length 13
  TOP w0.14: v1(12.04,25.28) 12.04,24.8 v2(11.63,24.39)
  TOP w0.254: PR257.1 PR264.2 10.85,24.77 11.23,24.39 v2(11.63,24.39)
  IN3 w0.254: v2(11.63,24.39) 11.13,24.39 10.4,23.67 10.4,21.38 11.52,20.27 v2(11.52,18.93)
  BOTTOM w0.254: v2(11.52,18.93) 12.09,18.93 12.64,19.48 12.64,20.04 12.38,20.3 PU202.6
N122733968: length 3.7
  BOTTOM w0.14: PQ228.1 10.81,24.79 v3(10.81,25.36)
  BOTTOM w0.254: PR253.1 9.46,23.83 9.75,24.13 PQ228.1
N122734450: length 11
  BOTTOM w0.14: v1(12.01,23.93) 12.01,23.45 13.13,22.34 13.78,22.34 14.92,21.19 14.92,20.86 15.48,20.3 PU202.3
  BOTTOM w0.254: PR273.1 16.98,20.07 16.76,20.3 PU202.3 ; PR273.1 17.65,20 PR260.2 ; PR273.1 PR258.1 PC215.2
N122734452: length 4.8
  BOTTOM w0.14: PR265.2 14.44,23.63 v3(14.05,24.02)
  BOTTOM w0.254: PR265.2 PR254.1 15.36,21.86 15.24,21.75 15.24,21.41 15.7,20.95 PU202.2
N122739033: length 10
  TOP w0.14: UZ11.2 178.67,3.28 RZ59.2 178.77,2.88 179.05,2.6 v1(187.07,2.6)
N122739099: length 9
  TOP w0.14: v1(167.23,2.9) 167.5,2.62 169.99,2.62 170.37,3 UZ21.4 170.77,3.68 171.01,3.44 RZ86.1 171.93,3.87 171.93,4.48 RZ60.1 171.84,4.92 172.06,4.71 172.91,4.71 UZ12.1
N122739340: length 3.9
  TOP w0.14: v3(175.85,3.44) 175.57,3.72 174.16,3.72 RZ61.2 173.62,3.92 173.78,4.08 UZ12.2
N122753661: length 3.8
  BOTTOM w0.254: PQ206.2 25.73,99.31 26.11,99.69 26.11,100.77 v3(26.35,101.01) PR268.2
N122754331: length 1.4
  TOP w0.14: 129.45,66.99 v1(128.02,66.99)
N122754354: length 3.8
  TOP w0.14: v1(130.57,70.5) 131.15,69.92 CZ57.1 131.15,68.69 130.84,68.37 130.84,67.93 131.07,67.7 UZ16.6
N122755391:
  vias: v3(185.79,83.71)
N122762967: length 1.7
  TOP w0.14: v3(228.21,58.28) 228.63,58.7 RZ69.1
N122763041: length 3
  TOP w0.127: CZ95.1 229.28,61.35 v2(229.47,61.16) 229.8,60.84 UZ17.6
  BOTTOM w0.14: v2(229.47,61.16) v1(229.47,59.97)
N122772225: length 1.2
  BOTTOM w0.254: PQ208.1 20.32,89.26 PR205.2
N122772428: length 9.4
  BOTTOM w0.14: v3(24.41,87.09) 23.09,87.09 PR213.2
  BOTTOM w0.254: PR213.2 23.06,87.58 23.24,87.76 PR217.1 22.63,88.93 22.63,89.59 22.73,89.7 PQ211.1 22.73,90.84 22.05,91.52 20.01,91.52 19.67,91.86 PQ208.2
N122774125: length 81
  TOP w0.254: PR813.2 PR808.1 171.84,70.68 v2(172.31,71.15) ; v2(129.49,64.83) 129.49,64.95 128.94,65.49 v1(126.14,65.49) 125.37,65.49 122.97,63.09 119.25,63.09 115.71,66.63 111.41,66.63 110.85,67.19 v2(110.55,67.19)
  IN1 w0.254: v2(110.55,67.19) 107.19,67.19 106.62,66.62 106.62,66.18 v2(106.49,66.05)
  IN6 w0.254: v2(129.49,64.83) 129.49,65.09 131.87,67.47 131.87,68.17 133.82,70.12 136.99,70.12 137.25,69.86 140.97,69.86 141.84,70.72 143.04,70.72 145.43,73.11 148.86,73.11 151.02,70.95 151.68,70.95 152,71.27 158.69,71.27 160.58,73.16 164.36,73.16 165.11,72.41 165.11,70.83 165.88,70.06 171.22,70.06 v2(172.31,71.15)
  BOTTOM w0.254: PR804.2 107.13,65.71 106.78,66.05 v2(106.49,66.05)
N122777610: length 1.3
  BOTTOM w0.254: PQ222.2 24.62,96.31 PR228.2
N122777613: length 4.2
  BOTTOM w0.14: PQ223.2 26.47,53.34 27.21,52.59 27.21,51.7 v1(26.85,51.33)
  BOTTOM w0.254: PQ223.2 27.08,54.37 PR231.2
N122912247: length 1.6
  TOP w0.14: v1(183.32,79.02) 182.54,79.8 182,79.8
N123037911:
  vias: v2(202.06,58.17)
N123346527: length 9.8
  TOP w0.14: QV13.1 23.59,77.99 v1(23.86,78.26)
  TOP w0.508: QV13.1 22.79,80 RV514.2 RV515.2 RV516.2 RV517.2 RV512.2 RV513.2 RV518.2 RV519.2
N123360127: length 2.1
  TOP w0.089: v2(25.41,37.09) 24.93,36.62 v3(24.92,36.62) 24.92,36.27 RT12.1
  BOTTOM w0.102: UT1.H19 v2(25.41,37.09)
N123360144: length 5.1
  TOP w0.089: v2(30.61,37.73) 30.46,37.73 30.15,37.42 30.15,37.1 29.87,36.83 29.77,36.83 29.55,36.61 29.55,35.76 v1(30.1,35.21) 30.19,35.12 RT5.1
  BOTTOM w0.076: v2(30.61,37.73) 30.61,37.74 30.93,38.06 UT1.Y18
N123628000: length 318.8
  TOP w0.14: v2(59.28,28.57) 58.7,28.57 58.24,29.03 57.61,29.03 v1(57.11,29.54)
  IN2 w0.099: v2(59.28,28.57) 60.58,29.87 70.22,29.87 70.79,29.3 73.76,29.3 74.12,29.66 79.82,29.66 80.71,30.55 84.33,30.55 88.13,34.35 97.84,34.35 100.86,37.37 110.88,37.37 115.47,32.78 139.04,32.78 145.91,25.91 153.96,25.91 155.01,24.86 156.84,24.86 157.36,24.34 157.36,19.63 158.79,18.2 172.9,18.2 173.14,17.96 175.49,17.96 175.95,17.5 246.48,17.5 248.04,15.93 252.87,15.93 254.27,17.33 259.65,17.33 261.18,18.86 264.39,18.86 264.61,19.08 267.44,19.08 268.5,20.14 273.56,20.14 274.11,19.58 278.5,19.58 279.11,20.2 280.25,20.2 281.7,21.65 290.33,21.65 291.03,22.35 291.63,22.35 293.7,24.42 296.42,24.42 297.65,25.65 298.61,25.65 299.51,26.55 301.6,26.55 302.59,27.54 316.18,27.54 325.55,36.92 325.55,43.99 v2(333.17,51.61)
  BOTTOM w0.127: v2(59.28,28.57) 59.28,28.39 55.51,24.63 55.51,24.53 DI1.2
  BOTTOM w0.14: v2(333.17,51.61) 332.99,51.43 JTS.2
N123760602: length 7.3
  TOP w0.14: v1(30.82,26.19) 30.49,26.19 29.45,25.15 PR271.1
  TOP w0.254: PR271.1 29.34,25.08 PR272.1 29.22,24.14 PQ225.1 27.75,24.14 27.5,23.88 27.5,23.59 27.18,23.27 27.18,22.49 26.91,22.22 PU203.4
N123974826: length 28.9
  IN5 w0.254: v2(16.61,43.68) 16.89,43.68 17.43,43.15 17.43,40.98 19.72,38.69 19.72,26.65 v2(19.62,26.55)
  BOTTOM w0.254: PQ218.2 18.28,47.15 17.01,45.88 17.01,44.08 v2(16.61,43.68) ; v2(19.62,26.55) 19.62,26.97 20.04,27.39 20.04,29.2 20.57,29.73 21.08,29.73 21.22,29.87 PR290.2 PR291.2
N123983992:
  vias: v1(111.05,67.85) v2(111.63,68.14) v2(111.66,67.5) v2(112.33,68.14) v2(112.35,67.52) v2(112.95,68.16) v2(112.98,67.57) v2(113.56,68.16) v2(113.62,67.57)
N123984002: length 49.4
  TOP w0.14: v2(107.13,101.16) 107.13,100.73 v1(107.48,100.38)
  TOP w0.254: v2(107.13,101.16) 107.19,101.23 PR1305.1
  IN1 w0.254: v2(107.13,101.16) 106.55,101.74 105.92,101.74 105.35,101.16 105.35,95.51 103.76,93.93 103.76,81.97 106.15,79.59 109.68,79.59 109.79,79.7 112.21,79.7 112.51,80.01 115.27,80.01 116.02,79.26 116.02,70.68 115.7,70.37 v2(115.44,70.37)
  BOTTOM w0.254: PR1314.2 v2(115.44,70.37) ; PR1306.1 107.19,101.23 v2(107.13,101.16)
N123984012:
  vias: v1(105.73,95.68) v2(106.49,94.31) v2(106.49,93.67) v2(106.94,96.72) v2(107.57,96.72)
N123984055: length 4.1
  TOP w0.14: PR1311.1 115.32,95.25 115.11,95.45 114.52,95.45 v3(114.21,95.14)
  TOP w0.508: PR1311.1 115.77,95.25 116.27,94.75 v2(116.84,94.75)
  BOTTOM w0.254: v2(116.84,94.75) 116.77,94.68 PU1302.2
N123984061: length 10.7
  TOP w0.14: v1(107.86,91.03) 107.96,91.13 v2(108.46,91.13)
  TOP w0.254: v2(112.84,95.96) 113.03,96.15 PC1313.1
  IN6 w0.762: 109.09,91.96 108.9,92.15 108.9,96.66 109.73,97.48 111.71,97.48 112.41,96.78 112.84,96.78
  vias: v2(109.09,91.13) v2(112.84,95.32)
N123984063: length 12.5
  TOP w0.14: v1(105.7,91.12) 105.91,91.32 v2(106.55,91.32)
  IN6 w0.762: 115.7,94.31 115.38,93.99 114.75,93.99 114.05,93.29 114.05,92.34 113.03,91.32 110.81,91.32 109.22,89.73 107.51,89.73 106.87,90.37
  vias: v2(107.15,91.32) v2(116.5,95.45) v2(117.1,95.45)
N123984071: length 3.4
  TOP w0.14: v1(112.68,97.12) 113.69,97.12 114.44,96.37 PC1313.2
  TOP w0.254: PR1311.2 114.45,96.16 PC1313.2
N123984081: length 31
  TOP w0.14: v1(105.65,100.26) 106.36,100.97 v2(106.36,101.1)
  TOP w0.254: v2(106.36,101.1) 106.17,101.1 105.92,101.35 PR1301.1
  IN1 w0.254: v2(115.7,82.56) 115.7,83.51 114.75,84.46 114.36,84.46 111.95,86.88 106.62,86.88 105.28,88.21 105.28,94.44 105.86,95.01 105.86,100.59 v2(106.36,101.1)
  BOTTOM w0.254: v2(106.36,101.1) 105.98,101.48 PR1303.1 ; PR1312.2 v2(115.7,82.56)
N123984161: length 1
  BOTTOM w0.14: v1(104.04,91.58) 104.41,91.21 104.85,91.21
N123984183:
  vias: v1(112.1,82.88) v2(111.25,80.25) v2(111.91,80.25) v2(114.63,80.55) v2(114.66,81.75) v2(114.66,81.14) v2(115.24,80.53) v2(115.27,81.77) v2(115.29,81.14)
N123984193: length 6.7
  BOTTOM w0.14: v1(103.77,90.08) 103.77,83.71 104.02,83.46
N123984213: length 48.4
  TOP w0.14: v2(115.44,71) v1(115.44,71.66)
  TOP w0.254: PR1304.1 v2(108.27,101.1)
  IN1 w0.254: v2(115.44,71) 115.44,71.13 115.38,71.19 115.38,79.19 115.01,79.56 112.64,79.56 112.4,79.32 109.91,79.32 109.83,79.23 106,79.23 105.97,79.26 105.97,79.26 103.4,81.82 103.4,81.83 103.4,94.21 104.97,95.78 104.97,101.42 105.73,102.18 107.19,102.18 v2(108.27,101.1)
  BOTTOM w0.254: PR1315.2 116.24,70.43 115.67,71 v2(115.44,71)
N123984277: length 29.1
  TOP w0.14: v2(111.25,89.29) v1(112.09,89.29)
  TOP w0.254: v2(127.72,103.3) 127.7,103.32 PR1310.1
  IN1 w0.254: v2(127.72,103.3) 127.72,103.26 127.19,102.73 126.02,102.73 125.76,102.47 124.09,102.47 122,100.38 122,93.83 121.24,93.07 120.49,93.07 120.05,92.64 120.05,92.3 118.72,90.97 115.13,90.97 114.27,90.12 111.7,90.12 111.25,89.67 v2(111.25,89.29)
  BOTTOM w0.254: v2(111.25,89.29) 111.25,89.19 PR1317.2
N123984281: length 28.4
  TOP w0.14: v2(110.62,89.29) v1(109.94,89.29)
  TOP w0.254: v2(126.37,103.54) 126.62,103.79 PR1309.1
  IN1 w0.254: v2(110.62,89.29) 110.68,89.35 110.68,89.8 111.38,90.5 113.95,90.5 114.78,91.32 118.57,91.32 119.7,92.45 119.7,92.78 120.35,93.43 121.1,93.43 121.64,93.98 121.64,100.53 123.94,102.83 125.5,102.83 126.19,103.51 126.33,103.51 126.35,103.54 v2(126.37,103.54)
  BOTTOM w0.254: PR1316.2 110.29,88.71 110.62,89.04 v2(110.62,89.29)
N123984351:
  vias: v1(111.98,92.58)
N123984423: length 1.7
  TOP w0.14: v1(110.36,73.85) 110.73,73.48 PC1347.1
N123984459: length 0.7
  TOP w0.14: 110.96,77.34 110.68,77.34 v1(110.41,77.07)
N123985122: length 31.1
  TOP w0.14: v2(109.22,101.1) 109.22,100.52 v1(109.3,100.44)
  TOP w0.254: PR1302.2 v2(109.22,101.1)
  IN1 w0.254: v2(109.22,101.1) 108.59,100.47 106.81,100.47 106.3,99.96 106.3,94.88 105.73,94.31 105.73,88.34 106.81,87.26 112.14,87.26 114.56,84.84 115,84.84 116.33,83.51 v2(116.33,82.56)
  BOTTOM w0.254: PR1313.2 v2(116.33,82.56)
N124073057: length 6
  TOP w0.14: v2(314.31,32.33) 316.12,32.33 316.8,33.02 v3(317.51,33.02) 317.83,33.33 RI36.2
  BOTTOM w0.14: DI11.2 313.56,32.8 314.03,32.33 v2(314.31,32.33)
N124199479: length 4.6
  TOP w0.14: v1(249.78,51.84) 248.97,52.65 248.13,52.65 PR705.2 247.02,52.16 246.85,51.99 246.55,51.99 246.29,51.74 PU700.28
N124211085: length 2.8
  TOP w0.089: v3(23.75,35.63) 24.35,35.63 RT164.2 24.53,36.03 24.53,36.87 v2(24.76,37.09)
  BOTTOM w0.102: UT1.F19 v2(24.76,37.09)
N124411322: length 14.3
  TOP w0.14: PD204.1 26.21,1.76 24.55,1.76 v1(24.33,1.55)
  TOP w0.254: PD204.1 v2(27.47,1.76) 27.99,2.28 PQ209.2 ; v2(18.61,1.53) 18.48,1.66 PR292.1
  IN1 w0.254: v2(18.61,1.53) 27.24,1.53 v2(27.47,1.76)
N124417517: length 3.5
  TOP w0.14: v2(27.27,28.49) 27.65,28.87 v3(27.65,29.35)
  TOP w0.254: v2(27.27,28.49) 27.16,28.38 PR238.2 PR256.2
  BOTTOM w0.254: v2(27.27,28.49) 27.38,28.38 PU201.2
N124417993: length 2.5
  TOP w0.254: PQ207.2 29.4,7.33 PR212.1 28.98,6.9 28.98,6.9 28.83,6.75 28.83,6.75 28.45,6.37 PR299.1
N124420412: length 15
  TOP w0.254: PR207.2 25.1,54.19 v2(25.15,54.24)
  IN3 w0.254: v2(20.43,60.54) 18.71,58.81 v2(18.71,56.45) 19.63,56.45 20.87,55.21 22.32,55.21 23.29,54.24 v2(25.15,54.24)
  BOTTOM w0.203: PR215.3 20.44,60.54 v2(20.43,60.54)
  BOTTOM w0.254: PR21.1 17.81,56.45 v2(18.71,56.45)
N124420521: length 5.7
  BOTTOM w0.203: PR233.2 17.3,56.91 18.91,56.91 19.26,56.56 v3(19.26,56.15) 19.26,55.72 18.93,55.4 18.51,55.4 18.04,54.92 PU200.6
N124420534: length 10
  IN3 w0.254: v2(18.71,55.86) 18.54,55.86 18.04,56.36 18.04,58.72 19.92,60.6 v2(19.92,60.84)
  BOTTOM w0.203: v2(19.92,60.84) 20.07,60.84 20.44,61.2 PR215.2
  BOTTOM w0.254: PR21.2 16.84,56.37 17.22,55.99 17.22,55.98 17.36,55.84 17.37,55.84 PR211.2 18.11,55.86 v2(18.71,55.86)
N124420538: length 13.7
  TOP w0.14: v2(23.14,52.84) 23.14,53.45 22.76,53.83 v1(22.76,55.67)
  TOP w0.254: PR207.1 23.57,53.27 v2(23.14,52.84)
  IN3 w0.091: v2(23.14,52.84) 23.13,52.84 23.13,53.28 21.8,54.62 19.05,54.62 v2(18.74,54.94)
  BOTTOM w0.14: PU200.4 16.74,53.81 16.92,53.62 18.17,53.62 18.48,53.93 18.48,54.68 v2(18.74,54.94)
N124425215: length 4.2
  TOP w0.14: v3(32.11,8.38) 31.92,8.57 31.05,8.57 PR210.2
  TOP w0.254: PQ207.1 31.81,6.68 31.48,7.01 31.48,7.65 PR210.2
N124426141: length 82.7
  TOP w0.14: v1(11.86,2.5) 11.52,2.84 v2(11.52,3.17)
  TOP w0.254: v2(11.52,3.17) PR218.1
  IN2 w0.254: v2(14.54,40.48) 14.72,40.48 15.61,41.38 16.85,41.38 17.55,42.08 17.55,43.82 19.1,45.37 19.1,48.79 18.59,49.29 18.59,52.82 19.38,53.61 19.38,56.72 19.06,57.04 19.06,61.94 20.36,63.24 20.36,64.36 23.91,67.92 24.44,67.92 v2(24.58,68.06)
  IN6 w0.254: v2(11.52,3.17) 11.2,3.49 11.2,4.33 10.69,4.85 8.74,4.85 8.13,5.46 8.13,9.08 7.61,9.6 7.61,15.69 5.48,17.81 5.48,20.13 8.4,23.04 8.81,23.04 12.88,27.11 12.88,30.21 12.13,30.96 12.13,32.12 15.06,35.05 15.06,37.83 15.2,37.97 15.2,39.95 14.68,40.48 v2(14.54,40.48)
  BOTTOM w0.254: v2(24.58,68.06) 24.32,67.8 PR216.2
N124426143: length 82.4
  TOP w0.14: v1(9.65,2.51) 10.33,3.18 v2(10.59,3.18)
  TOP w0.254: v2(10.59,3.18) PR221.1
  IN2 w0.254: v2(24.58,67.37) 24.41,67.53 24.04,67.53 20.72,64.21 20.72,63.09 19.42,61.79 19.42,57.19 19.73,56.87 19.73,53.41 18.95,52.62 18.95,49.44 19.45,48.94 19.45,45.19 17.91,43.65 17.91,41.93 16.99,41.02 15.76,41.02 14.62,39.88 v2(14.54,39.88)
  IN6 w0.254: v2(14.54,39.88) 14.85,39.57 14.85,38.12 14.66,37.93 14.66,35.19 11.75,32.28 11.75,30.83 12.14,30.44 12.14,30.44 12.52,30.06 12.52,27.26 8.69,23.43 8.29,23.43 5.13,20.28 5.13,17.66 7.25,15.54 7.25,9.45 7.77,8.93 7.77,5.31 8.59,4.49 10.54,4.49 10.85,4.19 10.85,3.44 v2(10.59,3.18)
  BOTTOM w0.254: PR216.3 25.01,67.8 v2(24.58,67.37)
N124428383: length 1.6
  BOTTOM w0.254: PR229.2 23.34,53.68 23.92,53.11 PQ223.1
N124494273: length 4.5
  BOTTOM w0.081: UT4.C10 6.55,39.67 6.55,39.81 6.55,39.82 6.55,40.54 6.21,40.88 6.21,41.05 6.51,41.35
  BOTTOM w0.14: 6.51,41.35 6.59,41.43 v3(6.59,42.1) 6.59,42.22 6.4,42.41 6.4,42.92 RT181.1
N124494860: length 2.4
  TOP w0.14: CT158.1 7.29,35.49 7.6,35.8 7.6,35.8 7.72,35.92 v2(8.21,36.41)
  BOTTOM w0.081: v2(8.21,36.41) 8.21,36.83 UT4.H7
N124494892: length 7.1
  BOTTOM w0.081: UT4.G2 11.05,37.67 12.34,37.67 12.76,37.25 12.76,37.02 12.9,36.87 13.62,36.87
  BOTTOM w0.14: 13.62,36.87 15.15,36.87 15.88,37.6 RT191.1 15.95,38.31 v3(15.7,38.57)
N124539520: length 2.9
  TOP w0.14: v2(8.8,36.41) 8.8,35.61 RT183.1 9.59,35.44 v3(10.1,34.93)
  BOTTOM w0.081: UT4.H6 v2(8.8,36.41)
N124539694: length 2.1
  BOTTOM w0.081: 5.36,36.81 5.83,36.81 6.3,37.28 UT4.G11
  BOTTOM w0.14: T187.1 4.98,36.81 5.36,36.81
N124539765: length 2.2
  TOP w0.14: v2(8,39.38) 8,39.24 v3(8.31,38.93) 8,38.63 RT182.1
  BOTTOM w0.081: UT4.D7 8,39.22 v2(8,39.38)
N124539944: length 0.5
  BOTTOM w0.081: UT4.E2 UT4.F2
N124607348: length 4
  TOP w0.14: v1(20,26.08) 19.38,26.08 18.65,26.81 QV89.1 18.07,26.81 17.95,26.68 RT195.1
N124695542: length 4.4
  TOP w0.14: PR237.1 11.25,7.4 v1(10.61,8.05)
  TOP w0.254: PQ215.2 13.15,7.86 PR244.2 PR237.1
N124695548: length 1.9
  TOP w0.14: v1(18.47,4.77) 18.03,5.2 18.03,6.5
N124695638: length 23.3
  TOP w0.14: PQ209.1 28.64,5.09 29.05,5.5 29.39,5.5 v3(29.54,5.34)
  TOP w0.254: v2(28.65,3.76) 28.65,4.76 PQ209.1 ; v2(11.01,6.85) 11.38,6.49 PR237.2
  IN2 w0.099: v2(11.01,6.85) 13.08,4.78 15.4,4.78 17.23,2.96 22.34,2.96 23.53,4.15 23.98,4.15 24.37,3.76 v2(28.65,3.76)
N124696815: length 3.3
  TOP w0.14: v1(22.96,2.76) 22.99,2.74 PR266.2
  TOP w0.254: PR266.2 25.24,2.74 25.56,3.07 PD204.3
N124699186: length 16.7
  TOP w0.254: PQ234.1 23.31,9.6 PR274.1 22.91,10.22 v2(22.61,9.91) ; v2(29.85,2.35) 29.68,2.18 PR269.1 PR214.1 30.52,2.21 30.4,2.32 PQ210.2
  IN5 w0.254: v2(29.85,2.35) 29.71,2.21 28.16,2.21 25.27,5.09 25.27,7.82 23.18,9.91 v2(22.61,9.91)
N124730498: length 2.5
  BOTTOM w0.081: 12.54,40.02 12.43,39.91 11.66,39.91 11.42,39.67 11.06,39.67 10.81,39.42 UT4.C2
  BOTTOM w0.14: RT178.1 12.54,40.02
N124730527: length 4.4
  BOTTOM w0.081: 11.55,41.35 11.55,41.16 11.05,40.66 11.05,40.17 UT4.B2
  BOTTOM w0.14: 11.55,41.35 11.55,41.41 11.63,41.5 11.63,43.39 11.94,43.7 T185.1
N124730736: length 1.7
  TOP w0.14: RT198.1 7.21,38.31 v2(7.33,38.2)
  BOTTOM w0.081: v2(7.33,38.2) 7.06,37.93 7.06,37.82 6.8,37.56 UT4.G10
N124730838: length 163.2
  TOP w0.14: v2(70.13,6.21) 69.72,5.8 RH573.1 ; v2(120.97,100.01) 120.97,100.01 JXDP.60 ; v2(114.4,49.44) 114.4,48.78 v1(114.43,48.78)
  IN4 w0.091: v2(114.4,49.44) 114.4,50.28 117.04,52.92 117.04,63.27 121.25,67.47 121.25,68.6 124.07,71.42 124.07,85.29 122.43,86.93 122.43,91.25 122.15,91.53 122.07,91.53 121.39,92.21 121.21,92.21 121.16,92.16 120.8,92.16 120.75,92.21 118.59,92.21 118.59,92.26 118.21,92.64 118.21,93.02 118.44,93.25 120.03,93.25 120.41,93.63 120.41,94.16 120.36,94.2 120.36,94.92 120.4,94.95 120.4,99.44 v2(120.97,100.01)
  IN5 w0.099: v2(114.4,49.44) 114.67,49.17 114.67,43.84 108.92,38.08 103.35,38.08 92.58,27.31 88.8,27.31 86.77,25.28 84.33,25.28 82.4,23.35 82.4,22.39 79.45,19.44 69.72,19.44 69.14,20.02 62.03,20.02 60.91,21.14 60.4,21.14 59.59,20.33 59.59,18.07 56.57,15.05 56.57,12.1 57.63,11.03 57.63,8.9 57.97,8.56 58.76,8.56 58.88,8.44 61.32,8.44 62.69,7.07 65.33,7.07 65.89,6.51 67.72,6.51 68.02,6.21 v2(70.13,6.21)
N124752685: length 2.1
  TOP w0.14: CH101.2 RH211.1 120.33,18.32 v3(120,17.99)
N124753277: length 2.2
  TOP w0.127: CH100.2 231.31,18.11
  TOP w0.14: v3(230.33,17.52) 230.43,17.42 RH212.1 231.42,17.99 231.31,18.11
N124754324: length 28.9
  TOP w0.14: v2(5.69,37.18) 5.63,37.11 RT199.1
  IN2 w0.099: v2(13.46,29.31) 13.46,29.05 13.14,28.74 13.14,27.6 10.41,24.87 7.24,24.87 3.66,28.45 3.66,32.67 v2(2.73,33.6)
  BOTTOM w0.081: UT4.F10 6.55,37.67 6.18,37.67 5.69,37.18 v2(5.69,37.18) 5.68,37.17 5.36,37.17
  BOTTOM w0.14: v2(2.73,33.6) 2.73,33.64 3.21,34.11 3.66,34.56 RT189.1 3.66,36.36 4.47,37.17 5.36,37.17 ; v1(12.74,28.93) 13.07,28.93 v2(13.46,29.31) 13.46,29.33 13.45,29.33 13.45,29.39 13.46,29.4 13.46,29.9 RT246.1
N124755351: length 5.2
  TOP w0.14: T193.1 13.08,34.12 12.12,35.09 12.12,35.49 11.33,36.28 11.08,36.28 v2(10.29,37.07)
  BOTTOM w0.081: v2(10.29,37.07) 10.25,37.11 10.22,37.11 9.91,37.42 UT4.G4
N124755352: length 1.8
  TOP w0.14: v2(10.24,37.68) 9.78,37.22 T194.1
  BOTTOM w0.081: v2(10.24,37.68) 10.06,37.68 9.82,37.92 UT4.F4
N124759625: length 2.5
  TOP w0.14: RT226.2 10.88,37.64 v2(10.26,38.26) 9.87,38.26 v3(9.61,38.53)
  BOTTOM w0.081: UT4.E4 9.96,38.26 v2(10.26,38.26)
N124759627: length 8.9
  TOP w0.14: RT227.2 7.38,42.77 7.21,42.6 v2(6.83,42.6) 6.65,42.79 6.65,44.14 v1(6.77,44.27)
  IN6 w0.099: v2(6.83,42.6) 7.11,42.33 7.11,40.62 7.85,39.89 9.37,39.89 9.75,39.51 9.75,39.3 v2(9.74,39.29)
  BOTTOM w0.081: UT4.D5 9.37,38.92 v2(9.74,39.29)
N124817422: length 1.8
  TOP w0.089: RH580.1 95.51,13.79 v2(95.53,13.76) 95.53,13.31 v3(95.59,13.24)
  BOTTOM w0.089: UH2.AD10 95.53,13.91 v2(95.53,13.76)
N124817429: length 2.5
  TOP w0.089: RH581.1 99.77,12.45 v2(99.99,12.68)
  BOTTOM w0.089: v2(99.99,12.68) 99.74,12.92 99.24,12.92 99.07,12.75 UH2.AG2
N125046794: length 3.6
  TOP w0.14: RZ75.2 RZ76.2 240.87,1.84 241.28,2.24 241.73,2.24 242.01,2.52 242.01,2.85 241.99,2.88 UZ7.5
N125087358: length 0.9
  BOTTOM w0.254: PR1224.1 PC1201.1
N125087364: length 9.1
  BOTTOM w0.14: v1(133.11,104.54) 133.48,104.91 134.82,104.91 136.45,106.54 136.45,108.8 136.93,109.28 PR1224.2
  BOTTOM w0.254: PR1224.2 137.86,108.96 PU1200.3
N125087423: length 0.9
  BOTTOM w0.254: PR1225.1 PC1228.1
N125087429: length 1.5
  BOTTOM w0.254: PU1201.3 138.46,115.38 137.82,114.74 PR1225.2
N125087470: length 1
  BOTTOM w0.254: PC1250.1 158.17,118.88 PR1226.1
N125087492: length 1.7
  BOTTOM w0.254: PU1202.3 157.16,117.93 156.39,118.7 156.39,118.88
N125087796: length 0.9
  BOTTOM w0.254: PR1320.1 PC1308.1
N125087802: length 1.4
  BOTTOM w0.254: PU1300.3 104.95,81.08 104.45,80.58 PR1320.2
N125087876: length 0.9
  BOTTOM w0.254: PC1337.1 PR1321.1
N125087885: length 3.6
  BOTTOM w0.254: PU1301.3 103.84,73.46 103.63,73.67 v2(103.63,75.15) PR1321.2
N125115914: length 29
  TOP w0.254: PR208.2 26.02,55.15 25.63,54.76 25.63,53.91 25.38,53.65 v2(25.15,53.65)
  IN3 w0.091: v2(25.15,53.65) 24.52,53.65 23.2,52.33 22.54,52.33 21.59,51.38 21.59,50.64 20.83,49.88 19.3,49.88 18.09,48.67 18.09,46.05 15.89,43.86 15.89,43.62 v2(16.35,43.16)
  BOTTOM w0.14: v2(16.35,43.16) 15.92,43.59 15.92,43.87 16.46,44.41 v3(16.46,44.9) 16.46,50.08 16.64,50.25 16.64,50.81
  BOTTOM w0.254: 16.64,50.81 PC209.1 16.64,51.52 16.74,51.62 PU200.3
N125173025: length 2.1
  BOTTOM w0.081: UT4.F1 11.49,37.92 11.56,37.85 12.57,37.85 12.74,37.69
  BOTTOM w0.14: RT190.1 13.08,37.35 12.74,37.69
N125233563: length 2
  TOP w0.14: v3(107.52,108.14) 108.59,108.14 PC1138.2
  TOP w0.254: PR1143.2 PC1138.2
N125235154: length 1.3
  BOTTOM w0.254: PU200.5 17.39,54.91 PR211.1
N125273664: length 1.5
  BOTTOM w0.089: UT1.E2 23.57,45.51 23.57,46.69 T195.1
N125374216: length 8.2
  TOP w0.14: QZ8.1 239.84,105.87 238.3,107.4 v1(236.45,107.4) 235.88,107.4 235.23,106.75 235.23,105.32 RZ9.2
N125652796: length 10.6
  TOP w0.14: v1(36.12,34.55) 35.42,33.85 PR276.1 35.51,32.91 PC223.2 PR275.2 35.51,31.73 35.05,31.27 35.05,29.15 35.22,28.98 35.22,28.34 35.64,27.92 35.79,27.92 36.75,26.96 PQ221.2
N125652818: length 4
  TOP w0.14: v1(31.87,31.49) 31.87,30.77 32.47,30.17 32.47,29.25 32.25,29.03 PQ231.2 31.7,29.03 31.57,29.16 PR277.2
N125652875: length 6.2
  TOP w0.14: PQ231.1 33.21,31.34 33.21,32.48 32.88,32.8 32.88,33.35 33.39,33.85 PR276.2 33.69,33.85 34.89,35.05 v1(34.89,35.85)
N125653204: length 9.3
  TOP w0.14: PQ224.2 22.94,20.1 20.82,22.22 19.27,22.22 PR278.2 PR279.1 19.61,24.11 v1(19.98,24.11)
N125653216: length 5.1
  TOP w0.14: PR279.2 17.07,23.5 16.38,24.19 PQ233.1 16.09,24.71 14.59,23.21 v1(14.41,23.21)
N125742089: length 4
  TOP w0.14: v2(59.08,8.99) 59.08,8.69 59.26,8.5 UH7.5
  BOTTOM w0.14: RH586.1 60.05,9.71 RH587.1 59.77,9.69 v2(59.08,8.99) 59.08,8.75 59.34,8.49 v1(59.77,8.49)
N125743729: length 5.2
  TOP w0.14: v1(158.08,2.77) 157.7,2.39 156.26,2.39 156.01,2.64 RE125.2 155.48,3.46 155.48,3.54 155.02,3.99 154.64,3.99 154.43,4.2 UE1.29
N125749803: length 3.1
  TOP w0.14: QZ6.6 237.25,101.88 237.69,102.32 RZ8.2 239.79,102.32 v1(239.8,102.33)
N125750578: length 6.5
  TOP w0.14: v1(200.18,57.83) 200.26,57.83 200.81,57.27 201.68,57.27 201.91,57.5 202.78,57.5 203.09,57.2 RZ10.2 203.09,55.19 QZ7.6
N125750624: length 4.5
  TOP w0.14: QZ7.3 202.96,53.08 204.15,51.89 RZ11.2 205.56,51.89 v3(205.89,51.56)
N125811362: length 3.8
  TOP w0.14: v1(163.65,7.37) 163.37,7.1 RE132.2 161.95,7.1 161.34,6.49 QE17.2
N125814267: length 1.9
  TOP w0.14: 335.29,100.43 335.29,100.04 335.86,99.48 v3(336.55,99.48)
N125814346: length 3.2
  TOP w0.14: v3(333.63,103.13) 334.21,102.55 CN22.1 334.73,101.54 UN3.6
N125836022: length 9.2
  TOP w0.14: UZ16.3 134.56,67.7 ; 134.56,67.7 135.82,67.7 v1(136.18,68.06) 136.18,68.63 135.8,69.01 134.28,69.01 RZ72.2 ; 134.56,67.7 134.56,65.99 134,65.43 RZ90.2
N125846238: length 3.6
  BOTTOM w0.081: 5.36,38.42 UT4.E11
  BOTTOM w0.14: RT245.1 RT186.1 3.76,37.59 4.59,38.42 5.36,38.42
N125857121:
  vias: v1(44.23,27.69)
N125861425: length 10.9
  TOP w0.14: QZ9.1 42.06,24.2 44.95,24.2 46.62,22.54 48.14,22.54 v1(48.45,22.23)
  TOP w0.508: QZ9.1 42.94,25.8 RZ37.1
N125925558: length 5.3
  TOP w0.14: v1(20.27,27.71) 20.27,28.54 20.7,28.96 20.7,29.94 CT106.1 19.37,30.69 18.66,29.98 UT3.6
N125927628: length 5.5
  TOP w0.14: UT3.3 15.65,29.98 15.56,29.9 15.08,29.9 RT240.2 14.22,29.3 13.34,28.41 13.34,26.68 v1(13.55,26.46)
N125960908: length 2.2
  TOP w0.14: v1(121.22,56.35) RZ81.2 121.22,58.51 UZ19.2
N126088934:
  vias: v1(21.08,57.41) v2(19.45,5.52) v2(19.45,4.89) v2(20.08,5.52) v2(20.08,4.89) v2(20.72,5.52) v2(20.72,4.89) v2(21.35,5.52) v2(21.35,4.89) v2(21.99,5.52) v2(21.99,4.89) v2(23.91,57.17) v2(23.9,56.59) v2(23.95,56) v2(24,55.42) v2(24.47,57.01) v2(24.49,56.42) v2(24.52,55.84) v2(24.56,55.25)
N126729390: length 139.9
  TOP w0.089: v2(101.2,20.91) 101.2,20.94 99.43,22.71 99.43,24.31 98.19,25.55 v2(98.19,27.12)
  TOP w0.14: UZ18.2 124.91,68.21 124.52,67.83 124.52,67.19 124.08,66.75 v2(123.62,66.75) 123.44,66.92 v1(122.85,66.92) ; v2(167.26,10.23) 166.69,9.66 164.47,9.66 163.94,10.19 163.94,11.81 160.25,15.49 145.17,15.49 v2(143.77,16.9)
  IN5 w0.089: 101.98,20.91 v2(101.2,20.91)
  IN5 w0.099: 101.98,20.91 102.1,20.91 105.87,17.14 106.73,17.14 107.61,16.25 129.29,16.25 129.52,16.49 134.08,16.49 134.14,16.43 134.57,16.43 134.62,16.47 143.34,16.47 v2(143.77,16.9)
  IN6 w0.099: v2(98.19,27.12) 98.19,31.9 99.53,33.25 99.87,33.25 105.06,38.44 107.98,38.44 114.2,44.65 114.2,49.05 113.97,49.28 113.97,53.86 116.93,56.83 116.93,62.18 121.5,66.75 v2(123.62,66.75)
  BOTTOM w0.14: RZ89.2 169.15,10.31 169.1,10.36 DZ1.1 167.39,10.36 v2(167.26,10.23)
N126843005: length 8.7
  TOP w0.14: LED6.2 333.2,119.2 331.6,119.2 331.09,118.69 v1(326.91,118.69) RE3.2
N126911279: length 5.9
  TOP w0.14: QE19.1 223.63,13.96 223.71,14.04 v2(223.69,14.04) ; v2(225.62,14) 226.1,14 226.62,13.49 QE2.1
  IN6 w0.099: v2(223.69,14.04) 223.69,14.01 224.06,13.64 224.45,13.64 224.82,14 v2(225.62,14)
  BOTTOM w0.14: v2(225.62,14) 225.02,14.6 v1(224.83,14.6)
N127114927: length 71.8
  TOP w0.14: PR282.2 11.06,11.57 v2(10.04,10.54) 9.87,10.37 9.74,10.37 PR283.2 9.41,9.26 8.73,8.58 v3(8.51,8.58)
  IN3 w0.091: v2(16.36,42.49) 15.7,43.15 15.7,43.94 17.9,46.13 17.9,48.75 19.22,50.07 20.75,50.07 21.27,50.59 v2(21.27,51.82)
  IN5 w0.099: v2(10.04,10.54) 10.04,12.58 9.81,12.81 9.81,14.12 8.26,15.67 8.26,16.14 7.49,16.9 7.49,18.04 9.53,20.07 14.81,20.07 15.51,20.77 15.51,23.99 16.43,24.92 17.54,24.92 18.08,25.46 18.08,30.92 19.44,32.28 19.44,38.58 16.89,41.12 16.89,41.95 v2(16.36,42.49)
  BOTTOM w0.14: v2(21.27,51.82) 21.03,51.82 PR234.2 20.28,52.58 PQ220.2
  BOTTOM w0.254: PD211.2 3.18,14.99 4.07,14.11 4.83,14.11 8.39,10.54 v2(10.04,10.54)
N127121027: length 2.3
  TOP w0.14: PR280.1 20,8.51 v3(20,9.34) 20.59,9.93 PQ234.2
N127128586: length 1.2
  TOP w0.14: PR282.1 9.75,11.11 PU204.4
N127291407: length 4.7
  BOTTOM w0.14: v1(338.25,43.8) 338.25,43.62 339.29,42.58 340.08,42.58 CZ31.1 341.39,42.24 UZ5.6
N127291517: length 1
  BOTTOM w0.14: 341.72,43.84 341.72,44.4 v1(342.06,44.74)
N127715891: length 3.6
  TOP w0.14: UV17.8 68.72,26.38 v1(67.71,27.39)
  TOP w0.381: RV547.2 70.2,25.75 UV17.8
N127915449: length 4.8
  TOP w0.14: PR27.2 27.2,26.31 PQ226.2 27.93,28.52 PC224.1
N127915537: length 34.5
  TOP w0.14: v2(22.91,26.73) 22.63,26.45 22.63,25.89 22.94,25.59 PR248.2 25.02,26.6 PR247.1
  IN2 w0.254: v2(22.91,26.73) 21.59,26.73 20.92,26.06 19.67,26.06 18.72,25.1 18.72,24.19 17.95,23.43 17.06,23.43 16.15,22.51 12.6,22.51 9.63,19.54 6.48,19.54 5.22,18.29 5.22,16.72 v2(4.95,16.46)
  BOTTOM w0.254: PD201.1 4.82,16.59 v2(4.95,16.46) 5.75,16.46 6.39,17.09 7.2,17.09 7.43,17.32 PQ227.1 ; PC212.1 PR249.1 22.58,26.68 22.63,26.73 v2(22.91,26.73) 23.12,26.73 23.46,27.08 PU201.5
N127915545: length 3.6
  BOTTOM w0.14: PQ227.2 8.08,15.45 v3(7.09,14.46)
  BOTTOM w0.254: PR270.1 8.97,16.65 8.81,16.49 8.21,16.49 8.08,16.37 PQ227.2
N127915559: length 12.4
  TOP w0.14: v2(29.69,27.16) 29.69,27.21 28.69,28.21 PQ226.1
  BOTTOM w0.254: v2(29.69,27.16) 29.69,26.86 v3(29.43,26.6) 27.08,26.6 26.48,27.2 26.48,28.56 25.35,29.69 25.35,30.78 25.21,30.92 23.99,30.92 23.86,30.79 PR242.1 PR291.1
N127915629: length 5.3
  TOP w0.254: PR245.1 25.4,27.81 v3(24.49,27.81) 23.44,27.81 v2(22.96,27.33)
  BOTTOM w0.254: v2(22.96,27.33) 22.96,27.42 22.57,27.81 PR250.2 23.03,27.95 23.25,27.73 PU201.6
N127961998: length 8.9
  TOP w0.14: PR287.2 21.51,1.71 v1(21.74,1.48) 23.42,1.48 24.18,2.24 25.91,2.24 26.86,3.2 PD204.2
  TOP w0.254: PR262.2 26.86,4.5 26.86,3.62 PD204.2
N127994048: length 2.8
  BOTTOM w0.081: UT4.E10 6.55,38.17 5.52,38.17 5.36,38
  BOTTOM w0.14: T200.1 4.75,37.96 v3(4.83,37.96) 5.32,37.96 5.36,38
N1211736753: length 3.8
  BOTTOM w0.089: UH2.R44 77.93,18.68 77.21,18.68 75.41,20.48 T91.1
N1211736754: length 5.3
  BOTTOM w0.089: UH2.R43 78.51,18.87 78.14,18.5 77.02,18.5 75.24,20.28 75.06,20.28
  BOTTOM w0.14: 75.06,20.28 T92.1
N1211736758: length 4.4
  BOTTOM w0.089: T94.1 75.89,19.38 76.94,18.32 77.27,18.32 77.57,18.02 78.65,18.02 78.74,17.92 78.95,17.71 UH2.U42
N1257483751: length 5.5
  TOP w0.14: QE19.4 225.74,15.06 226.13,15.45 227.62,15.45 227.92,15.15 QE2.4 228.59,14.93 v1(229.53,13.99)
N12017464511: length 3.8
  BOTTOM w0.089: UH2.AL42 78.95,10.89 78.74,11.1 78.42,11.1 78.32,11.2 77.51,11.2 77.47,11.15 75.79,11.15 T120.1
N12017464512: length 4.6
  BOTTOM w0.089: 75.06,10.35 75.21,10.19 76.29,10.19 76.61,9.87 77.86,9.87 78.02,10.03 78.76,10.03 78.89,9.9 UH2.AN42
  BOTTOM w0.14: T121.1 75.06,10.35
N12017464513: length 5.5
  BOTTOM w0.089: UH2.AM43 78.68,10.29 78.43,10.54 77.93,10.54 77.67,10.8 76.48,10.8 76.37,10.7 75.06,10.7
  BOTTOM w0.14: 75.06,10.7 74.16,10.7 T122.1
N12017464514: length 1.6
  TOP w0.089: T123.1 83.44,11.73 v2(82.99,11.28)
  BOTTOM w0.089: v2(82.99,11.28) 83.39,11.69 UH2.AJ33
N12017464515: length 2.9
  BOTTOM w0.089: T124.1 75.93,12.39 77.79,12.39 77.96,12.56 UH2.AH44
N12017464518: length 5.4
  BOTTOM w0.089: 75.06,12.43 75.32,12.16 77.88,12.16 78.05,12.33 78.16,12.33 78.82,12.33 78.97,12.18 UH2.AJ42
  BOTTOM w0.14: 75.06,12.43 74.97,12.52 T127.1
N12117367569: length 1.3
  TOP w0.089: T182.1 83.44,13.16 v2(82.99,12.7)
  BOTTOM w0.089: v2(82.99,12.7) 82.63,13.06 UH2.AG35
N12117367571: length 1.6
  TOP w0.089: v2(82.99,13.74) 82.99,14.14 T104.1
  BOTTOM w0.089: UH2.AD35 v2(82.99,13.74)
N12117367572: length 1.2
  TOP w0.089: v2(84.56,13.74) 84.81,13.48 T105.1
  BOTTOM w0.089: UH2.AD31 v2(84.56,13.74)
N12117367573: length 1.5
  TOP w0.089: T106.1 81.46,14.25 v2(81.46,13.74)
  BOTTOM w0.089: UH2.AD38 v2(81.46,13.74)
N12117367574: length 3.8
  BOTTOM w0.089: T107.1 76.04,15.34 76.2,15.5 77.52,15.5 77.96,15.07 78.43,15.07 78.67,14.84 UH2.AC43
N12117367575: length 4.8
  BOTTOM w0.089: UH2.AB44 77.67,15.74 76,15.74 75.9,15.64 75.57,15.64 75.4,15.81 75.06,15.81
  BOTTOM w0.14: T108.1 73.83,15.81 75.06,15.81
N12449474450: length 5.5
  BOTTOM w0.081: UT4.B9 7.05,40.17 7.05,41.18 6.94,41.3 6.94,41.35
  BOTTOM w0.14: 6.94,41.35 6.94,42 7.66,42.72 8.04,42.72 8.51,43.19 8.51,43.6 8.6,43.69 8.6,44.24 T191.1
N12449474451: length 3.3
  BOTTOM w0.081: 7.26,41.35 7.3,41.3 UT4.A9
  BOTTOM w0.14: T192.1 8.22,42.39 7.67,42.39 7.2,41.92 7.2,41.4 7.26,41.35

## Copper pours and planes (outline as drawn)
1.2V_B+ on TOP (solid shape): 277.62,32.65 277.62,30.68 277.12,30.17 274.13,30.17 273.78,30.52 273.78,32.65 274.1,32.97 277.31,32.97
1.2V_B+ on BOTTOM (solid shape): 275.89,33.54 277.27,33.35 278.65,33.22 278.67,33.21 278.86,33.02 278.86,32.29 279.2,32.29 279.25,32.24 279.25,31.71 279.24,31.71 278.71,31.71 278.69,31.68 278.69,31 278.72,30.97 279.24,30.97 279.25,30.96 279.25,30.52 279.22,30.49 278.7,30.49 278.7,30.49 278.7,29.79 278.71,29.77 279.24,29.77 279.24,29.77 279.24,29.24 278.87,28.87 278.86,28.87 278.07,28.08 278.07,26.87 277.94,26.74 276.92,26.74 276.86,26.81 276.86,27.95 277.4,28.49 277.4,29.73 276.89,30.23 271.83,30.23 271.6,30.47 271.6,33.3 271.83,33.54 275.89,33.54
+0.6VS on TOP (solid shape): 174.55,17.93 177.75,17.93 177.9,17.78 177.9,16.35 177.48,15.93 173.89,15.93 173.68,16.15 173.68,17.01 173.5,17.19 173.5,18.03 173.55,18.09 174.4,18.09
+0.6VS on TOP (solid shape): 282.37,28.02 282.87,28.02 282.87,28.56 283.17,28.56 283.17,28.02 283.67,28.02 283.67,28.56 284.44,28.56 284.61,28.39 284.61,25.85 284.04,25.28 282.6,25.28 282.6,25.28 281.7,25.28 281.39,25.6 281.39,28.4 281.55,28.56 282.37,28.56
+0.6VS on IN4 (solid shape): 177.09,17.06 177.09,16 176.65,15.56 174.09,15.56 173.65,16 173.65,17.06 173.94,17.36 176.8,17.36
+0.6VS on IN4 (solid shape): 251.28,16.95 251.28,15.2 251.02,14.94 249.54,14.94 249.18,15.31 249.18,15.62 249.44,15.88 249.44,16.85 249.66,17.08 251.15,17.08
+0.6VS on TOP: 249.8,17.71 250.53,17.71 250.7,17.88 254.2,17.88 254.38,17.7 254.38,16.73 254.1,16.46 253.21,16.46 252.58,15.82 249.86,15.82 249.56,16.13 249.56,17.47
+0.6VSP on TOP (solid shape): 286.93,30.98 286.93,30.58 286.86,30.52 286.41,30.52 286.26,30.36 286.26,29.79 286.01,29.54 285.31,29.54 284.45,28.68 283.55,28.68 283.55,28.15 283.29,28.15 283.29,28.68 282.75,28.68 282.75,28.15 282.49,28.15 282.49,28.68 281.54,28.68 281.43,28.79 281.43,30.74 281.75,31.06 286.85,31.06
+0.6VSP on BOTTOM (solid shape): 286.62,30.57 287.21,30.57 287.29,30.5 287.29,30.39 287.22,30.32 285.35,30.32 285.18,30.49 285.18,31 285.24,31.06 286.13,31.06
+0.95VSP on TOP (solid shape): 118.94,61.77 118.94,60.4 118.75,60.21 115.24,60.21 115.12,60.33 115.12,62.93 115.31,63.13 117.57,63.13
+0.95VSP on BOTTOM (solid shape): 117.41,65.82 117.42,65.75 117.42,64.78 117.43,64.78 117.43,64.63 117.97,64.63 117.97,64.33 117.96,64.33 117.96,64.22 117.42,64.22 117.4,64.2 117.4,63.46 117.43,63.43 117.97,63.43 117.97,63.06 117.93,63.03 117.45,63.03 117.42,63 117.42,62.27 117.53,62.16 118.76,62.16 118.94,61.99 118.94,60.33 118.87,60.27 115.25,60.27 115,60.52 115,62.75 114.49,63.25 111.7,63.25 111.34,63.62 111.34,65.99 111.52,66.18 117.06,66.18
+1.2V_DDR on TOP (solid shape): 134.18,67.25 134.18,66.25 133.86,65.92 132.62,65.92 132.5,66.05 132.5,66.34 132.66,66.51 133.22,66.51 133.38,66.66 133.38,67.23 133.48,67.33 134.1,67.33
+1.2V_DDR on BOTTOM (solid shape): 258.76,24.62 258.76,23.15 257.87,22.27 254.89,22.27 254.55,22.6 254.55,24.78 254.61,24.84 255.78,24.84 255.78,24.32 256.48,24.32 256.48,24.84 256.98,24.84 256.98,24.32 257.68,24.32 257.68,24.84 257.78,24.84 257.81,24.87 258.51,24.87
+1.2V_DDR on TOP: outline of 908 points within 109.71,15.86 257.67,68.49
+1.2V_DDR on VCC: 248.26,14.99 247.65,15.61 247.65,18.28 246.49,19.44 128,19.44 127.49,19.95 117.96,19.95 117.22,20.69 117.22,25.13 116.06,26.3 114.48,26.3 114.1,26.68 114.1,28.61 114.46,28.96 253.16,28.96 259.59,22.53 259.59,15.48 259.21,15.1 259.21,14.99
+1.2V_MEN_P on BOTTOM (solid shape): 283.81,31.64 283.81,30.64 283.27,30.64 283.27,30.21 283.81,30.21 283.81,29.91 283.76,29.86 282.26,29.86 281.86,30.26 281.86,31.56 282.13,31.82 283.63,31.82
+1.2V_MEN_P on BOTTOM (solid shape): 263.89,33.46 263.89,29.7 263.15,28.95 262.69,28.95 261.05,27.31 261.05,25.92 260.16,25.03 257.57,25.03 257.57,24.96 257.56,24.96 257.56,24.45 257.11,24.45 257.11,24.96 257.08,24.96 257.08,24.97 256.38,24.97 256.38,24.96 256.36,24.96 256.36,24.45 255.91,24.45 255.91,24.96 255.88,24.96 255.88,24.97 255.07,24.97 254.83,25.22 254.83,28.71 255.33,29.22 255.33,31.63 256.16,32.46 260.43,32.46 261.31,33.34 261.31,33.51 261.36,33.57 263.78,33.57
+1.2V_MEN_P on IN1 (solid shape): 283.15,31.44 283.15,30.17 282.83,29.85 282.13,29.85 281.88,30.11 281.88,31.57 281.94,31.63 282.96,31.63
+1.2V_MEN_P on IN1 (solid shape): 263.28,29.29 263.28,29.02 263.78,28.52 263.78,28.27 263.59,28.08 262.76,28.08 262.07,28.77 262.07,29.39 262.23,29.55 263.02,29.55
+1.2V_VCCPLL_OC on IN6 (solid shape): outline of 907 points within 142.09,65.63 175.7,69.69
+1.05VSDGPU on TOP (solid shape): 231.48,98.74 231.48,98.21 230.83,97.55 230.83,96.71 230.75,96.63 229.76,96.63 229.66,96.73 229.66,97.44 229.73,97.52 229.93,97.52 230.19,97.77 230.19,98.38 230.75,98.94 231.28,98.94
+1.05VSDGPU on TOP (solid shape): outline of 696 points within 196.03,74 207.68,93.82
+1.05VSDGPU on BOTTOM (solid shape): outline of 359 points within 200.66,73.1 207.16,87.03
+1.05VSDGPU on IN1 (solid shape): outline of 4205 points within 196.61,66.46 211.33,88.49
+1.05VSDGPU on TOP: 199.26,63.04 199.06,63.24 198.2,63.24 197.99,63.45 197.99,66.71 197.64,67.06 196.79,67.06 196.53,67.32 196.53,68.65 196.88,69 200.58,69 201.13,68.45 201.13,65.7 201.71,65.12 201.71,65.11 202.02,64.8 202.25,64.7 202.49,64.79 202.86,64.79 203.33,64.32 203.33,64.32 204.03,63.62 204.03,63.24 204.27,63 207.96,63 208.28,63.32 208.28,64.33 208.6,64.65 208.6,65.54 208.98,65.92 210.25,65.92 210.44,65.73 210.44,65.35 210.19,65.1 210.19,62.78 210.69,62.28 210.71,62.21 210.73,62.15 210.73,61.67 211.02,61.38 211.41,61.38 211.52,61.26 211.52,58.49 211.39,58.37 210.82,58.37 210.82,58.88 210.12,58.88 210.12,58.37 209.62,58.37 209.62,58.88 208.92,58.88 208.92,58.37 208.09,58.37 207.36,57.64 203.66,57.64 202.92,58.37 202.4,58.37 202.16,58.12 200.62,58.12 199.26,59.47
+1.05VSP on BOTTOM (solid shape): 214.69,57.86 214.69,55 214.5,54.81 211.71,54.81 211.2,55.32 208.3,55.32 208.13,55.49 208.13,56.62 208.31,56.8 209.41,56.8 209.79,57.18 209.79,57.65 210.1,57.97 214.59,57.97
+1.05VSP on TOP: 205.01,54.48 204.79,54.71 204.79,55.8 205.01,56.02 207.08,56.02 207.38,56.33 207.38,57.36 208.25,58.23 209.02,58.23 209.02,58.24 209.04,58.24 209.04,58.75 209.49,58.75 209.49,58.24 209.52,58.24 209.52,58.23 210.22,58.23 210.22,58.24 210.24,58.24 210.24,58.75 210.69,58.75 210.69,58.24 210.72,58.24 210.72,58.23 211.61,58.23 211.9,57.94 211.9,55.83 211.52,55.44 208.23,55.44 207.27,54.48
+1.35V_RUN_B+ on TOP (solid shape): 242.89,49.54 242.89,48.01 243.08,47.82 243.08,47.32 243.02,47.25 240.67,47.25 240.21,46.8 240.21,46.02 239.87,45.68 237.51,45.68 237.51,46.2 237,46.2 237,45.68 236.71,45.68 236.71,46.2 236.2,46.2 236.2,45.68 235.34,45.68 235.01,46.01 235.01,48.38 235.23,48.6 240.74,48.6 241.75,49.6 242.83,49.6
+1.35V_VSNS on TOP (solid shape): 243.63,63.15 245.07,63.15 245.89,62.33 245.89,59.62 246.51,59 246.51,57.48 246.32,57.29 245.56,57.29 243.46,59.38 241.72,59.38 241.52,59.57 241.52,60.65 240.98,60.65 240.98,61.1 241.52,61.1 241.52,61.85 240.98,61.85 240.98,62.3 241.52,62.3 241.52,63.01 241.89,63.38 243.4,63.38
+1.35V_VSNS on BOTTOM (solid shape): 244.86,64.36 245.89,64.36 245.96,64.29 245.96,60.43 247.42,58.96 249.09,58.96 249.16,58.89 249.16,55.48 248.92,55.24 246.03,55.24 244.08,57.18 244.08,58.62 243.52,59.18 242.53,59.18 242.29,59.42 242.29,61.2 242.83,61.73 242.83,62.87 242.7,63 241.86,63 241.86,62.45 241.42,62.45 241.42,62.98 240.67,62.98 240.67,62.45 240.22,62.45 240.22,62.98 239.42,62.98 239.42,63.53 240.86,64.97 244.25,64.97
+1.35VSDGPU on TOP (solid shape): 223.95,95.99 223.95,94.26 224.92,93.29 224.92,91.64 224.85,91.58 224.11,91.58 222.78,92.9 222.78,96.12 223,96.33 223.61,96.33
