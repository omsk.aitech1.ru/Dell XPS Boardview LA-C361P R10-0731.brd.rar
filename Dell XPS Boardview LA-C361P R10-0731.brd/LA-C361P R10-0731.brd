# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D43: length 101
  IN1 w0.079: v2(166.71,66.57) 167.28,66 167.28,64.53 167.58,64.23 167.58,63.42 167.82,63.19 167.82,59.17 172.11,54.88 172.4,54.88 174.3,52.98 174.3,52.54 175.39,51.44 175.68,51.44 175.91,51.45 180,47.36 193.54,47.36 205.47,35.43 209.13,35.43 210.35,34.21 224.14,34.21 224.88,33.46 230.08,33.46 234.9,28.64 234.9,27.99 238.64,24.25 238.64,21.16 v2(237.89,20.41)
  BOTTOM w0.089: v2(166.71,66.57) 166.6,66.57 UH1.V11
  BOTTOM w0.14: v2(237.89,20.41) 237.89,19.78 237.42,19.31 JDIMM2.208
DDR_B_D44: length 100.9
  IN1 w0.079: v2(234.66,22.95) 234.15,23.46 234.15,24.42 231.18,27.39 231.18,28.05 228.76,30.47 218.26,30.47 218.18,30.55 218.18,31.11 218.07,31.21 217.92,31.21 217.82,31.11 217.82,30.64 217.71,30.53 217.55,30.53 217.44,30.64 217.44,31.09 217.31,31.21 209.07,31.21 207.85,32.44 204.23,32.44 192.3,44.37 175.79,44.37 173.42,46.74 173.42,49.19 170.88,51.73 170.88,52.91 165.69,58.1 165.69,62.86 165.24,63.31 165.24,64.14 165.42,64.33 165.42,65.52 v2(165.82,65.92)
  BOTTOM w0.076: v2(165.82,65.92) 165.49,66.25 UH1.W11
  BOTTOM w0.14: JDIMM2.191 233.18,24.44 v2(234.66,22.95)
DDR_B_D45: length 100.9
  IN1 w0.079: v2(234.66,21.68) 234.45,21.47 234,21.47 233.87,21.6 233.87,24.31 230.9,27.28 230.9,27.94 228.65,30.19 217.45,30.19 216.7,30.93 208.96,30.93 207.73,32.15 204.11,32.15 192.18,44.09 175.67,44.09 173.14,46.63 173.14,49.07 170.71,51.5 170.71,52.83 165.49,58.05 165.49,62.83 165.06,63.25 165.06,65.24 v2(164.92,65.38)
  BOTTOM w0.076: UH1.W10 165.14,65.6 v2(164.92,65.38)
  BOTTOM w0.14: JDIMM2.190 232.94,19.16 234.11,20.33 234.11,21.13 v2(234.66,21.68)
DDR_B_D46: length 100.8
  IN1 w0.079: v2(237.89,22.95) 237.66,22.95 237.01,23.6 237.01,25.08 234.34,27.76 234.34,28.41 229.85,32.9 224.65,32.9 223.91,33.64 210.12,33.64 208.9,34.86 205.24,34.86 193.3,46.8 177.77,46.8 177.32,47.24 177.32,47.36 177.55,47.59 177.55,47.7 177.44,47.81 177.33,47.81 177.1,47.58 176.98,47.58 176.87,47.69 176.87,47.8 177.1,48.03 177.1,48.14 176.99,48.25 176.88,48.25 176.65,48.02 176.54,48.02 176.43,48.14 176.43,48.25 176.66,48.48 176.66,48.59 176.55,48.7 176.43,48.7 176.21,48.47 176.09,48.47 175.85,48.72 175.85,50.19 173.83,52.21 173.83,52.8 173,53.63 172.76,53.63 167.44,58.95 167.44,63.05 167.12,63.37 167.12,64.11 166.73,64.49 v2(166.73,64.62)
  BOTTOM w0.089: v2(166.73,64.62) 166.6,64.62 UH1.V8
  BOTTOM w0.14: v2(237.89,22.95) 236.18,24.67 JDIMM2.203
DDR_B_D47: length 100.8
  IN1 w0.079: v2(237.89,21.68) 237.24,22.34 237.24,22.81 236.73,23.31 236.73,24.97 234.06,27.64 234.06,28.29 229.73,32.62 224.53,32.62 223.79,33.36 210,33.36 208.78,34.58 205.12,34.58 193.19,46.52 177.07,46.52 176.68,46.9 176.68,47.02 176.86,47.19 176.86,47.3 176.75,47.42 176.64,47.42 176.46,47.24 176.35,47.24 176.24,47.35 176.24,47.46 176.41,47.64 176.41,47.75 176.3,47.86 176.19,47.86 176.01,47.68 175.9,47.68 175.56,48.02 175.56,50.08 172.83,52.82 172.3,52.82 166.65,58.47 166.65,63.88 v2(166.73,63.97)
  BOTTOM w0.089: v2(166.73,63.97) 166.6,63.97 UH1.V7
  BOTTOM w0.14: v2(237.89,21.68) 237.31,21.09 237.31,20.19 236.42,19.31 JDIMM2.204
DDR_B_D48: length 101.4
  IN1 w0.079: v2(168.56,66.57) 168.17,66.18 168.17,65.78 168.02,65.63 168.02,64.45 167.84,64.27 167.84,63.63 168.2,63.27 168.2,59.03 172.18,55.04 172.48,55.04 175.59,51.93 176.11,51.93 180.2,47.85 193.74,47.85 205.63,35.95 209.29,35.95 210.56,34.69 224.34,34.69 225.08,33.95 230.45,33.95 236.6,27.8 236.6,26.98 239.12,24.45 239.12,21.47 v2(240.18,20.41)
  BOTTOM w0.089: v2(168.56,66.57) 168.43,66.57 UH1.R11
  BOTTOM w0.14: v2(240.18,20.41) 240.18,19.86 239.42,19.11 JDIMM2.216
DDR_B_D49: length 101.1
  IN1 w0.079: v2(240.18,24.22) 240.18,24.6 237.45,27.33 237.45,28.15 230.8,34.79 230.13,34.79 230.04,34.89 230.04,35.44 229.96,35.52 229.8,35.52 229.72,35.44 229.72,34.89 229.64,34.81 229.49,34.81 229.41,34.89 229.41,35.44 229.33,35.52 229.17,35.52 229.09,35.44 229.09,34.89 229.01,34.81 228.86,34.81 228.78,34.89 228.78,35.44 228.7,35.52 228.54,35.52 228.46,35.44 228.46,34.89 228.38,34.81 228.23,34.81 228.15,34.89 228.15,35.44 228.07,35.52 227.91,35.52 227.83,35.44 227.83,34.89 227.75,34.81 227.6,34.81 227.52,34.89 227.52,35.44 227.44,35.52 227.28,35.52 227.2,35.44 227.2,34.89 227.12,34.81 226.96,34.81 226.85,34.92 226.85,35.41 226.72,35.54 210.91,35.54 209.65,36.8 205.98,36.8 194.09,48.69 180.61,48.69 176.53,52.78 175.94,52.78 173.17,55.55 172.39,55.55 168.73,59.21 168.73,63.81 v2(168.56,63.97)
  BOTTOM w0.089: v2(168.56,63.97) 168.43,63.97 UH1.R7
  BOTTOM w0.14: JDIMM2.215 239.18,25.22 v2(240.18,24.22)
DDR_B_D50: length 101.4
  IN1 w0.079: v2(243.48,20.41) 242.4,20.41 242.29,20.52 242.29,20.67 242.4,20.77 242.59,20.77 242.7,20.88 242.7,21.03 242.59,21.13 242.37,21.13 242.29,21.21 242.29,24.72 239.71,27.3 239.71,28.12 230.72,37.12 213.23,37.12 212.61,37.74 210.94,37.74 210.3,38.38 206.64,38.38 194.74,50.28 181.26,50.28 176.75,54.8 175.79,54.8 174.37,56.22 173.23,56.22 170.11,59.34 170.11,62.09 169.48,62.73 v2(169.48,63.97)
  BOTTOM w0.089: v2(169.48,63.97) 169.35,63.97 UH1.P7
  BOTTOM w0.14: JDIMM2.228 242.42,19.61 243.23,20.41 v2(243.48,20.41)
DDR_B_D51: length 101.2
  IN1 w0.079: v2(243.48,24.22) 243.48,24.73 240.56,27.65 240.56,28.47 231.07,37.97 214.88,37.97 214.8,38.04 214.8,38.51 214.72,38.59 214.57,38.59 214.49,38.51 214.49,38.04 214.41,37.97 214.25,37.97 214.17,38.04 214.17,38.51 214.09,38.59 213.94,38.59 213.86,38.51 213.86,38.04 213.78,37.97 213.58,37.97 213.45,38.09 213.45,38.46 213.33,38.59 211.29,38.59 210.65,39.23 206.99,39.23 195.09,51.13 181.61,51.13 175.89,56.85 173.33,56.85 170.75,59.43 170.75,62.2 170.2,62.76 170.2,64.48 170.02,64.66 170.02,66.03 169.85,66.2 v2(169.48,66.57)
  BOTTOM w0.089: UH1.P11 169.35,66.57 v2(169.48,66.57)
  BOTTOM w0.14: JDIMM2.229 242.67,25.03 v2(243.48,24.22)
DDR_B_D52: length 101.2
  IN1 w0.079: v2(168.56,64.62) 168.56,64.49 168.19,64.12 168.19,63.78 168.55,63.42 168.55,59.15 172.32,55.38 172.94,55.38 175.83,52.49 176.41,52.49 180.28,48.62 180.5,48.41 193.97,48.41 205.87,36.52 209.53,36.52 210.79,35.26 225.06,35.26 225.19,35.13 225.19,34.64 225.31,34.52 225.47,34.52 225.59,34.64 225.59,35.16 225.67,35.24 225.83,35.24 225.9,35.16 225.9,34.59 225.98,34.51 226.14,34.51 226.22,34.59 226.22,35.16 226.3,35.24 226.45,35.24 226.53,35.16 226.53,34.59 226.61,34.51 230.69,34.51 237.17,28.03 237.17,27.21 239.69,24.69 239.69,23.44 v2(240.18,22.95)
  BOTTOM w0.089: UH1.R8 168.43,64.62 v2(168.56,64.62)
  BOTTOM w0.14: JDIMM2.211 238.18,25.55 239.25,24.48 239.25,23.88 v2(240.18,22.95)
DDR_B_D53: length 101.2
  IN1 w0.079: v2(168.56,65.92) 168.19,65.55 168.19,64.38 168.02,64.2 168.02,63.71 168.37,63.35 168.37,59.09 172.25,55.21 172.71,55.21 175.71,52.21 176.3,52.21 180.26,48.24 180.27,48.24 180.38,48.13 193.86,48.13 205.75,36.23 209.41,36.23 210.67,34.97 224.46,34.97 225.2,34.23 230.57,34.23 236.88,27.92 236.88,27.09 239.41,24.57 239.41,22.16 239.89,21.68 v2(240.18,21.68)
  BOTTOM w0.089: v2(168.56,65.92) 168.43,65.92 UH1.R10
  BOTTOM w0.14: v2(240.18,21.68) 239.11,20.61 239.11,19.86 238.42,19.18 JDIMM2.212
DDR_B_D54: length 101.6
  IN1 w0.079: v2(169.48,64.62) 169.85,64.25 169.85,62.61 170.31,62.14 170.31,59.37 173.26,56.42 174.45,56.42 175.82,55.05 176.89,55.05 181.38,50.56 194.86,50.56 206.76,38.66 210.42,38.66 211.06,38.03 212.72,38.03 213.35,37.4 230.83,37.4 240,28.24 240,27.42 242.57,24.84 242.57,22.04 242.93,21.68 v2(243.48,21.68)
  BOTTOM w0.089: v2(169.48,64.62) 169.35,64.62 UH1.P8
  BOTTOM w0.14: v2(243.48,21.68) 243.23,21.68 241.42,19.88 JDIMM2.224
DDR_B_D55: length 101.1
  IN1 w0.079: v2(243.48,22.95) 243.31,22.95 242.86,23.41 242.86,24.96 240.28,27.53 240.28,28.36 230.95,37.68 213.46,37.68 212.84,38.31 211.17,38.31 210.53,38.94 206.87,38.94 194.97,50.84 181.5,50.84 175.72,56.63 173.3,56.63 170.52,59.41 170.52,62.19 170.02,62.68 170.02,64.38 169.85,64.56 169.85,65.55 v2(169.48,65.92)
  BOTTOM w0.089: UH1.P10 169.35,65.92 v2(169.48,65.92)
  BOTTOM w0.14: JDIMM2.225 241.67,25.47 242.36,24.79 242.36,24.07 v2(243.48,22.95)
DDR_B_D56: length 102.8
  IN1 w0.079: v2(245.77,24.22) 245.65,24.22 242.79,27.08 242.79,28.12 231.9,39.01 215.78,39.01 214.52,40.28 207.43,40.28 203.04,44.66 203.04,44.77 203.5,45.23 203.5,45.36 203.4,45.45 203.27,45.45 202.82,45 202.71,45 202.59,45.11 202.59,45.22 203.08,45.7 203.08,45.83 202.98,45.92 202.85,45.92 202.37,45.44 202.26,45.44 202.15,45.55 202.15,45.66 202.6,46.12 202.6,46.25 202.51,46.34 202.38,46.34 201.93,45.89 201.82,45.89 201.7,46 201.7,46.11 202.15,46.55 202.15,46.68 202.05,46.77 201.92,46.77 201.48,46.33 201.37,46.33 201.26,46.44 201.26,46.55 201.68,46.97 201.68,47.1 201.58,47.19 201.45,47.19 201.04,46.78 200.92,46.78 195.52,52.19 182.04,52.19 175.78,58.44 175.22,58.44 172.97,60.69 172.97,61.13 172.62,61.48 172.62,62.69 172.18,63.13 171.41,63.13 v2(171.24,63.3)
  BOTTOM w0.076: v2(171.24,63.3) 171.2,63.3 UH1.M7
  BOTTOM w0.14: v2(245.77,24.22) 245.14,24.22 244.67,24.69 JDIMM2.237
DDR_B_D57: length 103.1
  IN1 w0.079: v2(171.31,66.57) 170.75,66.02 170.75,64.93 170.71,64.89 170.71,62.72 171.3,62.13 171.3,61.41 171.71,61.01 172.3,61.01 172.57,60.74 172.57,60.49 175.06,58 175.43,58 181.82,51.61 195.29,51.61 207.19,39.71 214.29,39.71 215.55,38.45 231.67,38.45 242.23,27.89 242.23,26.84 244.43,24.64 244.43,21.74 v2(245.77,20.41)
  BOTTOM w0.089: v2(171.31,66.57) 171.17,66.57 UH1.M11
  BOTTOM w0.14: v2(245.77,20.41) 245.57,20.41 244.42,19.27 JDIMM2.236
DDR_B_D58: length 102.9
  IN1 w0.079: v2(248.81,24.22) 248.81,25.93 233.02,41.72 219.84,41.72 219.71,41.85 219.71,42.52 219.58,42.64 219.41,42.64 219.28,42.52 219.28,41.85 219.15,41.72 219,41.72 218.89,41.83 218.89,42.52 218.78,42.63 218.64,42.63 218.53,42.52 218.53,41.85 218.4,41.72 218.27,41.72 218.14,41.85 218.14,42.86 218.01,42.99 210.2,42.99 200.66,52.52 199.01,52.52 189.16,62.38 177.55,62.38 176.66,63.27 174.91,63.27 174.42,63.76 174.42,64.39 173.95,64.86 173.58,64.86 172.66,65.78 172.66,66.1 v2(172.19,66.57)
  BOTTOM w0.089: v2(172.19,66.57) 172.09,66.57 UH1.L11
  BOTTOM w0.14: v2(248.81,24.22) 248.3,24.22 247.68,24.85 JDIMM2.249
DDR_B_D59: length 102.8
  IN1 w0.079: v2(248.81,20.41) 247.99,20.41 247.88,20.52 247.88,20.68 247.99,20.79 248.3,20.79 248.37,20.87 248.37,21.03 248.3,21.11 248.08,21.11 248,21.19 248,21.34 248.08,21.42 248.3,21.42 248.37,21.5 248.37,21.66 248.3,21.74 248.08,21.74 248,21.82 248,22.82 247.78,23.05 247.78,25.77 232.67,40.88 216.64,40.88 215.38,42.14 209.85,42.14 200.31,51.68 198.66,51.68 188.81,61.53 176.63,61.53 176.49,61.39 175.12,61.39 174.46,62.05 174.46,62.68 173.69,63.46 172.79,63.46 172.17,64.07 v2(172.17,64.08)
  BOTTOM w0.14: JDIMM2.250 247.93,19.58 248.75,20.41 248.81,20.41 v2(248.81,20.41) ; UH1.L7 172.12,64.08 v2(172.17,64.08)
DDR_B_D60: length 103.2
  IN1 w0.079: v2(171.31,65.92) 170.93,65.55 170.93,64.87 170.88,64.82 170.88,62.79 171.34,62.33 172.23,62.33 172.44,62.12 172.44,61.29 172.76,60.96 172.76,60.6 175.17,58.19 175.64,58.19 181.93,51.89 195.41,51.89 207.31,39.99 214.4,39.99 215.67,38.73 231.78,38.73 242.51,28 242.51,26.96 244.72,24.75 244.72,22.06 245.09,21.68 v2(245.77,21.68)
  BOTTOM w0.089: UH1.M10 171.17,65.92 v2(171.31,65.92)
  BOTTOM w0.14: v2(245.77,21.68) 243.42,19.34 JDIMM2.232
DDR_B_D61: length 102.9
  IN1 w0.079: v2(171.24,63.94) 171.88,63.3 172.25,63.3 172.81,62.73 172.81,61.6 173.14,61.28 173.14,60.84 175.29,58.69 175.93,58.69 182.16,52.47 195.63,52.47 198,50.1 199.21,50.1 204.22,45.09 204.22,44.96 204.02,44.76 204.02,44.65 204.13,44.54 204.25,44.54 204.54,44.83 204.67,44.83 204.76,44.74 204.76,44.61 204.47,44.32 204.47,44.21 204.58,44.1 204.69,44.1 205.01,44.41 205.14,44.41 205.23,44.32 205.23,44.19 204.91,43.87 204.91,43.76 205.08,43.59 205.2,43.59 205.46,43.85 205.57,43.85 205.68,43.74 205.68,43.63 205.42,43.37 205.42,43.26 208.12,40.56 214.64,40.56 215.9,39.3 232.02,39.3 243.07,28.24 243.07,27.31 243.43,26.95 245.05,25.33 245.77,25.33 246.2,24.91 246.2,23.38 v2(245.77,22.95)
  BOTTOM w0.089: UH1.M8 171.2,63.94 v2(171.24,63.94)
  BOTTOM w0.14: JDIMM2.233 243.67,25.04 v2(245.77,22.95)
DDR_B_D62: length 103.5
  IN1 w0.079: v2(172.19,65.92) 172.73,65.38 172.73,64.93 175.26,62.4 176.73,62.4 177.04,62.1 189.04,62.1 198.89,52.24 200.55,52.24 210.08,42.7 216.93,42.7 217.06,42.58 217.06,41.57 217.19,41.44 217.35,41.44 217.48,41.57 217.48,42.38 217.59,42.49 217.75,42.49 217.86,42.38 217.86,41.57 217.98,41.44 232.91,41.44 248.34,26 248.34,23.42 v2(248.81,22.95)
  BOTTOM w0.089: v2(172.19,65.92) 172.09,65.92 UH1.L10
  BOTTOM w0.14: v2(248.81,22.95) 247.1,24.66 247.1,25.19 246.67,25.62 JDIMM2.245
DDR_B_D63: length 103.1
  IN1 w0.079: v2(248.81,21.68) 248.29,22.21 248.29,22.94 248.06,23.16 248.06,25.89 232.79,41.16 216.9,41.16 216.78,41.29 216.78,42.29 216.65,42.41 216.41,42.41 216.28,42.29 216.28,42.04 216.16,41.92 215.99,41.92 215.88,42.04 215.88,42.3 215.75,42.42 209.97,42.42 200.43,51.96 198.78,51.96 188.93,61.81 176.45,61.81 176.26,61.62 175.2,61.62 174.69,62.12 174.69,62.74 172.81,64.62 v2(172.19,64.62)
  BOTTOM w0.14: v2(172.19,64.62) 172.06,64.62 UH1.L8 ; v2(248.81,21.68) 248.16,21.03 248.16,20.3 246.93,19.06 JDIMM2.246
DDR_B_DQS0: length 90.5
  IN1 w0.079: v2(185.23,22.57) 185.02,22.78 184.84,22.78 184.66,22.96 184.66,24.42 183.55,25.52 175.83,25.52 175.16,26.19 163.12,26.19 156.33,32.98 147.55,32.98 134.24,46.29 134.24,63.47 135.9,65.13 135.9,65.53 136.44,66.07 137.24,66.07 137.95,65.37 138.57,65.37 138.64,65.44 138.64,65.64 v2(138.48,65.81)
  BOTTOM w0.076: v2(138.48,65.81) 138.15,65.4 UH1.BR9
  BOTTOM w0.14: v2(185.23,22.57) 185.36,22.7 185.82,22.7 186.14,23.02 186.14,24.49 186.58,24.93 186.58,25.36 186.68,25.45 JDIMM2.13
DDR_B_DQS1: length 90.2
  IN1 w0.079: v2(141.2,65.27) 140.99,65.27 140.93,65.21 140.93,62.52 140.73,62.32 140.73,61.12 141.22,60.62 141.22,58.43 138.06,55.26 138.06,51.36 138.86,50.56 138.86,47.21 147.87,38.21 157.63,38.21 165.09,30.75 177.73,30.75 178.57,29.91 185.42,29.91 186.96,28.37 186.96,27.92 190.46,24.42 190.46,21.75 190.53,21.69 190.81,21.69 190.89,21.78 v2(190.89,21.94)
  BOTTOM w0.076: UH1.BJ9 141.47,64.83 141.17,64.83 141.08,64.92 141.08,65.16 v2(141.2,65.27)
  BOTTOM w0.14: v2(190.89,21.94) 191.12,21.72 191.41,21.72 191.79,21.33 191.79,19.16 191.92,19.03 JDIMM2.34
DDR_B_DQS2: length 92.1
  IN1 w0.079: v2(196.61,22.57) 196.88,22.84 197.11,22.84 197.31,23.04 197.31,23.92 193.81,27.42 193.81,28.74 188.04,34.5 166.64,34.5 158.54,42.61 152.41,42.61 152.33,42.69 152.33,42.99 152.14,43.19 151.82,43.19 151.63,42.99 151.63,42.69 151.55,42.61 151.31,42.61 151.23,42.69 151.23,42.99 151.06,43.16 150.7,43.16 150.53,42.99 150.53,42.69 150.45,42.61 150.22,42.61 150.14,42.69 150.14,42.99 149.97,43.16 149.6,43.16 149.43,42.99 149.43,42.69 149.35,42.61 148.78,42.61 143.38,48.01 143.38,56.36 144.9,57.88 144.9,62.34 144.4,62.85 144.4,64.91 v2(144.76,65.27)
  BOTTOM w0.089: UH1.BF9 144.66,65.27 v2(144.76,65.27)
  BOTTOM w0.14: JDIMM2.55 197.18,25.49 197.07,25.39 197.07,25.21 197.39,24.89 197.39,23.11 197.07,22.79 196.83,22.79 v2(196.61,22.57)
DDR_B_DQS3: length 91.8
  IN1 w0.079: v2(202.65,21.94) 202.43,21.72 202.26,21.72 202.17,21.8 202.17,24.67 199.81,27.03 199.81,28.25 189.78,38.28 168.29,38.28 163.07,43.5 163.07,43.61 163.42,43.96 163.42,44.22 163.19,44.46 162.92,44.46 162.58,44.11 162.46,44.11 162.3,44.28 162.3,44.39 162.64,44.73 162.64,44.98 162.38,45.23 162.14,45.23 161.8,44.89 161.69,44.89 158.63,47.94 151.02,47.94 148.46,50.51 148.46,55.14 147.84,55.76 147.84,63.09 147.15,63.78 147.15,63.94 147.16,63.95 147.16,64.9 v2(147.53,65.27)
  BOTTOM w0.089: UH1.BB9 147.4,65.27 v2(147.53,65.27)
  BOTTOM w0.14: v2(202.65,21.94) 202.82,21.77 203.13,21.77 203.38,21.51 203.38,20.29 202.32,19.23 202.32,19.13 202.43,19.03 JDIMM2.76
DDR_B_DQS4: length 99.3
  IN1 w0.079: v2(230.6,23.25) 230.37,23.02 229.89,23.02 229.81,23.11 229.81,24.05 229.89,24.13 230.17,24.13 230.37,24.34 230.37,24.63 230.17,24.84 229.89,24.84 229.81,24.91 229.81,25.25 228.11,26.95 210.05,26.95 206.99,30.01 203.37,30.01 191.33,42.04 174.33,42.04 169.33,47.05 169.33,51.77 166.97,54.12 164.84,56.25 163.86,57.23 163.86,63.48 163.61,63.73 163.61,64.83 163.5,64.94 163.5,65.43 163.63,65.55 163.86,65.55 163.99,65.43 v2(163.99,65.27)
  BOTTOM w0.089: v2(163.99,65.27) 163.86,65.27 UH1.AA9
  BOTTOM w0.14: v2(230.6,23.25) 230.41,23.06 230.23,23.06 230.1,23.19 230.1,25.23 230.18,25.3 JDIMM2.179
DDR_B_DQS5: length 101.2
  IN1 w0.079: v2(165.83,64.64) 165.83,64.8 165.99,64.95 166.13,64.95 166.2,64.88 166.2,63.67 166.27,63.6 166.27,58.39 171.38,53.28 171.38,53.03 174.69,49.72 174.69,47.47 176.52,45.65 192.83,45.65 193.25,45.23 204.76,33.71 208.42,33.71 209.64,32.49 223.43,32.49 224.17,31.75 229.29,31.75 232.79,28.25 232.79,27.66 235.86,24.59 235.86,21.85 236.09,21.61 236.35,21.61 236.44,21.52 v2(236.44,21.36)
  BOTTOM w0.076: v2(165.83,64.64) 165.89,64.59 166.25,64.59 166.33,64.66 166.33,64.89 UH1.V9
  BOTTOM w0.14: JDIMM2.200 235.44,18.98 235.31,19.11 235.31,19.32 235.81,19.81 235.81,21.32 236,21.51 236.29,21.51 v2(236.44,21.36)
DDR_B_DQS6: length 101.6
  IN1 w0.079: v2(241.7,23.27) 241.49,23.06 241.36,23.06 241.31,23.11 241.31,24.7 238.7,27.31 238.7,28.13 230.42,36.41 212.62,36.41 212.54,36.48 212.54,36.8 212.32,37.02 211.93,37.02 211.71,36.8 211.71,36.53 211.58,36.41 211.27,36.41 211.14,36.53 211.14,36.84 210.95,37.03 210.64,37.03 210.01,37.67 206.34,37.67 194.45,49.56 180.97,49.56 176.47,54.06 175.64,54.06 173.8,55.91 172.53,55.91 169.42,59.01 169.38,59.01 169.1,59.3 169.1,64.86 168.92,65.04 168.92,65.39 169.06,65.53 169.31,65.53 169.48,65.36 v2(169.48,65.27)
  BOTTOM w0.089: UH1.P9 169.35,65.27 v2(169.48,65.27)
  BOTTOM w0.14: v2(241.7,23.27) 241.59,23.15 241.34,23.15 241.27,23.23 241.27,24.66 240.6,25.33 240.6,25.44 240.67,25.52 JDIMM2.221
DDR_B_DQS7: length 103.3
  IN1 w0.079: v2(171.26,64.56) 171.16,64.67 171.16,64.74 171.29,64.88 171.47,64.88 171.62,64.73 171.62,63.9 171.98,63.54 172.24,63.54 173.12,62.66 173.12,62.46 173.62,61.96 173.82,61.96 180.96,54.82 184.55,54.82 185.51,53.87 191.91,53.87 192.51,53.27 195.84,53.27 198.3,50.81 199.81,50.81 209.35,41.27 215.02,41.27 216.28,40.01 232.31,40.01 244.28,28.04 244.28,27.11 244.56,26.84 244.79,26.84 244.94,26.98 245.05,26.98 245.21,26.81 245.21,26.7 245.07,26.56 245.07,26.32 245.34,26.06 246.06,26.06 246.91,25.2 246.91,23.09 246.59,22.77 246.59,21.89 246.86,21.62 247.17,21.62 247.29,21.5 v2(247.29,21.36)
  BOTTOM w0.076: UH1.L9 171.64,64.95 v2(171.26,64.56)
  BOTTOM w0.14: v2(247.29,21.36) 247.29,21.36 246.96,21.36 246.86,21.26 246.86,20.13 245.93,19.2 JDIMM2.242
DDR_B_DQS#0: length 90.6
  IN1 w0.079: v2(185.23,23.21) 185.23,23.1 185.07,22.93 184.9,22.93 184.81,23.02 184.81,24.48 183.62,25.68 175.89,25.68 175.23,26.35 163.19,26.35 156.4,33.14 147.62,33.14 134.4,46.36 134.4,63.41 136.05,65.06 136.05,65.46 136.5,65.91 137.18,65.91 137.88,65.21 138.63,65.21 138.8,65.38 138.8,65.65 138.94,65.79 v2(139.08,65.79)
  BOTTOM w0.076: UH1.BP9 138.75,65.19 138.85,65.1 138.98,65.1 139.08,65.19 v2(139.08,65.79)
  BOTTOM w0.14: v2(185.23,23.21) 185.43,23.01 185.69,23.01 185.83,23.15 185.83,24.61 186.28,25.06 186.28,25.45 186.18,25.55 JDIMM2.11
DDR_B_DQS#1: length 90.1
  IN1 w0.079: v2(141.16,65.92) 140.78,65.54 140.78,62.59 140.57,62.38 140.57,61.05 141.07,60.56 141.07,58.49 137.9,55.33 137.9,51.3 138.71,50.49 138.71,47.15 147.8,38.05 157.56,38.05 165.02,30.59 177.67,30.59 178.51,29.75 185.36,29.75 186.81,28.3 186.81,27.86 190.31,24.35 190.31,21.69 190.46,21.54 190.66,21.54 v2(190.89,21.3)
  BOTTOM w0.076: UH1.BL9 v2(141.16,65.92)
  BOTTOM w0.14: v2(190.89,21.3) 191,21.41 191.28,21.41 191.48,21.21 191.48,19.04 191.43,18.98 JDIMM2.32
DDR_B_DQS#2: length 92.1
  IN1 w0.079: v2(143.87,65.27) 143.87,65.43 143.96,65.52 144.24,65.52 144.32,65.43 144.32,65.05 144.24,64.97 144.24,62.79 144.75,62.28 144.75,57.95 143.23,56.42 143.23,47.94 148.71,42.46 149.42,42.46 149.59,42.63 149.59,42.93 149.67,43.01 149.9,43.01 149.98,42.93 149.98,42.63 150.15,42.46 150.52,42.46 150.69,42.63 150.69,42.93 150.76,43.01 151,43.01 151.08,42.93 151.08,42.63 151.25,42.46 151.61,42.46 151.78,42.63 151.78,42.93 151.89,43.03 152.07,43.03 152.18,42.93 152.18,42.63 152.35,42.46 158.47,42.46 166.58,34.35 187.98,34.35 193.65,28.68 193.65,27.36 197.15,23.86 197.15,23.11 197.04,23 196.82,23 v2(196.61,23.21)
  BOTTOM w0.089: UH1.BG9 143.74,65.27 v2(143.87,65.27)
  BOTTOM w0.14: v2(196.61,23.21) 196.72,23.1 196.95,23.1 197.08,23.24 197.08,24.76 196.77,25.08 196.77,25.42 196.67,25.52 JDIMM2.53
DDR_B_DQS#3: length 91.8
  IN1 w0.079: v2(146.62,65.27) 146.72,65.38 146.87,65.38 146.99,65.26 146.99,63.72 147.68,63.03 147.68,55.7 148.31,55.07 148.31,50.44 150.96,47.79 158.57,47.79 161.62,44.73 161.86,44.73 162.21,45.08 162.32,45.08 162.49,44.91 162.49,44.8 162.14,44.45 162.14,44.21 162.4,43.95 162.64,43.95 162.99,44.3 163.12,44.3 163.27,44.16 163.27,44.02 162.92,43.67 162.92,43.44 168.23,38.13 189.71,38.13 199.65,28.19 199.65,26.97 202.02,24.61 202.02,21.74 202.19,21.56 202.39,21.56 v2(202.65,21.3)
  BOTTOM w0.089: v2(146.62,65.27) 146.49,65.27 UH1.BC9
  BOTTOM w0.14: v2(202.65,21.3) 202.81,21.46 203,21.46 203.08,21.38 203.08,20.42 202.02,19.36 202.02,19.13 201.92,19.04 JDIMM2.74
DDR_B_DQS#4: length 99.3
  IN1 w0.079: v2(230.6,22.62) 230.35,22.87 229.83,22.87 229.65,23.05 229.65,24.12 229.82,24.29 230.1,24.29 230.22,24.4 230.22,24.57 230.1,24.68 229.82,24.68 229.65,24.85 229.65,25.18 228.04,26.79 209.98,26.79 206.92,29.85 203.3,29.85 191.27,41.89 174.27,41.89 169.17,46.98 169.17,51.7 166.86,54.01 164.73,56.14 163.71,57.17 163.71,63.42 163.46,63.67 163.46,64.77 163.34,64.88 163.34,65 v2(163.08,65.27)
  BOTTOM w0.089: UH1.AC9 162.94,65.27 v2(163.08,65.27)
  BOTTOM w0.14: v2(230.6,22.62) 230.46,22.76 230.1,22.76 229.8,23.06 229.8,25.2 229.67,25.33 JDIMM2.177
DDR_B_DQS#5: length 101.2
  IN1 w0.079: v2(165.83,65.28) 166,65.11 166.19,65.11 166.35,64.95 166.35,63.74 166.43,63.66 166.43,58.46 171.54,53.34 171.54,53.09 174.85,49.78 174.85,47.54 176.58,45.8 192.89,45.8 193.4,45.29 204.83,33.87 208.49,33.87 209.71,32.65 223.49,32.65 224.24,31.9 229.36,31.9 232.95,28.31 232.95,27.72 236.02,24.65 236.02,21.91 236.16,21.77 236.21,21.77 v2(236.44,22)
  BOTTOM w0.076: v2(165.83,65.28) 165.5,64.95 UH1.W9
  BOTTOM w0.14: v2(236.44,22) 236.26,21.82 235.87,21.82 235.5,21.45 235.5,19.94 235.01,19.44 235.01,19.02 234.94,18.96 JDIMM2.198
DDR_B_DQS#6: length 101.7
  IN1 w0.079: v2(241.7,22.63) 241.43,22.9 241.29,22.9 241.15,23.04 241.15,24.63 238.54,27.24 238.54,28.06 230.36,36.25 212.55,36.25 212.38,36.42 212.38,36.74 212.26,36.86 211.99,36.86 211.86,36.74 211.86,36.47 211.65,36.25 211.2,36.25 210.98,36.47 210.98,36.77 210.88,36.87 210.58,36.87 209.94,37.51 206.28,37.51 194.39,49.41 180.91,49.41 176.41,53.91 175.58,53.91 173.74,55.75 172.47,55.75 169.36,58.86 169.32,58.86 168.94,59.23 168.94,64.79 168.76,64.97 168.76,65.07 v2(168.56,65.27)
  BOTTOM w0.089: UH1.R9 168.43,65.27 v2(168.56,65.27)
  BOTTOM w0.14: v2(241.7,22.63) 241.49,22.85 241.22,22.85 240.96,23.1 240.96,24.53 240.29,25.2 240.29,25.34 240.18,25.46 JDIMM2.219
DDR_B_DQS#7: length 103.5
  IN1 w0.079: v2(171.29,65.24) 171.47,65.06 171.51,65.06 171.78,64.79 171.78,63.96 172.04,63.7 172.3,63.7 173.28,62.72 173.28,62.52 173.69,62.11 173.89,62.11 181.02,54.98 184.62,54.98 185.57,54.02 191.98,54.02 192.57,53.43 195.9,53.43 198.36,50.96 199.87,50.96 209.41,41.43 215.09,41.43 216.35,40.17 232.38,40.17 244.44,28.1 244.44,27.18 244.62,27 244.73,27 244.87,27.14 245.11,27.14 245.37,26.88 245.37,26.64 245.23,26.5 245.23,26.39 245.4,26.21 246.13,26.21 247.07,25.27 247.07,23.02 246.75,22.7 246.75,21.95 246.93,21.78 247.07,21.78 v2(247.29,22)
  BOTTOM w0.076: UH1.M9 171,64.95 v2(171.29,65.24)
  BOTTOM w0.14: v2(247.29,22) 246.96,21.66 246.83,21.66 246.55,21.38 246.55,20.25 245.42,19.13 JDIMM2.240
DDR_B_MA0: length 100.1
  IN3 w0.089: v2(157.59,65.27) 157.29,65.27 157.1,65.09 157.1,63.87 158.01,62.97 158.01,61.12 157.66,60.77 157.66,59.97 158.28,59.35 158.28,53.95 158.56,53.68 158.56,51.49 159.82,50.24 159.82,50
  IN3 w0.122: v2(220.72,21.12) 220.51,20.9 220,20.9 219.66,21.24 219.66,22.01 219.66,22.18 219.66,30.01 208.02,41.64 166.94,41.64 159.82,48.76 159.82,50
  BOTTOM w0.076: v2(157.59,65.27) 157.46,65.27 UH1.AJ9
  BOTTOM w0.221: JDIMM2.144 219.43,19.82 v2(220.72,21.12)
DDR_B_MA1: length 98.9
  IN3 w0.089: v2(156.12,62.68) 156.12,61.89 155.76,61.52 155.76,54.45 155.89,54.32 155.89,51.9 156.48,51.31 156.48,50
  IN3 w0.122: v2(216.38,24.22) 216.38,26.46 215.76,27.08 215.76,29.62 207.41,37.97 201.13,37.97 200.45,38.66 195.6,38.66 195.48,38.53 195.48,38.1 195.35,37.97 195.12,37.97 194.99,38.1 194.99,38.71 194.87,38.84 194.62,38.84 194.5,38.71 194.5,38.1 194.37,37.97 194.14,37.97 194.01,38.1 194.01,38.71 193.89,38.84 193.65,38.84 193.53,38.71 193.53,38.1 193.4,37.97 193.16,37.97 193.04,38.1 193.04,38.71 192.92,38.84 192.67,38.84 192.55,38.71 192.55,38.1 192.42,37.97 192.19,37.97 192.06,38.1 192.06,38.71 191.94,38.84 191.7,38.84 191.57,38.71 191.57,38.1 191.45,37.97 191.21,37.97 191.09,38.1 191.09,38.8 190.96,38.93 190.66,38.93 190.53,38.8 190.53,38.1 190.41,37.98 190.17,37.98 190.05,38.1 190.05,38.8 189.92,38.93 165.81,38.93 156.48,48.25 156.48,50
  BOTTOM w0.076: UH1.AK6 156.26,62.68 v2(156.12,62.68)
  BOTTOM w0.221: JDIMM2.133 216.67,24.94 216.38,24.64 v2(216.38,24.22)
DDR_B_MA2: length 98.6
  IN3 w0.089: v2(156.9,62) 156.49,62 155.93,61.45 155.93,59.31 156.66,58.58 156.66,53.7 156.91,53.45 156.91,50
  IN3 w0.122: 156.91,50 156.91,48.43 165.99,39.35 200.94,39.35 201.06,39.23 201.06,38.73 201.18,38.6 201.42,38.6 201.55,38.73 201.55,39.23 201.67,39.35 201.91,39.35 202.03,39.23 202.03,38.53 202.16,38.4 202.39,38.4 202.52,38.53 202.52,39.23 202.64,39.35 202.89,39.35 203.01,39.23 203.01,38.53 203.14,38.4 207.59,38.4 216.84,29.14 216.84,22.92 v2(218.15,21.62)
  BOTTOM w0.076: v2(156.9,62) 156.85,62 UH1.AK5
  BOTTOM w0.221: JDIMM2.132 216.43,19 217.11,19.69 217.11,20.61 218.12,21.62 v2(218.15,21.62)
DDR_B_MA3: length 97.9
  IN3 w0.089: 156.06,50 156.06,51.05 155.71,51.39 155.71,54.24 155.58,54.38 155.58,61.77 v2(155.34,62.01)
  IN3 w0.122: v2(216.38,22.95) 215.95,23.38 215.95,26.28 215.33,26.9 215.33,29.45 207.23,37.55 200.5,37.55 200.38,37.67 200.38,38.11 200.26,38.23 200.02,38.23 199.89,38.11 199.89,37.67 199.77,37.55 199.53,37.55 199.41,37.67 199.41,38.11 199.28,38.23 199.04,38.23 198.92,38.11 198.92,37.67 198.8,37.55 198.55,37.55 198.43,37.67 198.43,38.11 198.31,38.23 198.06,38.23 197.94,38.11 197.94,37.67 197.82,37.55 197.58,37.55 197.45,37.67 197.45,38.11 197.33,38.23 197.09,38.23 196.97,38.11 196.97,37.67 196.85,37.55 196.6,37.55 196.48,37.67 196.48,38.11 196.36,38.23 196.11,38.23 195.99,38.11 195.99,37.67 195.87,37.55 189.84,37.55 188.89,38.5 165.63,38.5 156.06,48.08 156.06,50
  BOTTOM w0.076: v2(155.34,62.01) 155.67,62.34 UH1.AL5
  BOTTOM w0.221: v2(216.38,22.95) 216.36,22.95 215.85,23.45 215.85,24.86 216.18,25.18 JDIMM2.131
DDR_B_MA4: length 96.6
  IN3 w0.089: 154.86,50 154.7,50.17 154.7,58.7 154.09,59.3 154.09,62.78 154.34,63.03 154.97,63.03 v2(155.34,62.66)
  IN3 w0.122: 154.86,50 155.2,49.66 155.2,47.72 165.28,37.65 188.53,37.65 189.49,36.69 206.67,36.69 208.53,34.83 208.54,34.83 214.48,28.89 214.48,26.55 215.1,25.93 215.1,21.69 v2(216.38,20.41)
  BOTTOM w0.076: UH1.AL6 155.67,62.99 v2(155.34,62.66)
  BOTTOM w0.221: v2(216.38,20.41) 216.38,19.81 215.99,19.42 215.91,19.42 215.43,18.93 JDIMM2.128
DDR_B_MA5: length 96.4
  IN3 w0.089: 155.47,50 154.87,50.59 154.87,58.35 155.4,58.87 155.4,61.44 154.91,61.93 154.91,62.25 v2(154.5,62.66)
  IN3 w0.122: v2(216.38,21.68) 216.27,21.79 215.65,21.79 215.53,21.92 215.53,22.17 215.65,22.29 215.85,22.29 215.98,22.42 215.98,22.75 215.85,22.88 215.65,22.88 215.53,23 215.53,26.1 214.9,26.72 214.9,29.12 206.91,37.12 189.67,37.12 188.71,38.07 165.46,38.07 155.63,47.9 155.63,49.84 155.47,50
  BOTTOM w0.076: UH1.AM6 154.83,62.99 v2(154.5,62.66)
  BOTTOM w0.221: JDIMM2.126 214.92,19.22 215.26,19.55 215.26,20.61 216.32,21.68 v2(216.38,21.68)
DDR_B_MA6: length 96.2
  IN3 w0.089: v2(154.85,63.47) 154.36,63.47 153.86,62.98 153.86,59 154.25,58.61 154.25,50
  IN3 w0.122: 154.25,50 154.25,49.72 154.37,49.6 154.63,49.6 154.75,49.47 154.75,49.23 154.63,49.11 154.37,49.11 154.25,48.99 154.25,48.72 154.34,48.62 154.61,48.62 154.74,48.5 154.74,48.31 154.48,48.05 154.48,47.84 165.1,37.22 188.36,37.22 189.32,36.26 206.49,36.26 213.57,29.18 213.57,26.85 214.67,25.75 214.67,22.95 214.59,22.87 v2(214.14,22.87)
  BOTTOM w0.076: v2(154.85,63.47) 154.67,63.65 UH1.AN7
  BOTTOM w0.221: JDIMM2.127 215.18,23.9 v2(214.14,22.87)
DDR_B_MA7: length 98
  IN3 w0.089: 153.4,50 153.4,58.4 153.48,58.48 153.48,63.11 154.19,63.82 154.19,64.09 154.48,64.37 154.48,65.56 v2(154.85,65.92)
  IN3 w0.122: 153.4,50 153.4,47.72 164.75,36.37 188,36.37 188.96,35.41 205.6,35.41 211.5,29.51 211.5,27.72 213.7,25.51 213.7,21.97 v2(214.14,21.52)
  BOTTOM w0.076: v2(154.85,65.92) 154.71,65.92 UH1.AN10
  BOTTOM w0.221: v2(214.14,21.52) 214.23,21.52 214.63,21.13 214.63,19.76 213.92,19.06 JDIMM2.122
DDR_B_MA8: length 96.1
  IN3 w0.089: 153.82,50 153.82,58.42 153.66,58.58 153.66,63.03 154.37,63.75 154.37,63.93 154.46,64.02 v2(154.82,64.02)
  IN3 w0.122: 153.82,50 153.82,47.9 164.92,36.79 188.18,36.79 189.14,35.83 206.31,35.83 209.65,32.49 209.65,32.32 209.56,32.23 209.56,32.06 209.73,31.88 209.9,31.88 210,31.98 210.17,31.98 210.34,31.8 210.34,31.63 210.25,31.54 210.25,31.37 210.42,31.19 210.59,31.19 210.69,31.29 210.86,31.29 211.03,31.11 211.03,30.94 210.94,30.85 210.94,30.68 211.11,30.5 211.64,30.5 211.81,30.34 211.81,29.8 212.19,29.43 212.72,29.43 212.85,29.3 212.85,29.07 212.72,28.94 212.05,28.94 211.92,28.81 211.92,28.58 212.05,28.45 212.58,28.45 212.71,28.32 212.71,28.09 212.58,27.96 212.31,27.96 212.19,27.84 212.19,27.63 212.31,27.5 212.65,27.5 213.15,27 213.15,26.67 214.25,25.57 214.25,24.32 v2(214.16,24.23)
  BOTTOM w0.076: UH1.AN8 154.55,64.3 v2(154.82,64.02)
  BOTTOM w0.221: v2(214.16,24.23) 214.67,24.75 JDIMM2.125
DDR_B_MA9: length 96.9
  IN3 w0.089: v2(153.01,65.87) 153.56,65.32 153.56,63.69 153.03,63.16 153.03,58.75 152.79,58.52 152.79,50.65 152.54,50.4 152.54,50
  IN3 w0.122: 152.54,50 152.54,47.37 164.39,35.51 187.65,35.51 188.61,34.55 205.08,34.55 209.95,29.69 209.95,27.07 212.51,24.51 212.51,23.17 v2(212.08,22.74)
  BOTTOM w0.076: v2(153.01,65.87) 152.63,66.25 UH1.AR11
  BOTTOM w0.221: JDIMM2.121 213.67,24.82 213.14,24.28 213.14,23.8 v2(212.08,22.74)
DDR_B_MA10: length 98.4
  IN3 w0.089: 161.45,50 159.34,52.11 159.34,53.91 158.98,54.28 158.98,59.41 158.41,59.98 158.41,60.77 158.54,60.9 158.54,63.93 v2(158.5,63.97)
  IN3 w0.122: 161.45,50 161.45,48.94 164.67,45.72 166.09,45.72 168.1,43.71 168.1,43.54 167.88,43.32 167.88,43.14 168.05,42.97 168.23,42.97 168.45,43.19 168.62,43.19 168.89,42.92 208.56,42.92 220.94,30.54 220.94,26.34 221.2,26.07 221.2,20.26 v2(220.71,19.76)
  BOTTOM w0.076: v2(158.5,63.97) 158.37,63.97 UH1.AH7
  BOTTOM w0.221: v2(220.71,19.76) 221.24,19.76 221.93,19.07 JDIMM2.146
DDR_B_MA11: length 100.3
  IN3 w0.089: v2(154.85,66.57) 154.3,66.03 154.3,64.45 153.98,64.12 153.98,63.86 153.25,63.13 153.25,58.62 153.13,58.5 153.13,50.37 152.97,50.21 152.97,50
  IN3 w0.122: 152.97,50 152.97,47.54 164.57,35.94 187.83,35.94 188.79,34.98 205.42,34.98 211.07,29.33 211.07,27.54 213.28,25.33 213.28,23.35 213.15,23.22 213.06,23.22 212.93,23.1 212.93,22.86 213.06,22.74 213.15,22.74 213.28,22.61 213.28,22.38 213.15,22.25 212.78,22.25 212.65,22.12 212.65,21.97 212.78,21.84 213.15,21.84 213.28,21.71 213.28,21.14 v2(214.16,20.25)
  BOTTOM w0.076: v2(154.85,66.57) 154.71,66.57 UH1.AN11
  BOTTOM w0.221: v2(214.16,20.25) 213.88,20.25 213.43,19.8 JDIMM2.120
DDR_B_MA12: length 96
  IN3 w0.089: v2(153.02,65.26) 153.38,64.9 153.38,63.76 152.8,63.18 152.8,60.43 152.03,59.66 152.03,54.06 152.09,54 152.09,50
  IN3 w0.122: v2(212.08,24.09) 212.08,24.33 209.52,26.9 209.52,28.53 207.4,30.65 207.4,30.82 207.71,31.13 207.71,31.3 207.54,31.47 207.37,31.47 207.06,31.16 206.89,31.16 206.71,31.34 206.71,31.51 207.02,31.82 207.02,31.99 206.85,32.16 206.68,32.16 206.37,31.85 206.2,31.85 206.02,32.03 206.02,32.2 206.33,32.51 206.33,32.68 206.16,32.85 205.99,32.85 205.68,32.54 205.51,32.54 203.92,34.13 188.43,34.13 187.47,35.09 164.22,35.09 152.09,47.21 152.09,50
  BOTTOM w0.076: v2(153.02,65.26) 152.68,65.6 UH1.AR10
  BOTTOM w0.221: JDIMM2.119 213.18,25.19 v2(212.08,24.09)
DDR_B_MA13: length 100.3
  IN3 w0.089: v2(160.33,65.27) 159.75,64.69 159.75,63.78 160.15,63.38 160.15,60.66
  IN3 w0.122: 160.15,60.66 161.21,59.6 161.21,55.98 164.44,52.75 164.74,52.75 171.77,45.72 209.71,45.72 223.82,31.61 223.82,29.02 224.15,28.68 224.15,21.52 224.06,21.43 223.58,21.43 223.46,21.3 223.46,21.07 223.58,20.94 224.06,20.94 224.18,20.82 224.18,20.57 224.06,20.45 223.56,20.45 223.43,20.33 223.43,20.11 223.56,19.99 v2(225.02,19.99)
  BOTTOM w0.076: v2(160.33,65.27) 160.01,64.95 UH1.AF9
  BOTTOM w0.221: JDIMM2.158 224.93,19.22 225.02,19.31 v2(225.02,19.99)
DDR_B_PAR: length 97.9
  IN3 w0.089: v2(157.59,63.97) 157.59,63.64 158.19,63.04 158.19,61.05 157.84,60.7 157.84,60.04 158.58,59.3 158.58,53.97 158.83,53.72 158.83,51.69 160.41,50.11 160.41,50
  IN3 w0.122: v2(220.75,22.64) 220.57,22.46 220.21,22.46 220.09,22.58 220.09,30.19 208.2,42.07 167.11,42.07 160.4,48.78 160.4,49.99 160.41,50
  BOTTOM w0.076: UH1.AJ7 157.46,63.97 v2(157.59,63.97)
  BOTTOM w0.221: JDIMM2.143 219.19,23.37 219.92,22.64 v2(220.75,22.64)
DDR_B_RAS#: length 98.3
  IN3 w0.089: 160.36,54.29 159.75,54.29 159.43,54.61 159.43,60.04 158.9,60.57 158.9,63.5 159.04,63.65 159.04,64.83 158.87,65 158.87,65.55 v2(158.5,65.92)
  IN3 w0.122: v2(222.65,21.51) 222.05,22.1 222.05,26.43 221.79,26.69 221.79,30.89 208.91,43.78 170.66,43.78 164.47,49.97 164.47,50.49 160.66,54.29 160.36,54.29
  BOTTOM w0.076: UH1.AH10 158.37,65.92 v2(158.5,65.92)
  BOTTOM w0.221: v2(222.65,21.51) 223.43,20.73 JDIMM2.152
DDR_B_WE#: length 94.3
  IN3 w0.089: v2(158.5,66.57) 159.05,66.03 159.05,65.23 159.31,64.97 159.31,63.65 159.08,63.43 159.08,60.77 159.24,60.61
  IN3 w0.122: 159.24,60.61 160.49,59.36 160.49,55.19 165.49,50.19 165.49,49.86 171.15,44.2 209.09,44.2 222.3,30.99 222.3,26.89 222.64,26.56 222.64,24.23 v2(222.65,24.22)
  BOTTOM w0.076: v2(158.5,66.57) 158.37,66.57 UH1.AH11
  BOTTOM w0.221: JDIMM2.151 223.18,24.75 222.64,24.22 v2(222.65,24.22)
DDR_CKE0_DIMMA: length 50
  IN6 w0.117: v2(133.91,24.37) 133.83,24.45 133.83,29.14 133.96,29.27 134.16,29.27 134.28,29.4 134.28,29.59 134.16,29.71 133.96,29.71 133.83,29.84 133.83,30.06 133.96,30.19 134.64,30.19 134.77,30.32 134.77,30.53 134.64,30.66 133.96,30.66 133.83,30.79 133.83,31 133.96,31.13 134.64,31.13 134.77,31.25 134.77,31.57 134.64,31.69 134.01,31.69 133.89,31.82 133.89,32.03 134.01,32.16 134.59,32.16 134.71,32.28 134.71,32.86 143.16,41.32 143.16,41.96 147.32,46.12 147.32,47.81 147.76,48.25 147.76,48.42 147.43,48.76 147.43,48.92 147.59,49.09 147.76,49.09 148.09,48.75 148.26,48.75 148.57,49.06 148.57,52.69 148.93,53.06 148.93,54.35 v2(149.54,54.95)
  BOTTOM w0.076: v2(149.54,54.95) 150.02,55.44 150.02,56.75 151.49,58.21 UH1.AT1
  BOTTOM w0.221: JDIMM1.109 134.37,25.44 133.91,24.98 v2(133.91,24.37)
DDR_CKE1_DIMMA: length 51.2
  IN6 w0.117: v2(133.92,23.04) 133.41,23.56 133.41,31.18 133.47,31.24 133.47,32.21 142.74,41.49 142.74,42.14 146.9,46.3 146.9,49.03 147.63,49.76 147.63,52.87 148.15,53.39 148.15,54.7 v2(149.51,56.06)
  BOTTOM w0.076: v2(149.51,56.06) 149.51,56.47 151.2,58.16 151.2,60.09 UH1.AT2
  BOTTOM w0.221: v2(133.92,23.04) 133.83,23.04 133.16,22.38 133.16,19.97 133.76,19.37 134.22,19.37 134.62,18.97 JDIMM1.110
DDR_CKE2_DIMMB: length 99.7
  IN3 w0.089: v2(152.11,64.01) 151.88,64.01 150.32,62.44 150.32,60.14 149.13,58.95 ; 149.12,50 149.12,55.32
  IN3 w0.122: 149.12,50 149.12,46.69 163.2,32.62 186.45,32.62 187.41,31.66 202.9,31.66 205.11,29.45 205.11,27.82 209.04,23.89 209.04,22.7 209.16,22.58 209.41,22.58 209.54,22.45 209.54,22.21 209.41,22.09 209.16,22.09 209.04,21.97 209.04,21.81 209.68,21.17 209.95,21.17 v2(210.23,21.45) ; 149.13,58.95 149.13,55.32 149.12,55.32
  BOTTOM w0.089: UH1.AT8 151.94,64.01 v2(152.11,64.01)
  BOTTOM w0.221: v2(210.23,21.45) 209.44,22.24 209.44,24.12 210.67,25.35 JDIMM2.109
DDR_CKE3_DIMMB: length 100.3
  IN3 w0.089: 148.82,58.95 150.04,60.17 150.04,62.56 151.74,64.26 151.74,65.56 v2(152.1,65.92) ; 148.64,50 148.64,55.13
  IN3 w0.122: v2(210.23,20.01) 208.48,21.76 208.48,23.84 207.92,24.4 207.75,24.4 207.33,23.98 207.15,23.98 206.98,24.14 206.98,24.32 207.41,24.75 207.41,24.92 207.23,25.09 207.06,25.09 206.91,24.94 206.74,24.94 206.57,25.12 206.57,25.29 206.72,25.44 206.72,25.61 204.69,27.64 204.69,29.27 202.73,31.24 187.24,31.24 186.28,32.2 163.02,32.2 148.64,46.58 148.64,50 ; 148.64,55.13 148.82,55.32 148.82,58.95
  BOTTOM w0.089: v2(152.1,65.92) 151.97,65.92 UH1.AT10
  BOTTOM w0.221: JDIMM2.110 210.92,19.32 v2(210.23,20.01)
DDR_CS0_DIMMA#: length 55.2
  IN6 w0.089: v2(161.19,62.01) 160.91,62.29 158.91,62.29 158.79,62.16 158.79,51.13 159.92,50
  IN6 w0.117: v2(146.47,23.25) 146.74,23.25 146.88,23.11 146.88,21.78 146.96,21.7 147.18,21.7 147.25,21.78 147.25,24.05 148.15,24.94 148.15,29.52 150.12,31.49 150.12,33.41 158.66,41.95 158.66,43.99 159.92,45.24 159.92,50
  BOTTOM w0.076: v2(161.19,62.01) 161.51,62.34 UH1.AD5
  BOTTOM w0.221: JDIMM1.149 146.37,25.47 145.87,24.97 145.87,23.43 146.05,23.25 v2(146.47,23.25)
DDR_CS1_DIMMA#: length 57.6
  IN6 w0.117: v2(159.94,53.16) 160.24,53.16 163.07,50.33 163.07,49.64 163.18,49.52 163.29,49.52 163.41,49.39 163.41,49.18 163.29,49.05 163.18,49.05 163.07,48.94 163.07,48.7 163.18,48.59 163.29,48.59 163.41,48.46 163.41,48.25 163.29,48.12 163.18,48.12 163.07,48 163.07,47.77 163.18,47.65 163.3,47.65 163.41,47.54 163.41,47.3 163.3,47.18 163.18,47.18 163.07,47.07 163.07,46.83 163.18,46.72 163.3,46.72 163.41,46.6 163.41,46.37 163.3,46.25 163.18,46.25 163.07,46.13 163.07,45.9 163.18,45.78 163.29,45.78 163.41,45.66 163.41,45.44 163.29,45.32 163.12,45.32 162.99,45.19 162.99,44.97 163.12,44.84 163.29,44.84 163.41,44.71 163.41,44.51 163.29,44.38 162.94,44.38 162.81,44.26 162.81,44.06 163.17,43.71 163.17,43.53 163.01,43.37 162.84,43.37 162.48,43.73 162.32,43.73 162.15,43.56 162.15,43.4 162.59,42.95 162.59,42.77 162.46,42.64 162.28,42.64 161.85,43.08 161.67,43.08 161.47,42.88 161.47,42.7 161.67,42.5 161.86,42.31 161.86,42.04 161.43,41.61 161.43,40.8 154.38,33.75 154.38,31.55 153.48,30.66 153.32,30.66 153.22,30.75 153.04,30.75 152.89,30.6 152.89,30.42 152.99,30.32 152.99,30.16 151.76,28.93 151.76,27 151.88,26.89 151.98,26.89 152.1,26.76 152.1,26.55 151.98,26.42 151.88,26.42 151.76,26.3 151.76,26.07 151.88,25.95 152.16,25.95 152.29,25.83 152.29,25.61 152.16,25.49 151.88,25.49 151.76,25.37 151.76,25.08 151.24,24.56 151.24,23.13 151.09,22.98 150.87,22.98 150.74,23.1 v2(150.74,23.22)
  BOTTOM w0.076: UH1.AE2 160.76,60.44 160.64,60.44 160.53,60.32 160.53,59.6 160.65,59.49 160.65,58.51 160.52,58.38 160.52,57.75 159.55,56.78 159.55,53.24 159.73,53.06 159.84,53.06 v2(159.94,53.16)
  BOTTOM w0.221: JDIMM1.157 148.37,24.98 150.36,22.99 150.51,22.99 v2(150.74,23.22)
DDR_CS2_DIMMB#: length 97.1
  IN3 w0.089: v2(160.31,65.89) 159.92,65.5 159.92,65.28 159.53,64.9 159.53,63.73 159.86,63.4 159.86,62.79 159.86,60.5
  IN3 w0.122: v2(222.65,22.95) 223.39,23.69 223.39,28.37 223.06,28.7 223.06,31.3 209.4,44.96 171.46,44.96 160.87,55.55 160.87,59.49 159.86,60.5
  BOTTOM w0.076: UH1.AF11 159.96,66.25 v2(160.31,65.89)
  BOTTOM w0.221: JDIMM2.149 222.67,25.49 221.77,24.58 221.77,23.59 222.42,22.95 v2(222.65,22.95)
DDR_CS3_DIMMB#: length 99.7
  IN3 w0.122: v2(226.26,23.32) 225.82,23.75 225.82,25.37 225.94,25.49 226.28,25.49 226.4,25.62 226.4,25.85 226.28,25.98 225.94,25.98 225.82,26.1 225.82,26.34 225.94,26.46 226.28,26.46 226.4,26.59 226.4,26.89 226.28,27.02 225.93,27.02 225.82,27.14 225.82,27.28 226.13,27.59 226.13,31.58 210.38,47.33 188.69,47.33 188.56,47.45 188.56,47.82 188.44,47.94 188.2,47.94 188.08,47.82 188.08,47.45 187.95,47.33 187.71,47.33 187.59,47.45 187.59,47.82 187.47,47.94 187.22,47.94 187.1,47.82 187.1,47.45 186.98,47.33 186.74,47.33 186.61,47.45 186.61,47.82 186.49,47.94 186.25,47.94 186.13,47.82 186.13,47.45 186,47.33 185.76,47.33 185.64,47.45 185.64,47.81 185.51,47.94 185.21,47.94 185.09,47.82 185.09,47.48 184.97,47.35 184.73,47.35 184.6,47.48 184.6,47.82 184.48,47.94 184.24,47.94 184.12,47.82 184.12,47.48 184,47.35 183.75,47.35 183.63,47.48 183.63,47.82 183.51,47.94 174.31,47.94 171.19,51.06 169.57,51.06 162.94,57.7 162.94,59.7 161.58,61.06 161.58,62.78 161.18,63.18 v2(161.18,63.3)
  BOTTOM w0.076: UH1.AE7 161.14,63.3 v2(161.18,63.3)
  BOTTOM w0.221: v2(226.26,23.32) 224.67,24.9 JDIMM2.157
DDR_VTT_PG_CTRL: length 27.1
  TOP w0.089: 134.96,65.8 134.96,66.55 v2(135.53,67.12)
  TOP w0.127: v1(124.82,56.32) 123.75,57.39 123.75,61.43 126.16,63.84 129.33,63.84 129.69,63.48 134.02,63.48 134.67,64.13 134.67,65.51 134.96,65.8
  TOP w0.14: v1(124.82,56.32) 125.82,55.32 125.82,54.07 125.6,53.86 UC1.2
  BOTTOM w0.102: v2(135.53,67.12) 136,67.12 136.64,67.76 UH1.BT13
DGPU_HOLD_RST#: length 151.8
  TOP w0.14: v2(203.21,48.22) 203.21,47.11 RV45.1 200.84,44.74 198.93,44.74 198.63,45.04 UV14.1
  IN5 w0.089: v2(82.23,10.42) 83.75,10.42 84.83,11.5 91.03,11.5 92.74,13.21 95.89,13.21 96.72,12.39 99.03,12.39 99.37,12.04 100.78,12.04 101.8,13.07 101.98,13.07
  IN5 w0.099: 101.98,13.07 106.03,13.07 106.24,12.86 107.92,12.86 108.75,12.03 113.49,12.03 114.12,12.66 174.66,12.66 181.33,19.33 181.33,20.5 181.5,20.67 v2(181.5,23.35)
  IN6 w0.099: v2(181.5,23.35) 182.84,24.69 182.84,30.57 198.76,46.48 201.47,46.48 v2(203.21,48.22)
  BOTTOM w0.089: v2(82.23,10.42) 81.89,10.76 UH2.AL36
DGPU_PEX_RST#: length 58.2
  TOP w0.14: DV8.1 200.28,55.84 199.42,54.97 199.03,54.97 198.09,54.03 RV208.2 RV29.2 196.01,53.12 196.01,45.65 198.17,43.49 201.81,43.49 v2(206.58,48.27) ; v2(205.83,57.55) 204.7,56.42 204.7,53.96 205.16,53.5 205.16,52.71 205.59,52.28 206.25,52.28 207.33,51.2 QV88.2 v2(208.89,51.2)
  IN2 w0.099: v2(205.83,57.55) 205.83,63.78 204.57,65.03 204.57,70.42 204.23,70.76 204.23,72.05 v2(202.9,73.38)
  BOTTOM w0.089: v2(202.9,73.38) 203.33,72.95 UV1.AJ12
  BOTTOM w0.14: v2(206.58,48.27) 208.89,50.57 v2(208.89,51.2)
DGPU_PWR_EN: length 166.9
  IN5 w0.089: 101.98,13.47 101.1,13.47 100.69,13.06 96.81,13.06 95.58,14.29 92.27,14.29 90.56,12.58 85.54,12.58 84.9,11.95 81.32,11.95 v2(80.67,11.3) 80.21,10.84 77.7,10.84 77.28,11.26 v2(77.28,11.56)
  IN5 w0.099: 101.98,13.47 106.2,13.47 106.41,13.26 115.09,13.26 115.29,13.06 174.49,13.06 180.52,19.09 180.52,21.94 v2(180.94,22.36)
  IN6 w0.099: v2(199.86,59.8) 199.86,58.54 198.73,57.41 198.07,57.41 195.61,54.95 195.61,54.57 194.99,53.95 194.99,43.57 182.24,30.82 182.24,25.26 180.7,23.71 180.7,22.6 v2(180.94,22.36)
  BOTTOM w0.089: v2(77.28,11.56) 77.04,11.33 76.11,11.33 75.72,11.72 ; v2(80.67,11.3) 80.67,11.65 UH2.AJ39
  BOTTOM w0.127: 75.72,11.72 75.67,11.77 75.22,11.77 74.82,12.18 73.84,12.18 73.66,12.35 72.34,12.35 RH538.1 RH537.1
  BOTTOM w0.14: QV87.2 200.41,60.35 v2(199.86,59.8)
DGPU_PWR_EN#: length 107.1
  TOP w0.14: QZ8.2 v2(238.88,105.94) ; v2(200.98,57.74) 204.14,57.74 v2(204.22,57.67) 204.42,57.46 204.42,54.06 204.09,53.73 QZ7.5 QZ7.2
  IN3 w0.089: 246.22,97.57 246.22,97.12 246.8,96.54 ; 246.81,66.08 246.72,66 241.83,66 241.47,65.63 236.91,65.63 236.62,65.34
  IN3 w0.091: 236.62,65.34 235.22,63.94 228.75,63.94 227.69,62.87 220.73,62.87 220.49,62.63 215.62,62.63 214.88,61.89 211.89,61.89 211.52,62.26 207.41,62.26 204.22,59.06 v2(204.22,57.67) ; v2(238.88,105.94) 241.69,103.13 243.03,103.13 246.22,99.95 246.22,97.57 ; 246.8,96.54 247.46,95.88 247.46,88.16 246.89,87.59 246.89,82.41 246.64,82.15 246.64,80.23 247.38,79.49 247.38,66.66 246.81,66.08
  BOTTOM w0.14: QV87.1 200.17,58.42 RV181.2 200.8,57.92 v2(200.98,57.74) ; v2(204.22,57.67) 203.73,57.18 QV86.2
DGPU_PWROK: length 226.6
  TOP w0.089: RH516.2 76.15,10.93 77.4,10.93 78.38,11.92 79.24,11.92 79.34,11.82 80.92,11.82 v2(81.46,11.28)
  TOP w0.14: v2(167.64,113.29) v1(167.64,113.93)
  IN2 w0.254: v2(167.64,113.29) 169.66,111.27 169.66,105.38 171.53,103.51 171.53,99.5 172.42,98.61 172.42,97.21 176.32,93.32 176.32,88.39 177.23,87.47 177.23,84.25 178.39,83.09 179.02,83.09 179.43,82.69 179.43,82.29 182.75,78.96 182.75,69.81 187.72,64.84 190.49,64.84 v2(191.56,63.78)
  IN5 w0.089: 101.98,13.27 101.74,13.27 100.71,12.24 99.53,12.24 99.21,12.56 96.8,12.56 95.97,13.39 91.62,13.39 90.87,12.64 90.87,12.01 90.58,11.72 81.9,11.72 v2(81.46,11.28)
  IN5 w0.099: v2(180.92,19.73) 180.75,19.55 180.75,19.03 174.58,12.86 114.04,12.86 113.4,12.23 108.83,12.23 108,13.06 106.33,13.06 106.12,13.27 101.98,13.27
  IN6 w0.099: v2(180.92,19.73) 179.29,21.36 179.29,25.25 180.87,26.83 180.87,31.5 193.51,44.14 193.51,60.2 191.56,62.15 v2(191.56,63.78)
  BOTTOM w0.089: UH2.AJ38 v2(81.46,11.28)
  BOTTOM w0.254: PR1024.2 v2(167.64,113.29)
DH_1.2V: length 15.2
  IN6 w1.016: 284.67,29.35 282.32,29.35 280.61,31.06 271.91,31.06 270.7,32.27
  vias: v2(270.75,34.07) v2(270.75,33.47) v2(285.31,28.58) v2(285.75,29.03)
DIMM_CHA_SA0: length 3.5
  TOP w0.14: RD1.2 RD28.1 172.76,17.39 v2(173.29,16.86)
  BOTTOM w0.127: JDIMM1.256 173.12,17.03 173.29,16.86 v2(173.29,16.86)
DIMM_CHA_SA1: length 8.9
  TOP w0.127: RD2.2 174.52,23.36 v3(174.33,23.17) 174.18,23.02 174.18,22 174.75,21.43 174.75,20.57 174.42,20.24 174.35,20.24 v2(173.93,19.82)
  TOP w0.14: RD29.1 175.17,24.17 RD2.2
  BOTTOM w0.127: v2(173.93,19.82) 173.93,19.31 174.12,19.12 JDIMM1.260
DIMM_CHA_SA2: length 3.8
  TOP w0.102: RD3.2 RD30.1
  TOP w0.14: RD30.1 150.88,17.33 v2(150.88,16.86) 150.88,16.82 v3(151.26,16.44)
  BOTTOM w0.127: v2(150.88,16.86) 150.63,17.11 JDIMM1.166
DIMM_CHB_SA0: length 4.2
  TOP w0.127: v2(248.95,16.84) 248.95,17.09 RD4.2 RD38.1
  TOP w0.14: v2(248.95,16.84) 249.15,16.64 v1(249.15,16.02)
  BOTTOM w0.102: v2(248.95,16.84) 249.01,16.84 249.42,17.25 JDIMM2.256
DIMM_CHB_SA1: length 6.4
  TOP w0.127: v2(250.09,19.73) 250.09,22.32
  TOP w0.14: RD5.2 RD39.1 250.66,22.89 250.09,22.32
  BOTTOM w0.127: JDIMM2.260 250.42,19.4 v2(250.09,19.73)
DIMM_CHB_SA2: length 4
  TOP w0.127: v2(227.16,16.86) 227.16,17.32 RD40.1
  TOP w0.14: v2(227.16,16.86) v1(227.16,16.09) ; RD6.2 RD40.1
  BOTTOM w0.102: v2(227.16,16.86) 226.93,17.1 JDIMM2.166
DISPOFF#: length 13.9
  TOP w0.127: v2(60.97,28.33) 60.11,27.47 v1(58.93,27.47) 57.89,27.47 57.02,28.33 55.42,28.33 RV107.1 53.65,27.19 DV1.1
  BOTTOM w0.127: v2(60.97,28.33) 60.97,29.5 60.01,30.46 60.01,32.19 60.05,32.23 JEDP1.24
DL_1.2V: length 12
  TOP w0.14: v2(274.32,26.62) v1(273.5,26.62)
  IN6 w1.016: 275.78,26.55 276.89,26.55 278.09,27.76 279.92,27.76 281.24,26.44 285.67,26.44 285.87,26.63
  vias: v2(274.96,26.62) v2(286.45,27.31) v2(286.96,27.76)
DMI_CRX_PTX_N0: length 132.9
  IN3 w0.099: v2(185.48,52.88) 185.27,53.09 185.27,53.71 184.42,54.56 184.42,58.65 177.91,65.16 176.31,65.16 175.98,64.83 175.98,64.63 v2(175.81,64.45)
  BOTTOM w0.076: v2(175.81,64.45) 175.48,64.12 UH1.E8
  BOTTOM w0.089: 87.89,27.45 87.89,27.07 87.05,26.22 87.05,25.59 86.93,25.48 86.93,25.15 86.73,24.95 UH2.C27
  BOTTOM w0.152: v2(185.48,52.88) 185.32,52.71 185.32,51.9 184.04,50.62 179.75,50.62 176.51,47.38 176.51,45.13 170.03,38.64 120.29,38.64 110.08,28.43 92.77,28.43 91.58,29.61 89.23,29.61 87.89,28.28 87.89,27.45
DMI_CRX_PTX_N1: length 129.7
  IN3 w0.099: v2(175.16,63.66) 175.29,63.66 175.73,63.22 178.32,63.22 183.63,57.91 183.63,54.22 183,53.58 v2(183,52.89)
  BOTTOM w0.076: UH1.F6 174.81,63.32 v2(175.16,63.66)
  BOTTOM w0.089: 86.68,27.31 86.18,26.82 86.18,26.43 85.99,26.24 85.99,25.95 85.99,25.94 85.99,25.63 86.15,25.47 UH2.B28
  BOTTOM w0.152: v2(183,52.89) 183.07,52.81 183.07,52.25 182.56,51.74 179.24,51.74 175.08,47.58 175.08,45.6 169.54,40.05 120.1,40.05 109.62,29.57 93.31,29.57 92.12,30.76 88.36,30.76 86.68,29.08 86.68,27.31
DMI_CRX_PTX_N2: length 128.1
  IN3 w0.099: v2(181.99,53.53) 182.2,53.73 182.2,54.46 183,55.26 183,57.18 178.13,62.05 176.43,62.05 176.07,62.41 176.07,62.57 v2(175.79,62.85)
  BOTTOM w0.076: v2(175.79,62.85) 175.48,62.54 UH1.E5
  BOTTOM w0.089: UH2.B29 85.64,25.27 85.58,25.22 85.41,25.22 85.35,25.28 85.35,25.41 85.6,25.66 85.6,26.46 85.7,26.56 85.7,28.22 85.54,28.37
  BOTTOM w0.152: 85.54,28.37 85.54,29.72 87.53,31.71 92.59,31.71 93.82,30.48 109.2,30.48 119.78,41.06 169.16,41.06 174.04,45.94 174.04,47.66 178.92,52.54 181.66,52.54 182.12,52.99 182.12,53.4 v2(181.99,53.53)
DMI_CRX_PTX_N3: length 131.7
  IN3 w0.099: v2(182.49,55.6) 182.27,55.81 182.27,56.01 181.95,56.32 181.95,56.83 178.98,59.8 175.94,59.8 175.27,60.47 175.27,61.33 174.51,62.09 174.51,64.7 174.22,65 174.06,65 174.04,64.99 v2(173.79,65.24)
  BOTTOM w0.076: UH1.J9 173.68,65.24 v2(173.79,65.24)
  BOTTOM w0.089: 84.78,28.54 84.78,28.53 84.8,28.51 84.96,28.36 84.96,28.36 85.36,27.96 85.36,27.87 85.43,27.8 85.43,27.5 85.43,27.28 85.43,27.28 85.43,26.95 85.43,26.95 85.43,26.55 85.42,26.54 85.42,25.85 85.36,25.79 85.36,25.69 85.02,25.36 UH2.B30
  BOTTOM w0.152: 84.78,28.54 84.78,30.16 87.06,32.43 93.12,32.43 94.61,30.94 108.66,30.94 119.53,41.8 168.92,41.8 173.31,46.19 173.31,47.58 178.73,52.99 180.53,52.99 182.49,54.95 v2(182.49,55.6)
DMI_CRX_PTX_P0: length 132.9
  IN3 w0.099: v2(176.46,64.45) 176.35,64.35 176.28,64.35 176.17,64.45 176.17,64.76 176.39,64.97 177.83,64.97 184.23,58.57 184.23,54.48 185.08,53.63 185.08,52.88 184.99,52.79 184.87,52.79 v2(184.79,52.88)
  BOTTOM w0.076: UH1.D8 176.13,64.12 v2(176.46,64.45)
  BOTTOM w0.089: 87.56,27.45 87.56,27.44 87.6,27.41 87.6,27.15 86.78,26.33 86.78,25.7 86.7,25.62 86.54,25.62 86.4,25.48 86.4,25.36 86.51,25.24 86.59,25.24 86.63,25.29 UH2.B27
  BOTTOM w0.152: v2(184.79,52.88) 184.9,52.76 184.99,52.67 184.99,52.04 183.9,50.95 179.62,50.95 176.18,47.51 176.18,47.24 176.18,47.24 176.18,45.26 169.89,38.97 120.15,38.97 109.94,28.76 92.9,28.76 91.72,29.94 89.09,29.94 87.56,28.42 87.56,27.45
DMI_CRX_PTX_P1: length 129.7
  IN3 w0.099: v2(175.81,63.66) 175.81,63.48 175.88,63.41 178.4,63.41 183.82,57.98 183.82,54.14 183.19,53.5 183.19,53.27 183.3,53.16 183.49,53.16 183.58,53.07 v2(183.58,52.89)
  BOTTOM w0.076: UH1.E6 175.48,63.37 175.77,63.66 v2(175.81,63.66)
  BOTTOM w0.089: 87.01,27.31 87.01,27.3 86.98,27.27 86.98,27.23 86.45,26.71 86.45,26.32 86.26,26.13 86.26,26.06 86.3,26.01 86.53,26.01 86.59,25.95 86.59,25.87 86.52,25.8 86.3,25.8 UH2.A28
  BOTTOM w0.152: v2(183.58,52.89) 183.4,52.71 183.4,52.12 182.69,51.41 179.38,51.41 175.41,47.45 175.41,45.46 169.67,39.72 120.23,39.72 109.75,29.24 93.17,29.24 91.99,30.43 88.49,30.43 87.01,28.94 87.01,27.31
