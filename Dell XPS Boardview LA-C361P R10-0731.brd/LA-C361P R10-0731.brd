# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GPU_TON: length 3.4
  TOP w0.14: v1(165.1,108.02) 165.1,107.73 v2(164.58,107.21)
  BOTTOM w0.254: PR1010.2 164.22,107.21 v2(164.58,107.21) 165,107.21 165.19,107.4 PU1000.9
GPU_VDD_SENSE: length 5.7
  TOP w0.254: v2(218.9,65.85) 218.71,65.85 v3(218.34,65.48) 217.91,65.05 217.91,61.97 PR1015.1
  BOTTOM w0.254: UV1.L4 v2(218.9,65.85)
GPU_VID: length 3
  BOTTOM w0.254: PR1000.2 165.48,103.8 v3(166.05,104.37) 166.31,104.63 166.38,104.63 166.97,105.22 PU1000.5
GPU_VID_0: length 86.8
  TOP w0.14: v2(165.48,101.61) 165.48,102.02 v1(165.23,102.27)
  IN4 w0.254: v2(217.33,66.68) 215.91,65.26 206.38,65.26 203.47,62.35 196.99,62.35 196.39,62.95 196.39,69 196.99,69.59 196.99,80.41 192.77,84.63 186.88,84.63 184.84,86.67 184.84,87.8 180.87,91.77 180.19,91.77 178.06,93.9 176.4,93.9 175.77,94.54 175.77,99.22 174.46,100.53 172.51,100.53 171.01,102.03 165.9,102.03 v2(165.48,101.61)
  BOTTOM w0.089: UV1.M5 v2(217.33,66.68)
  BOTTOM w0.254: PR1000.1 v2(165.48,101.61)
GPU_VREF: length 5.5
  TOP w0.14: v1(166.49,106.83) 166.17,106.51 v2(164.57,106.51)
  TOP w0.254: PR1002.1 163.94,106.51 v2(164.57,106.51)
  BOTTOM w0.254: PR1002.1 163.94,106.51 v2(164.57,106.51) 164.91,106.51 165.3,106.9 PU1000.8
GPU_VSS_SENSE: length 5.4
  TOP w0.254: v2(218.9,66.65) 218.9,66.65 217.49,65.24 v3(217.49,63.38) 217.49,62.52 PR1012.1
  BOTTOM w0.254: v2(218.9,66.65) 218.5,67.05 UV1.L5
H_CATERR#: length 10.3
  BOTTOM w0.076: 134.62,80.72 135.31,80.72 135.74,81.15 137.02,81.15 137.35,80.82 139.73,80.82 UH1.BM30
  BOTTOM w0.14: 134.62,80.72 133.19,80.72 v3(133.14,80.66) 131.88,80.66 131.43,80.2 131.16,80.2 RH570.2
H_CPUPWRGD: length 98
  TOP w0.14: v2(132.76,81.76) v1(132.26,81.26)
  IN4 w0.091: v2(132.76,81.76) 132.74,81.76 128.56,77.58 128.56,70.58 126.67,68.69 126.67,65.34 123.44,62.11 122.8,62.11 122.46,61.77 122.46,58.58 123.56,57.47 123.56,48.39 109.42,34.25 109.42,27.33 109.77,26.98 109.77,19.86 106.71,16.8 v2(106.71,16.58)
  BOTTOM w0.076: 134.62,81.76 134.86,81.76 135.01,81.91 UH1.BT31
  BOTTOM w0.089: 101.98,10.79 101.93,10.79 101.86,10.72 98.61,10.72 98.37,10.48 UH2.AM3
  BOTTOM w0.14: 134.62,81.76 v2(132.76,81.76) ; 101.98,10.79 103.34,10.79 103.38,10.75 105.38,10.75 108.34,13.71 108.34,14.41 107.03,15.72 107.03,16.26 v2(106.71,16.58)
H_DRAMRST#: length 74.7
  TOP w0.127: v2(140.26,7.31) 140.26,11.21 v1(140.06,11.41) 134.9,16.57 134.9,17.08 134.71,17.27 134.71,18.26 RD31.2
  TOP w0.14: RD35.2 CD69.1 RD31.2
  IN6 w0.089: v2(93.09,2.21) 92.9,2.4 92.9,2.93 92.83,3 92.83,3.49 93.33,3.98 94.22,3.98 94.32,3.89 96.99,3.89 97.22,3.66 97.22,3.25 97.45,3.02 98.71,3.02 99.42,3.73 99.42,5.34 99.98,5.9 101.98,5.9
  IN6 w0.099: v2(140.26,7.31) 139.62,7.95 135.55,7.95 134.81,7.21 134.31,7.21 133.34,7.21 132.91,6.78 129.95,6.78 129.33,7.4 126.68,7.4 125.89,8.19 119.85,8.19 117.19,5.53 109.78,5.53 108.95,4.7 107.31,4.7 106.94,4.33 106.05,4.33 104.39,5.98 102.11,5.98 102.03,5.9 101.98,5.9
  BOTTOM w0.089: v2(93.09,2.21) 92.91,2.39 92.91,2.57 92.91,2.58 92.91,2.72 92.59,3.04 92.59,3.58 92.83,3.81 92.83,4.27 92.93,4.37 92.93,4.85 93.16,5.08 UH2.BC14
H_PECI: length 303.6
  TOP w0.14: v2(284.94,15.58) 284.94,15.57 285.75,16.39 285.75,17.72 284.87,18.6 284.87,19.81 v1(286.66,21.6) 289.02,23.96 290.42,23.96 291.15,24.7 292.63,24.7 RE48.2
  IN4 w0.091: v2(133.41,82.88) 133.16,82.88 128.09,77.8 128.09,70.77 125.66,68.35 125.66,65.28 122.96,62.58 122.6,62.58 121.86,61.83 121.86,56.12 123.08,54.9 123.08,48.95 108.47,34.34 108.47,27.26 109.07,26.67 109.07,20.9 107.84,19.67 107.47,19.67 106.41,20.72 105.43,20.72 105.25,20.55 105.25,20.54 v2(104.91,20.2)
  IN5 w0.099: v2(284.94,15.58) 284.4,15.58 283.16,14.33 276.58,14.33 276.45,14.47 255.52,14.47 251.51,18.48 251.51,20 250.99,20.52 250.34,20.52 249.4,21.46 249.4,24.22 248.06,25.56 223.28,25.56 221.68,27.16 187.44,27.16 187.26,27.33 181.85,27.33 177.8,23.28 177.8,19.71 175.55,17.46 129.65,17.46 129.33,17.14 107.3,17.14 106.71,17.73 105.92,17.73 104.37,19.27 104.37,19.74 104.82,20.2 v2(104.91,20.2)
  BOTTOM w0.14: RH539.2 104.13,11.91 104.34,12.12 105.17,12.12 105.89,12.84 105.89,15.68 105.82,15.74 105.82,17.4 105.21,18.01 105.21,19.89 v2(104.91,20.2) ; v2(133.41,82.88) 132.94,83.35 RH190.1
H_PECI_R: length 3.9
  BOTTOM w0.14: UH1.BT34 137.2,83.18 v3(135.37,83.18) 134.25,83.18 RH190.2
H_PM_DOWN: length 91.1
  TOP w0.14: v2(103.84,20.68) 103.84,20.6 v1(104.22,20.21)
  IN4 w0.091: v2(129.52,83.1) 129.15,82.73 129.15,81.79 126.11,78.75 126.11,71.24 122.82,67.95 122.82,66.24 119.91,63.33 119.91,57.9 119.49,57.49 119.49,52.78 118.47,51.76 118.47,45.49 106.81,33.82 106.81,30.11 105.46,28.76 103.94,28.76 103.27,28.1 103.27,24.39 103.71,23.95 104.71,23.95 104.94,23.72 104.94,23.04 103.46,21.55 103.46,21.07 v2(103.84,20.68)
  BOTTOM w0.089: 101.98,13.34 101.64,13.34 101.14,12.85 101.14,12.39 100.57,11.82 99.73,11.82 99.53,12.02 99.2,12.02 UH2.AH2
  BOTTOM w0.127: 101.98,13.34 103.58,13.34 104.25,14.01 104.25,15.42 104.06,15.6 104.06,17.15 103.79,17.43 103.79,18.92 103.79,20.49 103.84,20.54 v2(103.84,20.68)
  BOTTOM w0.14: v2(129.52,83.1) 129.98,83.1 RH155.1
H_PM_DOWN_R: length 8.2
  BOTTOM w0.076: 134.62,82.2 135.78,82.2 135.85,82.14 136.93,82.14 136.98,82.19 137.94,82.19 137.98,82.23 138.46,82.23 UH1.BP31
  BOTTOM w0.14: 134.62,82.2 v3(134.04,82.2) 131.8,82.2 RH155.2
H_PM_SYNC_R: length 93.1
  TOP w0.089: v2(136.14,83.57) v1(135.57,83)
  IN2 w0.089: v2(136.14,83.57) 139.36,83.57 v2(139.73,83.93)
  IN4 w0.091: v2(103.87,21.27) 103.87,21.7 105.29,23.11 105.65,23.11 106.22,23.68 106.23,23.68 106.9,24.36 106.9,29.22 107.19,29.5 107.19,33.93 119.7,46.44 119.7,57.4 120.1,57.81 120.1,62.3 122.14,64.34 122.14,65.28 123.02,66.16 123.02,67.87 126.43,71.28 126.43,78.7 130.12,82.39 130.12,83.17 v2(131.67,84.73)
  BOTTOM w0.076: UH1.BM34 140.05,83.6 v2(139.73,83.93)
  BOTTOM w0.127: v2(103.87,21.27) 104.33,20.81 104.33,20.58 104.01,20.27 104.01,17.94 104.93,17.03 104.93,15.9 104.48,15.45 104.48,14.67 RH189.2
  BOTTOM w0.14: v2(136.14,83.57) 135.59,84.12 132.28,84.12 v2(131.67,84.73)
H_PROCHOT#: length 367.1
  TOP w0.14: v2(62.74,18.97) 62.4,18.64 62.4,17.44 61.23,16.26 60.52,16.26 PR315.1 ; RE96.2 295.78,25.31 296.36,25.89 v2(296.36,26.71) ; v2(120.93,51.66) 119.9,51.66 v1(119.89,51.67)
  IN3 w0.091: v2(119.97,108.97) 120.24,109.25 122.37,109.25 122.95,108.67 122.95,104.87 129.78,98.04 v2(129.78,97.82) ; v2(296.36,26.71) 296.2,26.87 292.61,26.87 291.04,25.31 289.29,25.31 288.01,24.03 281.31,24.03 279.81,22.53 277.45,22.53 276.93,22.01 270.26,22.01 268.62,20.37 260.77,20.37 260.5,20.64 257.36,20.64 256.59,21.4 255.7,21.4 252.49,18.19 231.77,18.19 231.21,17.63 230.07,17.63 229.54,17.11 229.54,16.66 229.24,16.35 222.53,16.35 221.98,15.8 221.98,15.51 221.71,15.24 219.11,15.24 218.37,15.98 179.37,15.98 179.1,15.71 168.54,15.71 167.81,16.43 167.81,26.28 163.96,30.14 160.93,30.14 143.93,47.14 v2(129.96,47.14)
  IN4 w0.091: v2(120.93,51.66) 120.74,51.66 120.45,51.95 120.45,54.58 120.99,55.12 120.99,62.22 122.8,64.04 122.8,65 124.79,66.99 124.79,68.71 127.13,71.04 127.13,78.25 v2(129.51,80.64) 130.93,82.06 130.93,82.5 132.66,84.23 132.66,87.67 129.12,91.2 129.12,97.54 129.4,97.82 v2(129.78,97.82)
  IN5 w0.089: 101.98,26.15 101.6,25.76 100.61,25.76 99.64,24.79 99.64,23.2 97.41,20.98 96.48,20.98 95.63,20.13 93.49,20.13 93.26,19.9 92.69,19.9 92.62,19.96 91.7,19.96 91.25,19.52 91.25,18.75 90.95,18.45 84.81,18.45 83.88,17.52 83.44,17.52 83.2,17.28 82.68,17.28 82.44,17.52 80.47,17.52 80.32,17.36 80.32,17.03 80.06,16.77 78.61,16.77 77.51,17.88 75.06,17.88
  IN5 w0.099: 75.06,17.88 74.28,17.88 73.69,17.28 66.92,17.28 65.96,18.25 63.47,18.25 v2(62.74,18.97) ; v2(120.93,51.66) 118.4,49.13 118.4,43.19 105.08,29.86 103.82,29.86 102.02,28.06 102.02,26.18 101.98,26.15
  BOTTOM w0.14: v2(129.51,80.64) 129.72,80.84 RH158.1 130.15,80.08 RH165.2 ; PR1103.1 119.81,108.82 v2(119.97,108.97) ; v2(129.96,47.14) 126.12,47.14 121.99,51.26 121.33,51.26 v2(120.93,51.66)
H_PROCHOT#_EC: length 2.7
  TOP w0.14: RE96.1 295.78,22.37 v3(296.27,21.88) UE3.A46
H_PROCHOT#_R: length 7.4
  BOTTOM w0.076: 134.62,81.05 135.13,81.05 v3(135.4,81.31) 135.51,81.43 137.62,81.43 137.9,81.15 UH1.BR30
  BOTTOM w0.14: RH158.2 131.26,81.05 134.62,81.05
H_THERMTRIP#: length 7
  BOTTOM w0.089: 101.98,13.93 101.56,13.93 100.91,13.29 v3(100.91,13.11) 100.91,12.48 100.42,12 99.81,12 99.6,12.2 99.38,12.2 99.07,12.51 98.78,12.51 UH2.AJ3
  BOTTOM w0.14: 101.98,13.93 103.33,13.93 RH191.1
H_THERMTRIP#_R: length 332
  TOP w0.14: QE10.3 309.64,20.09 v2(309.39,20.34)
  TOP w0.254: v2(172.7,82.15) 172.7,82.11 RH163.2
  IN3 w0.091: v2(174.56,19.82) 174.56,19.3 176.19,17.67 222.78,17.67 223.01,17.89 228.88,17.89 229.64,18.65 230.79,18.65 231.34,19.21 252.06,19.21 255.28,22.42 257.62,22.42 258.49,23.3 259.28,23.3 261.19,21.39 265.92,21.39 267.56,23.03 276.51,23.03 277.02,23.55 279.38,23.55 281.74,25.9 288.44,25.9 288.9,26.36 290.65,26.36 292.04,27.75 292.04,31.29 293.46,32.71 296.97,32.71 297.61,33.36 298.43,33.36 299.09,32.7 299.09,31.86 300.8,30.15 303.02,30.15 304.03,29.14 305.37,29.14 306.92,30.69 311.93,30.69 v2(312.76,29.85)
  IN6 w0.089: 181.1,66.13 180.71,66.13 178.2,68.63 178.2,79.92 177.54,80.58 172.89,80.58 172.7,80.78 v2(172.7,82.15)
  IN6 w0.099: 181.1,66.13 184.44,66.13 185.81,64.75 188.79,64.75 189.47,64.07 189.47,62.2 192.13,59.54 192.13,44.71 179.45,32.02 178.23,30.8 178.23,26.76 176.67,25.21 176.67,24.44 176.96,24.15 176.96,22.86 176.11,22.01 176.11,20.91 175.02,19.82 v2(174.56,19.82) 174.13,19.39 151.07,19.39 150.53,18.86 130.56,18.86 129.97,19.45 107.34,19.45 106.96,19.82 106.96,20.3 106.42,20.84 105.94,20.84 104.55,22.23 v2(103.57,22.23)
  BOTTOM w0.076: UH1.J31 173.03,81.81 v2(172.7,82.15)
  BOTTOM w0.14: v2(103.57,22.23) 103.57,21.75 103.28,21.46 103.28,20.89 103.19,20.81 103.19,15.64 RH191.2 ; v2(312.76,29.85) 312.01,29.1 312.01,26.22 309.17,23.38 309.17,22.58 309.6,22.14 309.6,20.56 v2(309.39,20.34)
H_VCCST_PWRGD: length 125.5
  TOP w0.089: 181.1,65.68 RH164.2
  TOP w0.127: RH154.1 178.84,66.59 RH164.2
  TOP w0.14: v2(131.47,89.72) 131.14,90.05 RH482.1 ; 181.1,65.68 181.92,65.68 183.05,64.55 v2(183.05,63.73) ; v2(122.93,61.44) 122.94,61.44 RZ82.2 122.86,60.46 UZ19.4 121.92,61 v1(121.43,61.49)
  IN4 w0.091: v2(131.47,89.72) 131.47,90.58 131.65,90.76 131.99,90.76 133.32,89.43 133.32,85.16 133.81,84.67 133.81,82.13 130.73,79.06 130.73,77.7 129.03,76 129.03,70.29 127.15,68.4 127.15,65.14 123.45,61.44 v2(122.93,61.44) ; 180.82,89.61 v2(178.8,89.61)
  IN4 w0.102: v2(183.05,63.73) 182.61,64.18 182.61,80.19 181.62,81.17 181.62,88.81 180.82,89.61
  IN6 w0.099: v2(178.8,89.61) 176.48,89.61 175.91,90.18 171.17,90.18 170.34,91 157.48,91 156.85,91.64 132.75,91.64 131.47,90.36 v2(131.47,89.72)
H_VCCST_PWRGD_EC: length 267.4
  TOP w0.14: RZ84.2 119.59,59.58 UZ19.1 121.68,59.62 RZ82.1 123.43,59.13 123.43,57.55 123.23,57.35 123.23,56.78 122.48,56.03 122.48,55.33 122.13,54.98 121.75,54.98 121.64,55.09 119.9,55.09 119.38,54.58 119.38,51.31 119.7,51 119.7,50.55 118.75,49.6 v1(118.75,48.14) 118.75,40.49 107.73,29.47 107.73,25.44 107.99,25.18 107.99,21.6 108.11,21.47 108.11,20.07 109.4,18.79 114.17,18.79 116.02,16.94 116.02,14.41 v2(116.37,14.07) ; v2(297.42,21.65) 297.27,21.5 UE3.A44
  IN5 w0.099: v2(116.37,14.07) 116.37,14.09 116.89,14.61 121.44,14.61 121.85,14.2 128.21,14.2 128.53,14.52 168.88,14.52 168.97,14.61 174.91,14.61 179.26,18.97 179.26,22.54 182.65,25.92 186.68,25.92 186.86,25.74 217.99,25.74 219.22,24.52 219.22,20.05 221.4,17.87 246.21,17.87 251.44,12.64 256.93,12.64 257.34,12.23 v2(257.35,12.23)
  IN6 w0.099: v2(297.42,21.65) 297.38,21.61 294.08,21.61 292.67,20.2 290.43,20.2 289.8,20.83 285.08,20.83 284.32,20.07 283,20.07 282.29,19.37 281.41,19.37 279.76,17.72 278.23,17.72 276.97,16.46 269.54,16.46 266.11,13.04 257.62,13.04 257.35,12.77 v2(257.35,12.23)
HDA_BITCLK: length 55.8
  TOP w0.089: 101.98,3.89 101.08,3.89 100.78,4.18 v2(100.78,4.5)
  TOP w0.14: v2(65.12,8.53) 65.12,8.28 RP15.8 ; 101.98,3.89 v1(103.38,3.89)
  IN1 w0.076: 75.06,6.65 75.41,6.65 75.62,6.44 77.01,6.44 79.1,4.35 97.13,4.35 97.59,3.9 97.59,3.36 97.77,3.18 99.37,3.18 100.69,4.5 v2(100.78,4.5)
  IN1 w0.099: 75.06,6.65 72.34,6.65 71.13,7.85 70.37,7.85 70.02,8.2 68.24,8.2 68.1,8.06 65.59,8.06 v2(65.12,8.53)
  BOTTOM w0.089: 101.98,4.12 101.17,4.12 v2(100.78,4.5) ; 97.3,1.69 96.95,1.69 96.7,1.94 96.7,2.19 96.01,2.88 96.01,3.87 95.77,4.11 95.77,4.31 95.67,4.41 95.67,5.5 95.61,5.57 UH2.BA9
  BOTTOM w0.14: 101.98,4.12 102.36,4.12 CH50.2 102.33,3.74 100.47,3.74 98.41,1.69 97.3,1.69
HDA_BITCLK_AUDIO: length 83.6
  TOP w0.14: v2(6.76,18.39) 6.76,18.85 7.2,19.29 JAUDIO.9 ; v2(65.76,15.66) 65.76,15.06 64.81,14.11 64.56,14.11 v1(64.28,13.83) 64.28,9.71 64.54,9.45 64.54,8.28 RP15.1
  IN6 w0.099: v2(65.76,15.66) 66.19,16.09 66.19,18.03 65.69,18.54 63.68,18.54 63.01,17.86 60.28,17.86 59.87,18.27 59.87,21.63 59.08,22.42 57.96,22.42 55.8,24.58 53.6,24.58 53.34,24.32 49.99,24.32 49.15,25.16 46.29,25.16 45.53,25.91 44.07,25.91 41.83,28.15 40.64,28.15 40.28,27.8 34.33,27.8 33.81,27.28 32.26,27.28 31.72,26.74 24.29,26.74 23.31,25.75 21.22,25.75 20.52,25.05 19.48,25.05 17.06,22.63 13.32,22.63 11.48,20.79 10.34,20.79 8.89,19.34 7.34,19.34 6.76,18.76 v2(6.76,18.39)
HDA_RST#: length 38.4
  TOP w0.14: RP15.6 v2(66.1,7)
  IN1 w0.076: v2(97.08,2.09) 97.08,2.03 96.46,1.41 90.26,1.41 89.8,1.86 89.8,3.77 89.57,4.01 78.35,4.01 78.25,4.11 77.88,4.11 77.55,4.44 76.08,4.44 75.54,4.98 75.54,5.09 75.26,5.38 75.15,5.38 75.06,5.46
  IN1 w0.099: v2(66.1,7) 66.58,6.51 67.85,6.51 68.55,5.8 74.72,5.8 75.06,5.46
  BOTTOM w0.089: UH2.BD8 96.06,4.38 96.06,4.11 96.23,3.94 96.23,2.94 v2(97.08,2.09)
HDA_RST#_AUDIO: length 77.8
  TOP w0.14: v2(9.21,17.39) 9.45,17.63 9.45,18.47 8.8,19.11 JAUDIO.13 ; v2(64.59,15.79) 64.59,15.77 63.26,14.44 v1(63.26,11.91) 63.26,9.5 62.73,8.97 62.73,7.94 63.68,7 RP15.3
  IN6 w0.099: v2(64.59,15.79) 60.67,15.79 58.66,17.8 58.66,18.65 57.67,19.64 57.67,19.87 56.71,20.84 56.46,20.84 54.51,22.79 50.51,22.79 50.42,22.88 48.76,22.88 48.55,23.09 44.45,23.09 41.24,26.3 40.49,26.3 39.33,25.15 36.76,25.15 30.96,25.15 30.56,25.55 24.79,25.55 23.8,24.56 22.33,24.56 21.3,23.54 20.1,23.54 16.03,19.46 12.77,19.46 11.7,18.39 10.21,18.39 9.46,17.64 9.46,17.64 v2(9.21,17.39)
HDA_SDIN0: length 18
  TOP w0.14: RH96.2 108.64,3.44 108.43,3.23 v2(108.43,3.02) 108.43,2.9 v1(109.06,2.27)
  IN1 w0.076: v2(96.81,2.93) 97.08,2.93 97.44,2.57 99.48,2.57 100.7,3.79 101.68,3.79 101.98,4.1
  IN1 w0.099: 101.98,4.1 102.36,4.1 102.54,4.28 105.36,4.28 106.5,5.42 106.99,5.42 107.57,4.83 108.05,4.83 108.43,4.45 108.43,3.03 v2(108.43,3.02)
  BOTTOM w0.089: v2(96.81,2.93) 96.8,2.93 96.41,3.32 UH2.BE7
HDA_SDIN0_AUDIO: length 134.6
  TOP w0.127: v2(110.62,3.72) 110.21,3.72 RH96.1
  TOP w0.14: v1(110.61,1.49) 109.93,2.17 RH96.1 ; v2(10.38,17.69) 10.38,18.44 9.6,19.21 JAUDIO.15
  IN2 w0.099: v2(63.27,8.06) 60.85,8.06 60.45,8.47 60.03,8.47 59.75,8.74 59.75,11 60.44,11.69 60.44,18.52 59.77,19.19 59.77,20.21 59.33,20.65 58.94,20.65 54.38,25.21 52.8,25.21 51.97,26.03 50.44,26.03 50.27,25.86 47.4,25.86 45.03,28.24 42.77,28.24 42.08,28.93 39.18,28.93 38.01,30.11 34.05,30.11 33.27,29.32 29.24,29.32 27.63,27.72 27.63,27.06 25.86,25.28 25.36,25.28 23.77,23.7 22.6,23.7 22.21,23.3 20.51,23.3 18.1,20.89 18.1,18.86 17.29,18.05 12,18.05 11.75,18.3 10.67,18.3 10.38,18 v2(10.38,17.69)
  IN5 w0.089: 101.98,4.71 101.77,4.92 99.01,4.92 98.89,5.05 97.5,5.05 97.29,4.84 96.03,4.84 95.26,5.61 93.84,5.61 93.66,5.79 93.66,5.91 93.21,6.37 90.67,6.37 90.36,6.68 90.36,7.06 90.05,7.37 89.2,7.37 88.26,6.43 87.08,6.43 87.02,6.37 85.54,6.37 85.12,5.95 84.57,5.95 84.06,5.44 83.6,5.44 83.15,5.88 82.27,5.88 81.66,6.49 79.66,6.49 79.15,7.01 79.15,7.18 78.91,7.41 78.61,7.41 77.95,6.74 76.15,6.74 75.06,7.84 75.06,8.01
  IN5 w0.099: 101.98,4.71 106.48,4.71 106.69,4.49 107.03,4.49 107.24,4.71 107.89,4.71 108.2,4.41 109.93,4.41 v2(110.62,3.72) ; v2(63.27,8.06) 67.82,8.06 67.92,8.16 71.48,8.16 71.78,8.46 72.93,8.46 73.38,8.01 75.06,8.01
HDA_SDOUT: length 68.7
  TOP w0.089: CH51.2 97.28,6.21 v2(96.69,6.8)
  TOP w0.14: v2(116,8.35) 115.51,8.35 v1(115.22,8.07) 114.86,7.71 RH454.2 ; RP15.5 66.2,6.5 v2(66.72,7.02)
  IN1 w0.076: 75.06,7.83 76.23,6.66 77.85,6.66 78.01,6.5 78.01,6.49 79.98,4.52 94.42,4.52 96.69,6.78 v2(96.69,6.8)
  IN1 w0.099: 75.06,7.83 74.69,8.2 70.52,8.2 70.08,8.64 68.1,8.64 67.69,9.05 66.51,9.05 66.49,9.03 66.15,9.03 66.13,9.05 65.05,9.05 64.72,8.72 64.72,8.36 65.44,7.63 66.1,7.63 v2(66.72,7.02)
  IN3 w0.089: 101.98,4.92 99.87,4.92 98.79,5.99 98.79,7.27 98.56,7.51 97.04,7.51 96.69,7.16 v2(96.69,6.8)
  IN3 w0.091: 101.98,4.92 101.98,4.92 104.84,4.92 106.28,6.36 114.66,6.36 116,7.7 v2(116,8.35)
  BOTTOM w0.089: UH2.BB7 96.34,6.45 v2(96.69,6.8)
HDA_SDOUT_AUDIO: length 78.6
  TOP w0.14: RP15.4 63.62,6.5 62.34,7.78 62.34,9.16 62.87,9.69 62.87,11.74 62.86,11.74 62.86,12.07 62.87,12.08 62.87,14.69 64.64,16.47 v1(64.64,16.81) v2(64.64,17.59) ; JAUDIO.17 10.4,19.16 10.63,18.93 v2(10.92,18.93)
  IN6 w0.099: v2(10.92,18.93) 10.92,19.34 11.4,19.82 15.88,19.82 19.96,23.89 21.16,23.89 22.18,24.92 23.65,24.92 24.64,25.9 30.71,25.9 31.11,25.5 34.47,25.5 35.09,26.12 37.17,26.12 37.53,26.47 40.16,26.47 40.34,26.66 41.38,26.66 43.72,24.32 48.8,24.32 49.64,23.48 51.73,23.48 52.07,23.15 54.35,23.15 54.68,23.48 55.72,23.48 58.02,21.18 58.02,19.79 59.02,18.8 59.02,17.94 60.81,16.15 62.47,16.15 63.91,17.59 v2(64.64,17.59)
HDA_SYNC: length 38
  TOP w0.14: RP15.7 65.91,7.5 66.13,7.72 v3(66.76,7.72) 66.99,7.49 67.03,7.49 v2(67.42,7.1)
  IN1 w0.076: v2(96.31,2.07) 95.81,1.57 90.33,1.57 89.97,1.93 89.97,3.84 89.63,4.18 78.42,4.18 77.84,4.76 76.86,4.76 76.29,5.33 76.02,5.33 75.06,6.3
  IN1 w0.099: 75.06,6.3 72.19,6.3 71.18,7.3 67.63,7.3 v2(67.42,7.1)
  BOTTOM w0.089: UH2.BD9 95.44,4.4 95.59,4.24 95.59,3.89 95.8,3.68 95.8,2.71 96.31,2.21 v2(96.31,2.07)
HDA_SYNC_AUDIO: length 81.3
  TOP w0.14: v2(65.21,17.82) 65.21,17.23 65.1,17.13 65.1,15.55 64.58,15.03 64.42,15.03 63.76,14.38 v1(63.76,10.13) 63.76,9.31 63.61,9.16 63.61,8.33 63.73,8.21 63.73,7.65 63.88,7.5 RP15.2 ; JAUDIO.11 8,19.21 8.95,18.27 v2(8.95,18.04)
  IN6 w0.099: v2(65.21,17.82) 64.97,18.06 63.88,18.06 62.33,16.5 60.96,16.5 59.37,18.09 59.37,18.94 58.38,19.94 58.38,21.32 55.86,23.84 54.53,23.84 54.2,23.51 52.21,23.51 51.88,23.84 49.79,23.84 48.95,24.68 46.09,24.68 45.33,25.43 43.11,25.43 41.53,27.01 40.2,27.01 40.02,26.83 37.38,26.83 37.03,26.47 34.95,26.47 34.33,25.85 33.91,25.85 32.97,26.8 32.66,26.8 32.12,26.26 24.49,26.26 23.51,25.27 22.03,25.27 21.01,24.25 19.81,24.25 15.73,20.17 11.15,20.17 9.76,18.78 9.69,18.78 v2(8.95,18.04)
HDD_DET#: length 180.4
  TOP w0.089: v2(80.68,12.68) 80.14,12.14 v3(79.97,12.14) 76.47,12.14 RH513.1
  IN5 w0.089: v2(80.68,12.68) 81.1,12.27 84.85,12.27 85.33,12.76 90.48,12.76 92.19,14.47 95.65,14.47 96.86,13.26 100.64,13.26 101.05,13.68 101.98,13.68
  IN5 w0.099: v2(236.17,11.77) 231.55,11.77 226.98,16.34 221.3,16.34 218.62,19.02 218.62,24.26 217.75,25.12 186.63,25.12 186.43,25.32 182.9,25.32 180.32,22.74 180.32,19.17 174.57,13.42 124.11,13.42 123.96,13.26 115.37,13.26 115.17,13.46 106.49,13.46 106.28,13.68 101.98,13.68
  BOTTOM w0.089: UH2.AG39 80.34,13.02 v2(80.68,12.68)
  BOTTOM w0.14: v2(236.17,11.77) 236.86,11.08 JHDD.12
HDMI_CEC: length 3.5
  BOTTOM w0.127: CV182.2 13.72,86.83 v3(12.74,86.83) 12.64,86.73 12.64,85.75 12.32,85.43 JHDMI1.13
HDMI_HPLUG: length 8.3
  BOTTOM w0.127: JHDMI1.19 12.48,88.91 CV180.2 14.02,89.66 v3(14.36,90) 14.57,90.2 15.36,90.2 15.8,89.76 RV123.1
  BOTTOM w0.14: RV123.1 16.84,90.03 QV14.1
HDMI_RESERVED: length 7
  IN2 w0.099: JHDMI1.14 11.15,86.51 11.15,88.6 11.57,89.02 12.4,89.02 v2(13.4,88.02)
  BOTTOM w0.127: v2(13.4,88.02) CV181.2
  BOTTOM w0.14: v2(13.4,88.02) 12.98,88.44 v3(12.98,88.49)
HOST_DEBUG_TX: length 24.4
  TOP w0.14: RE64.2 307.02,29.03 v2(306.67,29.38) 306.26,29.38 v1(305.5,28.62) ; UE3.B44 v2(298.52,19.08)
  IN4 w0.091: v2(298.52,19.08) 298.52,19.94 296.93,21.54 296.93,22.42 297.95,23.45 297.95,26.27 301.41,29.73 301.89,29.73 302.66,28.95 306.23,28.95 v2(306.67,29.38)
  BOTTOM w0.14: v2(306.67,29.38) 306.67,29.79 307.61,30.74 JDEG1.8
HOST_SD_WP#: length 301.1
  TOP w0.089: RH563.2 76.44,8.49 77.19,8.49 77.65,8.04 v2(77.65,7.65)
  IN1 w0.099: v2(329.57,42.67) 329.57,40.24 331.79,38.01 331.79,34.43 328.16,30.79 326.99,30.79 326.4,30.2 326.4,26.8 325.54,25.95 325.54,23.59 323.44,21.49 321.93,21.49 320.76,20.32 320.76,13.68 317.87,10.79 v2(316.13,10.79)
  IN5 w0.089: 101.98,11.73 101.2,10.95 98.05,10.95 97.62,11.37 95.5,11.37 94.94,10.81 92.65,10.81 90.94,9.1 89.79,9.1 89.05,8.36 87.14,8.36 86.77,7.99 86.77,7.19 86.32,6.73 86.02,6.73 85.42,7.33 85.42,7.95 85.02,8.35 84.42,8.35 84.07,8.7 82.13,8.7 81.92,8.48 81.92,8.4 81.45,7.93 79.22,7.93 79.21,7.94 77.94,7.94 v2(77.65,7.65)
  IN5 w0.099: v2(316.13,10.79) 315.58,10.23 309.59,10.23 306.32,6.96 301.05,6.96 300.86,7.14 297.75,7.14 297,7.89 297,8.62 294.52,11.11 293.32,11.11 292.26,10.04 291.74,10.04 290.29,8.59 283.89,8.59 281.55,10.93 271.04,10.93 270.73,10.62 269.15,10.62 268.74,10.2 265.75,10.2 264.28,11.67 262.3,11.67 261.5,10.88 252.35,10.88 251.97,11.26 230.66,11.26 229.57,12.35 224.94,12.35 224.85,12.26 215.45,12.26 214.59,11.4 214.41,11.22 186.67,11.22 184.92,9.48 177.12,9.48 175.38,11.22 163.82,11.22 163.02,10.42 159.58,10.42 158.34,11.66 150.43,11.66 149.48,10.7 147.65,10.7 146.7,11.66 114.54,11.66 113.9,11.02 108.33,11.02 107.5,11.86 105.83,11.86 105.75,11.94 102.19,11.94 101.98,11.73
  BOTTOM w0.089: UH2.AU44 78.29,8.01 78.08,7.81 77.8,7.81 v2(77.65,7.65)
  BOTTOM w0.14: QR1.2 v2(329.57,42.67)
I2C0_SCK: length 11.4
  TOP w0.089: v2(81.35,8.35) 81.35,8.5 v3(81.08,8.77)
  TOP w0.14: v2(73.86,8.82) 73.86,8.85 73.74,8.72 72.9,8.72 RH424.2
  IN5 w0.089: v2(81.35,8.35) 80.9,8.8 75.06,8.8
  IN5 w0.099: v2(73.86,8.82) 73.99,8.7 74.96,8.7 75.06,8.8
  BOTTOM w0.089: UH2.AR38 81.12,8.58 v2(81.35,8.35)
  BOTTOM w0.14: v2(73.86,8.82) 73.53,8.49 73,8.49 RH521.2
I2C0_SCK_DSP: length 86.8
  TOP w0.127: JAUDIO.21 12,20.54 12.25,20.79 12.96,20.79 v2(13.36,21.19)
  TOP w0.14: v3(14.69,21.74) 13.91,21.74 v2(13.36,21.19)
  IN2 w0.099: v2(70.71,9.56) 70.73,9.57 70.73,10.31 70.05,10.98 70.05,16.34 70.76,17.05 70.76,17.91 68.43,20.24 68.43,21.05 v2(68.15,21.32) 68.15,22.38 67.44,23.1 66.31,23.1 65.2,24.2 60.06,24.2 55.77,28.49 47.8,28.49 45.56,30.73 35.82,30.73 35.21,31.35 34.01,31.35 33.22,30.56 31.46,30.56 31.03,30.13 28.23,30.13 26.12,28.02 26.12,26.89 23.52,24.3 22.35,24.3 21.96,23.9 20.23,23.9 16.74,20.41 13.92,20.41 13.36,20.96 v2(13.36,21.19)
  BOTTOM w0.127: v2(70.71,9.56) 70.95,9.32 71.28,9.32 71.87,8.72 RH521.1
  BOTTOM w0.14: v2(68.15,21.32) 68.15,21.32 67.37,21.32 66.98,20.94 RE136.2 66.98,19.56 QE18.4
I2C0_SDA: length 8
  TOP w0.14: RH425.2 73.06,9.72 73.39,9.39 v2(73.39,9.19)
  BOTTOM w0.089: UH2.AT42 78.95,8.62 78.74,8.83 78.07,8.83 77.96,8.72 76.1,8.72 v3(75.69,9.13) 75.41,9.41 75.19,9.41
  BOTTOM w0.127: 75.19,9.41 75.06,9.53 73.74,9.53 v2(73.39,9.19) 73.19,9.19 RH522.2
I2C0_SDA_DSP: length 85.8
  TOP w0.14: JAUDIO.19 11.2,21.29 11.66,21.75 v1(11.81,21.75) 12.19,21.75 v2(12.73,21.22)
  IN2 w0.099: v2(12.73,21.22) 13.54,22.03 16.36,22.03 17.22,22.9 18.95,22.9 20.15,24.1 21.87,24.1 22.27,24.5 23.44,24.5 25.92,26.98 25.92,28.1 28.15,30.33 30.95,30.33 31.37,30.76 33.14,30.76 33.93,31.55 35.34,31.55 35.95,30.94 45.64,30.94 47.88,28.69 55.85,28.69 60.12,24.43 65.26,24.43 66.4,23.3 67.52,23.3 68.63,22.19 68.63,20.33 70.99,17.96 70.99,16.55 v2(70.53,16.09) 70.53,13.09 70.91,12.71 70.91,11.15 71.26,10.79 v2(71.26,9.76)
  BOTTOM w0.127: RH522.1 71.43,9.6 v2(71.26,9.76)
  BOTTOM w0.14: QE18.1 68.34,16.96 RE137.2 69.12,16.65 69.68,16.09 v2(70.53,16.09)
I2C1_SCK_TP: length 174.6
  TOP w0.14: v1(67.11,17.33) 67.11,16.53 67.74,15.89 RH119.2 67.74,14.17 67.93,13.98 68.08,13.98 68.72,13.34 v2(68.72,13.08) ; QE2.3 227.92,11.79 227.95,11.76 v2(227.95,11.72)
  IN5 w0.089: 75.06,9.71 79.08,9.71 79.36,9.43 v2(80.13,9.43)
  IN5 w0.099: 75.06,9.71 72.08,9.71 71.32,8.95 69.69,8.95 68.89,9.76 68.89,12.92 v2(68.72,13.08)
  IN6 w0.089: v2(80.13,9.43) 80.51,9.81 80.92,9.81 81.09,9.98 82.65,9.98 83.18,10.51 85.03,10.51 86.12,11.6 91.45,11.6 91.64,11.79 95.36,11.79 95.5,11.93 98.77,11.93 99.16,11.54 101.78,11.54 101.98,11.74
  IN6 w0.099: 101.98,11.74 102.3,12.06 107.29,12.06 107.96,11.38 112.67,11.38 113.34,12.06 125.77,12.06 126.22,12.5 159.14,12.5 159.98,11.66 169.33,11.66 169.52,11.85 176.91,11.85 177.11,12.05 186.54,12.05 187.13,12.64 200.13,12.64 200.58,12.19 215.19,12.19 215.35,12.03 223.75,12.03 224.79,10.99 227.52,10.99 227.95,11.43 v2(227.95,11.72)
  BOTTOM w0.089: UH2.AR41 79.86,8.86 80.13,9.13 v2(80.13,9.43)
I2C1_SCK_TP_C: length 18.5
  TOP w0.14: QE19.3 224.93,12.8 224.79,12.65 223.18,12.65 221.98,13.85 RE9.1 221.18,14.87 v1(221.08,14.98) 220.93,15.12 217.5,15.12 217.17,15.45 215.7,15.45 215.33,15.08 215.33,14.47 215.81,13.99 216.11,13.99 216.41,14.28 DE5.3 217.88,14.72 218.12,14.47 v2(218.12,14.04)
  BOTTOM w0.14: CE79.1 218.25,14.17 v2(218.12,14.04) 218.38,13.79 218.38,13.2 218.4,13.17 JTP.6
I2C1_SDA_TP: length 169.6
  TOP w0.14: QE2.6 226.25,14.93 225.93,14.61 225.49,14.61 225.11,14.23 225.11,13.85 227.24,11.72 v2(227.37,11.72)
  IN6 w0.089: v2(76.63,9.33) 77.14,9.84 79.6,9.84 79.76,10 80.85,10 81.1,10.25 81.1,10.63 81.29,10.82 82.52,10.82 82.65,10.69 84.95,10.69 86.11,11.85 91.37,11.85 91.5,11.97 95.29,11.97 95.44,12.12 98.88,12.12 99.29,11.72 101.67,11.72 101.98,12.03
  IN6 w0.099: 101.98,12.03 102.21,12.26 107.37,12.26 108.05,11.58 112.58,11.58 113.26,12.26 125.69,12.26 126.14,12.7 159.22,12.7 160.06,11.86 169.25,11.86 169.43,12.05 176.82,12.05 177.02,12.25 186.45,12.25 187.05,12.84 200.22,12.84 200.67,12.39 215.27,12.39 215.44,12.23 223.84,12.23 224.86,11.21 227.26,11.21 227.37,11.32 v2(227.37,11.72)
  BOTTOM w0.089: UH2.AR44 78.15,9.16 77.89,8.9 77.06,8.9 v2(76.63,9.33) 76.43,9.33 76.06,9.7 75.22,9.7
  BOTTOM w0.127: RH120.2 70.14,10.66 70.59,10.22 70.61,10.19 71.49,10.19 71.54,10.14 73.14,10.14 73.52,9.76 75.15,9.76 75.22,9.7
I2C1_SDA_TP_C: length 37.9
  TOP w0.14: v2(226.47,11.8) 226.47,12.1 226.06,12.51 225.01,12.51 224.73,12.23 RE7.1 ; v2(227.81,16.87) 227.81,15.93 227.57,15.69 226.46,15.69 226.26,15.88 223.9,15.88 223.63,15.61 QE19.6 223.57,14.99 221.62,14.99 221.48,15.14 221.48,15.14 220.71,15.91 v1(219.51,15.91) 219.1,15.5 217.65,15.5 217.43,15.73 215.55,15.73 215.06,15.25 215.06,14.36 215.53,13.89 215.53,13.31 216.05,12.79 DE5.2 216.41,13.31 217.14,14.04 v2(217.49,14.04)
  BOTTOM w0.14: v2(226.47,11.8) 226.81,12.15 230.38,12.15 230.94,12.71 230.94,15.2 230.23,15.91 228.77,15.91 v2(227.81,16.87) ; JTP.7 217.4,13.96 v2(217.49,14.04) 217.3,14.23 CE80.1
I2C_EN8723: length 3.5
  BOTTOM w0.14: UI3.24 318.41,29.57 RI25.1 316.89,28.66 v3(316.27,28.04)
I2CA_SCL: length 7.5
  TOP w0.089: v2(213.14,67.51) 212.79,67.16 RPH15.1 ; RPH13.1 216.08,65.2 215.56,65.71 v2(215.56,65.89) 215.56,66 215.81,66.24 v3(216.16,66.24)
  IN1 w0.076: v2(213.14,67.51) 213.14,66.74 213.99,65.89 v2(215.56,65.89)
  BOTTOM w0.089: UV1.R4 v2(215.56,65.89)
I2CA_SDA: length 8.8
  TOP w0.089: RPH13.2 215.58,65.23 215.18,65.63 v3(215.18,67.14) 215.18,67.19 214.86,67.51 v2(214.79,67.51) ; RPH15.2 212.29,67.48 v2(212.32,67.51)
  IN1 w0.076: v2(212.32,67.51) 212.32,67.81 213.06,68.55 214.28,68.55 214.79,68.03 v2(214.79,67.51)
  BOTTOM w0.089: UV1.R5 215.2,67.1 v2(214.79,67.51)
I2CB_SCL: length 9.2
  TOP w0.089: RPH13.3 215.08,65.28 214.66,65.7 214.66,66.97 214.39,67.24 214.39,67.8 v2(214.01,68.18) 213.98,68.21 v3(212.09,68.21) 211.79,67.91 RPH15.3
  BOTTOM w0.089: v2(214.01,68.18) 214.63,68.18 UV1.R7
I2CB_SDA: length 9.3
  TOP w0.089: v2(211.39,67.51) 211.29,67.41 RPH15.4 ; RPH13.4 214.58,65.34 214.27,65.65 v3(214.27,66.2) 214.27,66.87 213.91,67.23 v2(213.91,67.51)
  IN1 w0.076: v2(211.39,67.51) 211.88,67.01 212.47,67.01 212.71,67.25 212.71,67.71 212.93,67.93 213.49,67.93 v2(213.91,67.51)
  BOTTOM w0.089: v2(213.91,67.51) 214.21,67.81 214.42,67.81 214.5,67.9 UV1.R6
I2CC_SCL: length 8.8
  BOTTOM w0.102: RV319.1 RV299.1 212.45,59.96 212.45,61.54 v3(212.52,61.61) 212.65,61.74 214.76,61.74 215.04,62.02 215.04,62.7 214.85,62.89 214.85,64 215.2,64.36 UV1.R2
I2CC_SDA: length 8.3
  BOTTOM w0.089: UV1.R3 215.6,65.05 215.6,63.45 215.72,63.32 215.72,62.97
  BOTTOM w0.127: v3(215.36,61.69) 215.72,62.05 215.72,62.97
  BOTTOM w0.14: v3(215.36,61.69) 215.16,61.49 214.53,61.49 214.35,61.31 214.35,59.98 RV331.1 RV300.1
I_ADP: length 272.7
  TOP w0.14: v2(301.08,8.59) 300.77,8.9 UE3.A12 ; v3(56.77,10.55) 56.77,10.96 v2(56.66,11.06)
  TOP w0.254: PR314.1 56.9,11.3 v2(56.66,11.06)
  IN1 w0.099: v2(56.66,11.06) 57.36,10.36 59.67,10.36 61.46,12.15 68.23,12.15 69.01,11.36 69.72,11.36 70.12,11.76 72.27,11.76 72.74,11.29 75.98,11.29 76.15,11.12 78.89,11.12 79.66,11.89 84.87,11.89 85.83,12.85 92,12.85 92.36,13.2 95.02,13.2 96.1,12.13 98.51,12.13 99.18,11.45 100.71,11.45 101.44,12.18 101.73,12.18 102.99,13.45 107.86,13.45 108.33,13.92 109.79,13.92 110.26,13.45 128.7,13.45 129.64,12.51 152.6,12.51 154.09,11.02 155.38,11.02 156.04,10.36 162.02,10.36 162.84,11.18 174.4,11.18 176.04,9.54 182.12,9.54 183.12,10.54 211.43,10.54 212.92,9.05 218.63,9.05 218.83,9.25 231.64,9.25 232.41,8.48 245.62,8.48 245.7,8.39 253.05,8.39 253.33,8.68 262.82,8.68 262.88,8.62 264.69,8.62 265.95,9.88 266.3,9.88 268.89,12.47 269.77,12.47 272.06,14.76 278.55,14.76 279.99,16.2 v2(279.99,16.21)
  BOTTOM w0.14: v2(301.08,8.59) 301.08,7.48 301.51,7.06 301.51,6.49 299.87,4.85 282.11,4.85 279.81,7.15 279.81,8.25 279.52,8.54 279.52,15.72 279.99,16.2 v2(279.99,16.21)
I_BATT: length 245.2
  TOP w0.14: v2(286.86,19.02) 286.69,18.85 RE55.2
  TOP w0.254: v2(58.61,11.65) v3(59.14,12.18) 60.41,13.46 60.41,14.6 PR317.1
  IN1 w0.099: v2(286.86,19.02) 286.52,19.36 283.23,19.36 282.72,18.86 281.33,18.86 280.26,17.79 278.91,17.79 277.62,16.5 270.75,16.5 266.87,12.62 266.38,12.62 264.34,10.58 262.87,10.58 261.97,9.68 249.47,9.68 248.66,10.49 224.84,10.49 224.5,10.83 218.22,10.83 217.69,10.3 213.61,10.3 212.36,11.55 175.46,11.55 174.76,12.25 154.66,12.25 153.36,13.55 130.02,13.55 128.47,15.1 105.43,15.1 104.82,14.49 102.61,14.49 101.43,13.31 99.12,13.31 98.88,13.06 96.7,13.06 96.32,13.44 96.32,14.24 95.44,15.12 91.98,15.12 91.4,15.71 85.48,15.71 85.32,15.54 83.55,15.54 83.36,15.35 78.66,15.35 77.28,13.97 73.69,13.97 72.4,15.26 66.23,15.26 63.92,12.95 59.91,12.95 v2(58.61,11.65)
ILIM_HI1: length 6.9
  BOTTOM w0.14: UI2.16 331.71,63.01 332.4,62.33 333.8,62.33 334.54,61.58 RI12.1 335.92,60.61 337.03,60.61 v3(337.17,60.75)
ILIM_HI3: length 2.9
  TOP w0.127: UI1.16 22.85,89.96 RI7.1
  TOP w0.14: v1(22.1,88.4) 22.3,88.6 RI7.1
ILIM_LO1: length 6.5
  BOTTOM w0.14: v3(336.97,62.4) 336.41,62.96 335.45,62.96 RI11.1 334.16,62.47 334.01,62.62 332.61,62.62 331.72,63.51 UI2.15
ILIM_LO3: length 2.7
  TOP w0.127: RI6.1 22.33,90.46 UI1.15
  TOP w0.14: RI6.1 22.3,90.95 v3(21.83,91.42)
ILIM_SEL_L: length 386.2
  TOP w0.127: v2(27.41,88.87) 27.13,88.59 26.31,88.59 26.14,88.75 UI1.4
  TOP w0.14: v2(321.79,47.37) RI33.1 322.63,47.19 RI34.2 322.63,46.05 322.38,45.79 DI12.3 322.01,44.92 RI31.2 320.5,44.92 v3(319.61,44.03)
  IN2 w0.089: 33.45,47.13 33.66,46.92
  IN2 w0.099: 33.66,46.92 33.92,46.65 33.92,44.27 35.55,42.64 35.55,40.62 41.35,34.82 46.27,34.82 47.01,34.08 47.01,33.18 47.48,32.7 51.79,32.7 51.94,32.86 80.59,32.86 81.65,33.92 84.17,33.92 87.16,36.91 95.35,36.91 98.45,40 111.44,40 116.84,34.6 139.78,34.6 145.06,29.32 153.25,29.32 155.82,26.75 158.15,26.75 159.89,25.01 159.89,20.37 160.49,19.77 173.06,19.77 173.53,20.23 174.92,20.23 175.11,20.04 178.49,20.04 179.44,19.09 184.56,19.09 184.79,19.31 207.28,19.31 207.5,19.1 252.29,19.1 254.74,21.54 257.54,21.54 258.68,22.69 259.19,22.69 260.54,21.34 264.19,21.34 264.58,21.73 267.49,21.73 268.55,22.79 288.18,22.79 289.05,23.66 290.63,23.66 293,26.04 293.78,26.04 296.4,28.66 314.1,28.66 315.93,30.5 315.93,32.48 317.77,34.31 317.77,42.03 321.79,46.06 v2(321.79,47.37) ; v2(27.41,88.87) 27.4,88.87 26.39,87.85 26.39,80.29 26.39,80.29 26.39,78 27.18,77.21 27.18,58.66 28.84,56.99 28.84,54.83 28.6,54.59 28.6,51.38 29.62,50.37 29.89,50.37 30.17,50.08 31.88,50.08 33.17,48.8 33.17,48.77 33.17,47.41 33.45,47.13
ILIM_SEL_R: length 25
  TOP w0.14: RI30.2 321.96,43.57 DI12.2 ; DI12.2 324.37,45.28 RI35.2 ; DI12.2 323.68,45.83 323.55,45.96 RI34.1 323.55,47.19 RI32.1 324,47.65 v2(324.59,47.65) v1(325.05,47.18)
  BOTTOM w0.14: v2(324.59,47.65) 323.91,48.32 323.91,51.44 328.12,55.65 328.12,60.37 329.07,61.32 UI2.4
ILMT_0.95V: length 5.1
  TOP w0.14: v2(108.51,63.81) 108.48,63.81 108.04,63.36 v1(107.19,63.36)
  TOP w0.254: v2(108.51,63.81) 107.81,64.51 PR812.1
  BOTTOM w0.254: PR811.2 108.1,64.51 108.51,64.11 v2(108.51,63.81) 108.51,63.81 PU800.3
ILMT_1.05V: length 19.3
  TOP w0.254: PU900.3 220.37,51.8 220.79,51.38 223.62,51.38 PR912.1 224.18,51.29 224.24,51.23 224.24,47.41 221.83,44.99 217.59,44.99 v1(217.3,45.28) 216.47,46.11 PR910.2
ILMT_1V: length 4.3
  TOP w0.14: v1(133.64,2.59) 133.05,2.59 PR510.2
  TOP w0.254: v2(132.34,3.82) 132.46,3.69 PR510.2
  BOTTOM w0.254: PU500.3 132.43,4.18 132.34,4.09 v2(132.34,3.82) 132.34,3.57 132.94,2.97 PR512.1
IMVP_VR_ON: length 142.6
  TOP w0.14: v1(167.27,4.89) 167.35,4.98 UZ21.1 169.15,4.98 169.84,4.29 171.5,4.29 v2(171.5,4.29) ; v2(295.43,9.19) 295.27,9.35 UE3.A1
  IN3 w0.091: v2(295.43,9.19) 294.91,9.71 294.45,9.71 294.08,9.34 294.08,4.23 293.83,3.98 v2(293.83,3.44)
  IN6 w0.099: v2(171.5,4.29) 171.81,4.6 174.34,4.6 176.25,6.51 177.76,6.51 179.18,7.93 210.43,7.93 215.78,2.58 237.55,2.58 238.28,3.31 242.83,3.31 243.71,4.19 245.63,4.19 246.69,5.26 252.88,5.26 254.27,3.87 262.41,3.87 263.54,5 266.85,5 268.63,3.22 290.44,3.22 291.21,4 293.26,4 293.83,3.43 v2(293.83,3.44)
IMVP_VR_PG: length 156.9
  TOP w0.127: v2(115.1,50.22) v1(116.16,49.17) 116.94,48.38 116.94,39.02 107.38,29.45 102.36,29.45 100.42,27.51 100.42,26 101.04,25.38 101.25,25.38 101.85,24.79 102.3,24.79 104.89,22.2 104.89,22.13 106.03,20.99 106.05,20.99 108.26,18.78 109.07,18.78 109.66,18.19 114.44,18.19 115.78,16.85 115.78,12.64 113.09,9.95 113.09,6.62 112.8,6.32 112.42,6.32 112.28,6.47 UH14.1
  TOP w0.254: PR1119.1 v2(112.97,112.72)
  IN6 w0.099: v2(112.97,112.72) 112.97,111.11 112.02,110.16 107.44,110.16 107.06,109.78 107.06,108.85 108.56,107.35 108.56,102.73 108.73,102.57 108.73,100.9 109.08,100.54 109.53,100.54 111.77,98.31 113.32,98.31 113.48,98.47 115.4,98.47 115.82,98.06 116.32,97.56 119.11,97.56 119.58,97.09 121.14,97.09 122.53,95.71 122.53,87.45 126.74,83.23 128.23,83.23 128.44,83.03 128.44,78.81 126.2,76.58 126.2,71.32 124.3,69.42 124.3,66.47 123.83,65.99 121.31,65.99 117.34,62.02 117.34,56.66 115.37,54.7 115.37,50.5 v2(115.1,50.22)
INA199_OUT: length 66
  TOP w0.254: PR239.1 30.18,30.36 30.4,30.14 30.4,28.72 v2(30.16,28.48) ; v2(26.46,29.92) 26.46,30.08 25.86,30.68 PD205.1
  IN2 w0.099: v2(23.17,26.2) 24.54,26.2 25.5,27.16 25.5,28.28 26.46,29.23 v2(26.46,29.92)
  IN3 w0.091: v2(20.13,57.57) 20.54,57.97 20.54,59.17 21.09,59.72 21.09,60.64 20.45,61.29 18.46,61.29 v2(16.13,58.96)
  IN5 w0.099: v2(20.13,57.57) 19.92,57.36 19.92,50.09 18.65,48.82 18.65,42.56 21.46,39.75 21.46,35 20.89,34.42 20.89,32.82 21.57,32.14 21.57,28.69 21.82,28.44 21.82,27.23 22.85,26.2 v2(23.17,26.2)
  IN5 w0.254: v2(26.46,29.92) 26.46,29.69 26.88,29.27 28.73,29.27 29.51,28.48 v2(30.16,28.48)
  BOTTOM w0.14: PR233.1 16.81,58.29 v2(16.13,58.96)
  BOTTOM w0.254: PU201.3 28.61,27.73 28.96,28.08 28.96,29.6 28.7,29.85 PC210.2 29.29,30.29 29.62,29.96 29.62,28.81 29.92,28.51 30.14,28.51 v2(30.16,28.48)
INTRUDER#: length 5.2
  TOP w0.089: v3(94.19,1.56) 94.19,1.65 v2(94.6,2.06) 94.6,3.43 RH531.1
  BOTTOM w0.089: UH2.BE11 94.29,3.89 94.46,3.72 94.46,2.55 94.64,2.37 94.64,2.1 v2(94.6,2.06)
INV_PWM: length 14.4
  TOP w0.127: RV109.1 52.64,28.41 v1(52.64,30.46) 52.64,31.22 53.59,32.16 59.09,32.16 v2(59.54,31.72)
  TOP w0.14: DV2.1 51.1,26.87 RV109.1
  BOTTOM w0.127: v2(59.54,31.72) 59.55,31.73 JEDP1.25
IRQ_SERIRQ: length 280.6
  TOP w0.127: RH111.1 66.52,10.58 v3(66.03,10.08) 65.74,9.79 v2(65.74,9.47)
  TOP w0.14: UE3.A28 305.52,17.13 305.77,16.87 v2(305.77,16.56)
  IN2 w0.089: 101.98,8.38 100.92,8.38 100.05,7.51 97.59,7.51 97.4,7.32 95.94,7.32 95.71,7.1 95.71,6.15 95.05,5.49 92.67,5.49 92.16,6 v2(92.16,6.01)
  IN2 w0.099: v2(308.63,4.94) 308.28,4.94 308.12,5.1 307.54,5.1 307.33,4.89 303.64,4.89 303.16,5.37 301.66,5.37 300.81,4.51 296.28,4.51 296.12,4.35 289.43,4.35 288.7,3.63 272.71,3.63 270.81,5.53 251.15,5.53 250.98,5.7 246.28,5.7 244.65,4.07 239.7,4.07 238.92,3.3 227.55,3.3 227.03,3.81 214.36,3.81 209.74,8.43 201.01,8.43 200.41,7.83 180.38,7.83 179.63,7.09 173.35,7.09 171.98,5.71 163.77,5.71 163.45,6.04 159.86,6.04 159.34,6.56 152.55,6.56 151.79,7.32 151.79,8.27 149.51,10.56 146.93,10.56 146.56,10.93 118.59,10.93 116.8,9.15 102.92,9.15 102.15,8.38 101.98,8.38
  IN6 w0.089: v2(92.16,6.01) 91.91,6.01 91.31,5.41 90.43,5.41 90.22,5.61 89.52,5.61 88.99,5.09 88.45,5.09 87.78,4.42 87.12,4.42 86.66,4.87 86.05,4.87 85.73,4.55 82.36,4.55 82.22,4.7 82.22,5.77 81.46,6.53 80.97,6.53 80.23,7.27 80.23,7.27 80.11,7.39 79.65,7.39 78.94,6.69 78.02,6.69 77.75,6.42 75.86,6.42 75.75,6.31 75.06,6.31
  IN6 w0.099: v2(65.74,9.47) 66.14,9.88 68.2,9.88 69.55,8.52 70.92,8.52 71.24,8.2 71.24,7.77 72.7,6.31 75.06,6.31
  BOTTOM w0.089: v2(92.16,6.01) 92.14,5.99 UH2.BA17
  BOTTOM w0.14: v2(305.77,16.56) 305.77,16.46 305.36,16.05 305.04,16.05 304.72,15.73 304.72,14.05 304.93,13.85 307.02,13.85 307.96,12.92 307.96,11.47 307.7,11.21 307.7,8.19 307.06,7.55 307.06,6.54 307.49,6.1 307.49,5.72 308.28,4.94 v2(308.63,4.94)
ISEN1_GT: length 16.5
  TOP w0.14: v2(105.98,104.34) v3(105.98,106.45)
  TOP w0.203: PU1100.9 113.44,104.89 112.8,104.24 v2(112.78,104.24) 112.78,104.23 112.12,103.56 112.12,103.42 PC1125.2
  IN1 w0.254: v2(105.98,104.34) 106.19,104.54 108.54,104.54 109.81,105.81 111.82,105.81 112.22,105.42 113.2,105.42 113.39,105.23 113.39,104.52 113.11,104.24 v2(112.78,104.24)
  BOTTOM w0.254: PR1303.2 v2(105.98,104.34)
ISEN1_VCORE: length 22.9
  TOP w0.203: PU1100.21 118.2,102.11 118.49,101.81 118.49,101.13 v2(118.47,101.1) 118.49,101.08 PC1124.1
  IN2 w0.254: v2(126.34,99.49) 126.34,99.49 127,99.49 127.41,99.89 127.41,100.66 126.81,101.26 126.58,101.26 126.18,101.67 v2(124.08,101.67) 123.62,101.22 120.12,101.22 119.66,101.67 119.06,101.67 118.49,101.1 v2(118.47,101.1)
  BOTTOM w0.254: PR1214.2 v2(124.08,101.67) v3(123.08,100.68) 123.08,97.65 123.83,96.91 124.51,96.91 PR1216.2 ; PR1201.2 126.9,99.77 126.62,99.49 v2(126.34,99.49)
ISEN2_GT: length 12.8
  TOP w0.14: v1(107.29,104.77) 107.19,104.67 v2(107.19,104.06)
  TOP w0.203: PC1122.2 112.13,102.49 112.13,102.94 113.67,104.49 PU1100.10
  TOP w0.254: v2(111.82,101.09) 111.63,101.28 PC1122.2
  IN1 w0.254: v2(107.19,104.06) 107.19,103.31 107.72,102.78 110.14,102.78 v2(111.82,101.09)
  BOTTOM w0.254: PR1306.2 v2(107.19,104.06)
ISEN2_VCORE: length 19.9
  TOP w0.203: PU1100.22 118.6,102.23 v3(119.24,101.58) 119.24,101.3 v2(119.44,101.1)
  TOP w0.254: v2(124.11,98.12) 124.11,99.51 v2(124.14,99.54) 124.61,100.02 124.61,101.22 126.05,102.65 127.99,102.65 128.4,103.06 v2(128.4,103.3) ; v2(119.44,101.1) 119.44,100.52 PC1123.1
  IN2 w0.254: v2(119.44,101.1) 119.69,100.86 122.49,100.86 123.8,99.54 v2(124.14,99.54)
  BOTTOM w0.254: PR1205.2 128.4,102.97 v2(128.4,103.3) ; v2(124.14,99.54) 124.59,99.54 PR1212.2 ; PR1217.2 124.75,97.88 124.51,98.12 v2(124.11,98.12)
ISEN3_VCORE: length 14
  TOP w0.203: PC1120.1 120.27,100.91 120.57,101.22 v3(120.57,101.52) 120.24,101.85 119.52,101.85 119,102.37 PU1100.23
  TOP w0.254: PC1120.1 120.69,100.47 120.79,100.57 123.71,100.57 v2(124.09,100.19)
  BOTTOM w0.254: PR1215.2 124.28,100.19 v2(124.09,100.19) 123.61,99.7 123.61,99.12 123.91,98.81 PR1213.2 125.45,98.18 125.93,98.18 126.37,97.74 PR1209.2
ISUMN_GT: length 40.5
  TOP w0.14: v2(119.64,85.1) 119.67,85.07 v1(119.67,84.34)
  TOP w0.254: v2(111.11,101.04) 110.72,101.43 PC1122.1 PC1125.1 ; PC1112.2 PC1125.1 ; PC1125.1 110.1,102.94 109.98,102.83 PR1302.1 PR1304.2
  IN3 w0.254: v2(111.11,101.04) 111.11,99.92 112.6,98.43 113.48,98.43 114.36,97.54 115.32,97.54 115.83,98.05 119.43,98.05 119.76,97.72 121.59,97.72 122.09,97.23 122.09,86.29 121.02,85.23 119.76,85.23 v2(119.64,85.1)
  BOTTOM w0.254: PH1102.2 119.99,85.1 v2(119.64,85.1) ; PC1133.2 110.22,103.96 PR1127.1 ; PC1133.2 PR1123.2 111.13,102 PC1119.1 v2(111.11,101.04) ; PC1133.2 PR1130.1
ISUMN_SA: length 40.5
  TOP w0.14: v2(115.38,92.4) 114.33,92.4 v1(114.06,92.67)
  TOP w0.254: PC1110.1 PR1117.1 124.83,108.91 v2(124.14,108.91) PR1115.2 ; v2(124.84,103.7) 125.48,104.34 125.48,105.67 125.99,106.18 127.29,106.18 127.7,105.77 127.7,105.16
  IN1 w0.254: v2(115.38,92.4) 115.63,92.66 117.68,92.66 119.71,94.69 119.71,94.69 120.26,95.24 120.26,95.86 120.45,96.05 120.45,101.91 120.21,102.15 120.21,104.72 121.41,105.93 121.92,105.93 123.51,107.51 123.51,108.28 v2(124.14,108.91)
  IN6 w0.254: v2(124.14,108.91) 125.35,107.7 125.35,104.21 v2(124.84,103.7)
  BOTTOM w0.254: PC1111.1 PC1136.1 ; PC1111.1 124.03,109.03 v2(124.14,108.91) ; PC1111.1 PR1120.1 ; PH1101.1 114.66,91.68 v2(115.38,92.4)
ISUMN_VCORE: length 68.6
  TOP w0.14: v2(149.07,97.96) 148.16,97.96 v1(148.03,98.09)
  TOP w0.254: PC1127.1 PC1126.1 118.49,98.37 v2(118.49,98.94) PC1124.2 PC1123.2 PC1120.2
  IN1 w0.254: v2(126.71,96.18) 126.39,96.5 125,96.5 124.65,96.16 124.65,95.86 124.38,95.59 123.71,95.59 123.25,96.05 123.25,100.15 124.98,101.88 v2(126.7,101.88)
  IN2 w0.254: v2(118.49,98.94) 118.49,99.65 119.34,100.5 122.34,100.5 123,99.84 123,97.7 123.67,97.02 124.51,97.02 126.49,99.01 v2(126.71,99.01) 127.12,99.01 127.76,99.65 127.76,100.81 v2(126.7,101.88) 126.9,102.08 130.33,102.08 133.62,98.79 146.43,98.79 147.12,98.1 148.93,98.1 v2(149.07,97.96)
  BOTTOM w0.254: PC1124.2 v2(118.49,98.94) 118.42,98.79 118.11,98.48 PR1135.2 118.12,98.14 PC1135.1 119.72,98.14 PR1134.1 ; v2(149.07,97.96) 148.5,98.54 148.5,100.19 PH1103.1 ; PR1207.1 126.99,100.97 126.7,101.27 v2(126.7,101.88) ; v2(126.71,96.18) 126.71,96.39 PR1211.1 ; PR1203.1 127.19,99.01 v2(126.71,99.01)
ISUMP_GT: length 44.8
  TOP w0.14: 105.92,103.39 105.33,103.97 v1(105.33,104.64)
  TOP w0.203: PU1100.7 113.03,105.69 112.72,105.37 112.49,105.37 112.14,105.03 v2(112.14,104.66)
  TOP w0.254: v2(112.14,104.66) 112.14,104.47 PC1112.1 ; 105.92,103.39 107.89,103.39 v2(108.14,103.64)
  IN1 w0.254: v2(108.14,103.64) 109.16,104.66 v2(112.14,104.66)
  IN3 w0.254: v2(108.14,103.64) 108.4,103.64 110.56,101.48 110.56,99.98 112.45,98.08 113.33,98.08 114.26,97.15 115.43,97.15 115.98,97.7 119.28,97.7 119.69,97.29 121.29,97.29 121.62,96.96 121.62,86.46 120.89,85.73 119.8,85.73 v2(119.64,85.9)
  BOTTOM w0.254: PR1122.1 120.16,86.43 v2(119.64,85.9) ; PR1123.1 PC1133.1 112.04,104.56 v2(112.14,104.66)
ISUMP_SA: length 41.1
  TOP w0.14: v1(115.9,92.83) 115.63,93.1 v2(115.35,93.1)
  TOP w0.203: v2(121.11,106.38) 121.01,106.49 PU1100.32
  TOP w0.254: PR1309.2 126.19,105.61 125.91,105.33 125.91,103.95 v2(125.29,103.32)
  IN1 w0.254: v2(115.35,93.1) 115.41,93.04 117.55,93.04 119.9,95.39 119.9,96.01 120.09,96.2 120.09,101.77 119.79,102.06 119.79,104.88 121.11,106.19 v2(121.11,106.38)
  IN6 w0.254: v2(125.29,103.32) 125.93,103.97 125.93,107.92 124.25,109.61 121.16,109.61 120.49,108.94 120.49,107.01 v2(121.11,106.38)
  BOTTOM w0.254: v2(121.11,106.38) 121.11,106.6 122.49,107.98 PC1136.2 PC1111.2 PR1120.2 ; v2(115.35,93.1) 115.15,93.1 PR1121.2
ISUMP_VCORE: length 64.8
  TOP w0.14: v2(149.06,98.71) 149.24,98.71 v1(149.66,99.13)
  TOP w0.203: v2(117.4,101.71) 117.4,101.71 PU1100.19
  TOP w0.254: v2(118.78,96.58) 118.9,96.58 119.58,97.27 PC1127.2
  IN2 w0.254: v2(149.06,98.71) 148.87,98.52 147.24,98.52 146.62,99.14 133.77,99.14 130.48,102.43 124.03,102.43 123.18,101.58 120.26,101.58 119.66,102.18 117.87,102.18 v2(117.4,101.71)
  BOTTOM w0.254: 119.97,101.51 119.76,101.71 v2(117.4,101.71) ; 119.97,101.51 119.98,101.49 119.98,99.25 120.4,98.83 120.4,97.9 PR1134.2 119.72,97.23 PC1135.2 118.78,97.02 v2(118.78,96.58) ; 119.97,101.51 123.01,101.51 124.13,102.62 126.29,102.62 127.45,103.78 128.6,103.78 130.6,101.79 PR1206.2 130.59,100.5 PR1202.2 130.38,99.03 PR1210.2 ; v2(149.06,98.71) 148.91,98.87 148.91,99.67 PR1136.2
JTAG_CLK: length 30.3
  TOP w0.14: v2(309.87,30.29) 310.47,29.69 310.47,29.37 310.71,29.13 RP20.3 ; v2(295.18,17.17) 294.98,17.38 UE3.B56
  IN4 w0.091: v2(295.18,17.17) 294.61,17.17 294.49,17.29 294.49,19.16 295.91,20.58 295.91,24.06 297.57,25.72 297.57,27.62 299.88,29.94 301.95,29.94 302.74,29.14 305.86,29.14 307.18,30.46 309.69,30.46 v2(309.87,30.29)
  BOTTOM w0.14: JDEG1.4 309.61,30.54 v2(309.87,30.29)
JTAG_RST#: length 9.7
  TOP w0.14: UE3.B47 297.02,19.55 v2(296.83,19.35) ; v2(296.5,22.35) 297.1,22.96 CE44.1 RE61.1 297.1,24.82 296.95,24.98 JTAG1.1 296.95,26.11 297.1,26.26 RE59.2 297.1,27.47 v3(296.88,27.69)
  BOTTOM w0.14: v2(296.83,19.35) 296.5,19.67 v2(296.5,22.35)
JTAG_TDI: length 33.8
  TOP w0.14: v1(311.44,30.82) 310.99,30.36 v2(310.99,30.17) 311.71,29.45 RP20.1 ; v2(292.33,18.3) 292.5,18.13 UE3.A51
  IN6 w0.099: v2(310.99,30.17) 312.22,28.93 312.22,24.31 309.93,22.02 308.79,22.02 307.93,21.16 304.38,21.16 303.77,20.55 295.33,20.55 293.08,18.3 v2(292.33,18.3)
  BOTTOM w0.14: v2(310.99,30.17) 310.61,30.54 JDEG1.2
JTAG_TDO: length 28.9
  TOP w0.14: v1(308.26,30.69) 309.42,29.52 v2(309.92,29.52) 310.21,29.23 RP20.4 ; UE3.B55 294.67,17.88 294.84,17.7 295.32,17.7 v2(295.86,17.16)
  IN4 w0.091: v2(295.86,17.16) 296.53,17.83 300.31,17.83 300.98,18.5 300.98,19.66 302.27,20.95 302.89,20.95 303.42,21.49 303.42,25.4 305.77,27.75 308.14,27.75 v2(309.92,29.52)
  BOTTOM w0.14: JDEG1.5 309.11,30.33 v2(309.92,29.52)
JTAG_TMS: length 42.8
  TOP w0.14: v1(315.85,26.63) 314.82,27.66 v2(314.82,28.05) ; UE3.A53 293.25,17.13 293.05,17.32 292.48,17.32 292.22,17.05 v2(292.22,16.86) ; RP20.2 311.21,29.32 v2(310.99,29.55)
  IN3 w0.091: v2(310.99,29.55) 312.48,28.05 v2(314.82,28.05)
  IN6 w0.099: v2(292.22,16.86) 292.61,16.47 293.7,16.47 293.89,16.65 296.02,16.65 296.93,17.56 301.42,17.56 301.9,18.04 303.63,18.04 304.54,18.96 312.71,18.96 315.15,21.4 315.15,27.72 v2(314.82,28.05)
  BOTTOM w0.14: JDEG1.3 310.11,30.76 310.31,30.57 310.31,30.22 v2(310.99,29.55)
KB_DET#: length 134.2
  TOP w0.127: v2(66.32,9.43) 66.55,9.66 RH557.1
  TOP w0.14: v2(162.31,4.33) 162.31,4.99 162.63,5.32 164.39,5.32 165.58,6.51 v1(165.58,7.03) 163.51,9.1 162.76,9.85 162.35,9.85 161.05,11.15 v2(161.04,11.15)
  IN5 w0.089: 99.89,1.41 99.82,1.47 90.43,1.47 89.92,1.98 89.92,3.31 89.57,3.65 v2(89.31,3.65) 89.02,3.95 87,3.95 86.49,4.46 76.02,4.46 75.06,5.42
  IN5 w0.099: v2(58.93,8.01) 58.93,7.37 59.11,7.2 62,7.2 62.53,6.67 63.7,6.67 64.95,5.42 75.06,5.42 ; 99.89,1.41 99.95,1.34 106.22,1.34 106.78,1.9 109.96,1.9 110.2,1.66 114.36,1.66 119,6.3 133.45,6.3 134.66,7.52 138.86,7.52 139.47,6.91 141.12,6.91 141.73,7.52 144.69,7.52 147.39,4.81 159.21,4.81 159.57,4.45 162.19,4.45 v2(162.31,4.33)
  IN6 w0.099: v2(66.32,9.43) 65.94,9.05 64.47,9.05 64.24,9.28 61.28,9.28 60.45,8.45 59.37,8.45 v2(58.93,8.01)
  BOTTOM w0.089: UH2.BD22 89.13,4.06 89.31,3.88 v2(89.31,3.65)
  BOTTOM w0.14: v2(161.04,11.15) 161.27,10.92 JKB.5
LAN_WAKE#: length 249.8
  TOP w0.14: v2(302.87,15.74) 303,15.87 303.62,15.87 UE3.B27 ; v2(185.19,4.74) 185.19,4.74 v1(185.19,5.86)
  IN2 w0.089: v2(94.1,3.55) 94.61,3.04 96.08,3.04 96.62,2.5 98.79,2.5 99.75,3.46 99.75,4.66 99.98,4.89 100.61,4.89 100.99,5.27 100.99,5.55 101.22,5.77 101.98,5.77
  IN2 w0.099: v2(185.19,4.74) 184.56,4.12 184.56,3.62 183.71,2.77 182.8,2.77 182.51,3.06 170.91,3.06 169.76,4.22 163.55,4.22 162.97,4.79 159.41,4.79 159.16,5.04 156.66,5.04 156.16,4.54 150.48,4.54 149.28,5.74 147.64,5.74 145.06,8.32 136.38,8.32 135.06,7 129.5,7 128.97,7.54 125.77,7.54 125.23,7 118.78,7 116.11,4.33 113.49,4.33 v2(112.95,4.86) 112.36,4.26 108.27,4.26 107.86,4.67 107.2,4.67 107.03,4.49 106.04,4.49 104.76,5.77 101.98,5.77
  IN3 w0.091: v2(302.87,15.74) 302.97,15.74 304.17,14.54 308.18,14.54 308.58,14.15 308.58,11.92 309.32,11.17 309.32,10.16 309.95,9.53 309.95,5.9 309.46,5.42 v2(309.46,5)
  IN5 w0.099: v2(185.19,4.74) 188.33,7.88 210.99,7.88 211.43,7.44 217.7,7.44 217.91,7.66 226.55,7.66 227.84,6.36 234.93,6.36 236.27,7.7 262.44,7.7 262.81,7.33 272.84,7.33 274.72,5.45 281.83,5.45 283.03,4.26 300.69,4.26 300.82,4.13 308.59,4.13 v2(309.46,5)
  BOTTOM w0.089: UH2.BD11 94.04,4.38 94.04,4.01 94.1,3.95 v2(94.1,3.55)
  BOTTOM w0.14: RH545.1 v2(112.95,4.86)
LCD_DBC: length 5.9
  TOP w0.089: v1(80.55,20.3) 80.87,20.3 81.2,19.97 81.97,19.97 83.09,18.85 v2(83.09,18.58) 82.82,18.31 RH527.1 RH528.1
  BOTTOM w0.089: UH2.U35 v2(83.09,18.58)
LCD_TST: length 267.2
  TOP w0.127: v2(68.36,15.95) 67.78,16.53 67.78,17.3 66.46,18.62 66.46,19.89 v1(66.76,20.18) 66.96,20.38 66.96,21.59 66.18,22.36 63.5,22.36 62.23,23.63 62.23,27.44 62.73,27.94 63.38,27.94 RV110.1
  TOP w0.14: v2(300.49,21.52) 300.27,21.3 UE3.A38 ; v2(300.99,24.85) RE32.2
  IN1 w0.099: v2(68.36,15.95) 68.64,15.67 72.65,15.67 73.98,14.34 77.08,14.34 78.49,15.75 83.46,15.75 83.64,15.93 85.03,15.93 85.56,16.47 91.25,16.47 92.41,15.31 95.52,15.31 96.51,14.32 96.51,13.52 96.78,13.25 98.75,13.25 99,13.49 101.34,13.49 102.53,14.69 104.74,14.69 105.35,15.3 128.64,15.3 130.19,13.75 153.47,13.75 154.77,12.45 174.84,12.45 175.54,11.75 212.44,11.75 213.35,10.84 215.13,10.84 215.34,10.62 217.73,10.62 218.14,11.03 224.58,11.03 224.92,10.69 248.75,10.69 249.56,9.88 261.88,9.88 262.78,10.78 264.26,10.78 266.3,12.82 266.75,12.82 270.94,17.01 277.85,17.01 278.95,18.11 280.29,18.11 281.24,19.06 282.64,19.06 283.27,19.69 287.14,19.69 287.54,20.1 291.21,20.1 291.47,20.35 293.46,20.35 294.09,20.99 299.96,20.99 v2(300.49,21.52)
  IN4 w0.091: v2(300.49,21.52) 300.65,21.52 301.18,22.04 301.18,24.66 v2(300.99,24.85)
LCD_VCC_TEST_EN: length 297.4
  TOP w0.14: v2(41.26,33.23) 41.26,33.54 40.96,33.84 39.26,33.84 38.4,32.98 38.4,31.97 38.73,31.64 38.73,31.27 38.29,30.83 DV7.2 ; v3(300.91,22.34) 300.72,22.14 v2(300.38,22.14) 300.27,22.14 299.77,21.65 UE3.A39
  IN2 w0.099: v2(41.26,33.23) 42.07,32.42 45.95,32.42 48.45,29.92 57.88,29.92 58.43,30.47 70.01,30.47 70.98,29.5 73.67,29.5 74.41,30.23 79.73,30.23 80.68,31.19 84.68,31.19 88.05,34.55 97.19,34.55 100.25,37.62 110.92,37.62 115.56,32.98 139.12,32.98 145.97,26.13 154.15,26.13 155.23,25.06 157.03,25.06 157.56,24.53 157.56,19.72 158.84,18.44 172.94,18.44 173.17,18.21 175.52,18.21 175.98,17.76 253.91,17.76 254.13,17.53 259.51,17.53 261.05,19.07 264.32,19.07 264.53,19.28 267.36,19.28 268.41,20.34 273.64,20.34 274.19,19.79 278.32,19.79 278.93,20.4 280.17,20.4 281.66,21.89 290.28,21.89 291.01,22.61 291.01,23.2 293.22,25.41 294.02,25.41 295.73,27.11 296.98,27.11 297.73,27.86 299.01,27.86 299.19,27.68 299.19,27.02 299.46,26.75 300.41,26.75 v2(300.76,27.11)
  IN4 w0.091: v2(300.76,27.11) 300.76,26.27 300.56,26.07 300.56,23.43 300.99,23 300.99,22.39 300.74,22.14 v2(300.38,22.14)
