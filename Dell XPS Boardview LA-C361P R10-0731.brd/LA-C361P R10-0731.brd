# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
VR_SVID_ALERT#_R: length 35.2
  TOP w0.14: v2(134.07,102.35) 134.07,103.5 RH153.2 ; v2(137.53,98) 137.53,98.73 v1(137.31,98.94)
  IN2 w0.099: v2(137.53,98) 137.53,92.68 134.37,89.53 134.37,82.82 135.37,81.82 136.98,81.82 138.08,80.73 141.61,80.73 142.01,81.14 v2(142.01,82.13)
  IN4 w0.091: v2(137.53,98) 137.53,98.89 v2(134.07,102.35)
  BOTTOM w0.076: v2(142.01,82.13) 142.33,81.81 UH1.BH31
VR_SVID_CLK: length 62.9
  TOP w0.14: v2(114.11,113.42) 114.44,113.09 PR1131.2 PR1319.1 ; v1(139.08,98) 139.07,98.01 v2(138.23,98.01)
  IN2 w0.099: v2(142.01,82.78) 141.62,82.39 141.62,81.36 141.38,81.12 138.46,81.12 137.29,82.29 135.74,82.29 134.93,83.1 134.93,89.3 138.23,92.6 v2(138.23,98.01)
  IN4 w0.091: v2(138.23,98.01) 138.23,99.03 134.95,102.31 134.95,105.3 129.25,111.01 126.87,111.01 122.82,115.06 115.75,115.06 v2(114.11,113.42)
  BOTTOM w0.076: v2(142.01,82.78) 142.33,82.46 UH1.BH32
VR_SVID_CLK_C: length 3.2
  TOP w0.14: PU1100.45 116.2,109.86 115.86,110.19 v3(115.2,110.19) 114.81,110.59 PR1319.2
VR_SVID_DATA: length 60.3
  TOP w0.14: v2(136.83,98) 136.83,97.71 v1(137.42,97.13) ; v2(133.48,102.15) 133.41,102.09 RH151.2 ; v2(117.45,113.86) 117.39,113.86 116.65,113.13 PR1145.2 PR1318.1
  IN2 w0.099: v2(142.95,79.51) 142.2,79.51 141.38,80.32 137.77,80.32 136.69,81.41 135,81.41 133.82,82.59 133.82,89.76 136.83,92.77 v2(136.83,98)
  IN4 w0.091: v2(117.45,113.86) 117.51,113.93 122.3,113.93 126.43,109.8 128.78,109.8 132.96,105.62 132.96,102.68 v2(133.48,102.15) 136.83,98.8 v2(136.83,98)
  BOTTOM w0.076: v2(142.95,79.51) 142.95,80.04 UH1.BH29
VR_SVID_DATA_C: length 2.4
  TOP w0.14: PR1318.2 117,110.84 v3(117,110.13) PU1100.43
VSB_N_001: length 56.6
  TOP w0.14: v2(67.01,14.47) 67.05,14.52 v1(67.05,15.67)
  IN2 w0.254: v2(67.01,14.47) 66.15,14.47 65.1,13.43 v2(65.1,9.55)
  IN6 w0.254: v2(65.1,9.55) 64.76,9.89 64.34,9.89 63.32,10.91 61.19,10.91 60.28,9.99 56.97,9.99 55.07,11.9 54.6,11.9 53.66,12.84 53.66,14.72 53.13,15.25 53.13,16.58 51.36,18.35 43.9,18.35 43.32,17.76 41.97,17.76 40.21,19.53 34.07,19.53 32.45,17.91 v2(32.45,16.14)
  BOTTOM w0.254: v2(67.01,14.47) 67.01,15.95 66.02,16.94 64.47,16.94 63.96,17.45 PR107.2 63.17,17.46 PR110.2
VSB_N_002: length 9.5
  BOTTOM w0.14: v3(66.54,14.77) 66.23,15.07 PR113.2
  BOTTOM w0.254: PR113.2 65.08,15.21 65.08,16.1 64.68,16.49 64.3,16.49 64,16.8 60.55,16.8 60.08,17.27 PC113.1 60.07,17.61 PQ103.2
VSB_N_003: length 2.4
  BOTTOM w0.14: v3(63.09,19.69) 62.29,19.69 PQ103.1
  BOTTOM w0.254: PR110.1 62.29,18.68 61.97,19 PQ103.1
VSET: length 4.7
  TOP w0.14: v1(182.02,16.93) 182.25,16.7 RZ54.2 RZ52.1 183.16,13.73 183.01,13.57 UZ10.4
VSET_5085: length 4.1
  TOP w0.14: RE58.1 CE41.1 305.79,10.08 305.61,9.9 v3(305.4,9.9) 305.02,10.28 305.02,11.38 304.77,11.63 UE3.A17
WLAN_CLK_REQ#: length 368.3
  TOP w0.127: RP2.5 67.95,5.08 67.62,4.75 66.96,4.75 v2(66.6,4.39)
  TOP w0.14: v2(338.63,87) 338.61,87 337.29,85.68 337.29,84.9 v1(337.38,84.81)
  IN5 w0.089: 75.06,4.76 75.21,4.61 75.71,4.1 86.34,4.1 86.85,3.59 87.14,3.59 87.98,2.76 v2(87.98,2.6)
  IN5 w0.099: v2(66.6,4.39) 67.24,5.02 74.8,5.02 75.06,4.76
  IN6 w0.089: 101.98,6.73 101.75,6.5 99.82,6.5 98.87,5.55 98.87,4.59 98.47,4.2 97.55,4.2 97.24,4.5 95.65,4.5 95.54,4.61 92.83,4.61 92.26,4.04 88.76,4.04 87.98,3.26 v2(87.98,2.6)
  IN6 w0.099: 101.98,6.73 102.54,7.29 104.25,7.29 104.75,6.79 104.75,6.62 105.19,6.18 115.56,6.18 117.42,8.04 117.96,8.04 118.72,8.79 126.14,8.79 126.89,8.04 129.59,8.04 130.24,7.39 132.67,7.39 133.09,7.81 134.56,7.81 135.82,9.07 144.74,9.07 148.2,5.61 149.88,5.61 150.5,4.99 157.72,4.99 158.68,5.96 162.95,5.96 162.96,5.95 170.66,5.95 172.27,7.55 177.67,7.55 178.85,8.73 210.76,8.73 215.38,4.12 238.83,4.12 239.79,5.08 245.37,5.08 246.36,6.06 256.61,6.06 256.81,5.86 262.97,5.86 263.34,6.23 267.36,6.23 268.17,5.42 270.27,5.42 270.81,4.88 295.14,4.88 295.32,4.71 300.93,4.71 301.59,5.37 303.05,5.37 303.18,5.24 305.68,5.24 306.16,5.73 306.16,6.04 306.81,6.68 316.06,6.68 319.68,10.31 319.68,23.68 320.82,24.82 320.82,27.57 324.26,31.01 324.26,34.83 325,35.58 325,37.75 328.21,40.96 328.21,51.43 328.44,51.65 328.44,52.07 330.05,53.68 330.05,57.34 334.07,61.36 334.07,81.79 337.31,85.03 337.31,85.71 338.61,87 v2(338.63,87)
  BOTTOM w0.089: UH2.BD25 87.71,4.39 87.71,3.71 87.87,3.54 87.87,2.7 87.97,2.6 v2(87.98,2.6)
  BOTTOM w0.14: JNGFF1.45 341.55,87.21 341.2,87.56 339.19,87.56 v2(338.63,87)
WLAN_WIGIG60GHZ_DIS#: length 107.2
  TOP w0.14: UE4.22 273.34,16.06 RE71.2 v3(273.13,17.26) 273.79,17.92 v2(274.41,17.92)
  IN6 w0.099: v2(274.41,17.92) 275.88,19.39 278.96,19.39 279.53,19.96 280.6,19.96 282.64,22.01 285.96,22.01 286.44,21.53 293.15,21.53 295.18,23.56 297.77,23.56 298.44,24.23 305.85,24.23 307.53,25.91 307.53,28 308.6,29.07 308.6,33.99 311.83,37.23 311.83,38.8 318.04,45.01 318.04,46.61 320.68,49.26 320.68,50.93 322.89,53.14 322.89,55.01 324.94,57.05 324.94,60.58 327.17,62.8 327.17,69.47 325.63,71 325.63,76.36 328.03,78.76 v2(328.03,79.05)
  BOTTOM w0.14: DN1.1 329.95,79.76 329.24,79.05 v2(328.03,79.05)
WLAN_WIGIG60GHZ_DIS#_R: length 23.4
  IN2 w0.099: v2(329.1,79.8) 330.33,81.03 330.94,81.03 333.48,83.57 333.48,86.88 334.62,88.02 338.67,88.02 339.56,88.91 v2(341.26,88.91)
  BOTTOM w0.14: DN1.2 329.44,81.48 329.44,80.15 v2(329.1,79.8) ; JNGFF1.48 342.3,89.95 v2(341.26,88.91)
XDP_BPM#0: length 24
  TOP w0.089: 134.62,78.46 134.85,78.23 v2(134.85,78.02)
  TOP w0.14: 134.62,78.46 v1(134.56,78.52) ; JXDP.21 126.95,90.51 126.53,90.09 v2(126.39,90.09)
  IN2 w0.089: v2(134.85,78.02) 134.62,78.25
  IN2 w0.099: 134.62,78.25 134.44,78.43 132.92,78.43 131.69,79.67 131.69,80.09 129.72,82.06 129.38,82.06 129.11,82.33 129.11,84.8 125.85,88.05 125.85,88.51 126.23,88.88 126.54,88.88 126.92,89.27 126.92,89.56 v2(126.39,90.09)
  BOTTOM w0.076: v2(134.85,78.02) 135.37,78.54 137.12,78.54 137.21,78.46 137.77,78.46 UH1.BR27
XDP_BPM#1: length 25.1
  TOP w0.14: JXDP.23 126.71,91.01 v2(126.39,90.69) ; v2(134.25,78.01) 133.11,79.16 v1(132.83,79.16)
  IN2 w0.099: v2(126.39,90.69) 125.98,90.27 125.98,88.91 125.65,88.59 125.65,87.97 128.91,84.72 128.91,82.25 129.3,81.86 129.64,81.86 131.49,80.01 131.49,79.58 133.47,77.61 133.85,77.61 v2(134.25,78.01)
  BOTTOM w0.076: 134.62,78.38 134.95,78.71 137.38,78.71 UH1.BT27
  BOTTOM w0.14: 134.62,78.38 v2(134.25,78.01)
XDP_DBRESET#: length 18.8
  TOP w0.14: v1(128.66,106.21) 128.66,105.07 129.11,104.63 129.11,102.95 127.47,101.31 126.05,101.31 125.2,100.46 v2(125.2,96.02) 124.21,97.01 JXDP.48
  BOTTOM w0.14: CH175.1 RH5.2 RH8.1 124.72,95.46 125.2,95.94 v2(125.2,96.02)
XDP_PLTRST#: length 7.7
  TOP w0.14: v3(117.65,92.59) 117.65,92.87 RH480.2 RH479.2 RH492.2 118.76,95.88 120.32,95.88 120.68,96.24 121.16,96.24 121.42,96.51 JXDP.46
XDP_PRDY#: length 124.2
  TOP w0.089: v1(136.32,78.48) 136.04,78.2 v2(136.04,78)
  TOP w0.14: v2(126.3,88.24) 126.3,87 126.8,86.51 JXDP.5
  IN2 w0.102: v2(126.3,88.24) 126.3,87.98 128.05,86.24 128.67,86.24 129.97,84.94 129.97,82.1 131.89,80.18 131.89,79.75 133.01,78.63 135.41,78.63 v2(136.04,78)
  IN4 w0.089: v2(136.04,78) 135.41,77.36 134.62,77.36
  IN4 w0.091: 134.62,77.36 133.07,77.36 130.98,75.28 130.98,66.32 132.01,65.29 132.01,58.05 125.23,51.26 125.23,47.23 112.28,34.29 112.28,26.74 111.82,26.28 111.82,18.77 112.38,18.21 112.38,16.43 112.21,16.26 111.8,16.26 v2(111.39,16.67)
  BOTTOM w0.076: v2(136.04,78) 136.42,78.38 136.98,78.38 137.07,78.29 138.26,78.29 UH1.BP27
  BOTTOM w0.089: 100,8.53 99.11,8.53 99.06,8.49 98.26,8.49 98.15,8.59 UH2.AT4 ; 101.98,7.72 101.31,7.72 101.11,7.92
  BOTTOM w0.102: v2(111.39,16.67) 111.39,16.38 113.2,14.58 113.2,11.42 110.45,8.67 110.22,8.45 110.22,6.6 109.82,6.2 107.14,6.2 106.71,6.63 106.71,7.13 106.2,7.64 102.06,7.64 101.98,7.72 ; 101.11,7.92 100.62,7.92 100,8.53
XDP_PREQ#: length 128.7
  TOP w0.089: v1(136.78,81.41) v2(136.78,80.8)
  TOP w0.14: v2(131.22,86.61) 130.63,86.61 130.03,86.01 JXDP.3
  IN2 w0.089: 134.62,80.85 136.72,80.85 v2(136.78,80.8)
  IN2 w0.099: v2(131.22,86.61) 131.5,86.33 131.5,85.48 132.08,84.9 132.08,83.04 134.27,80.85 134.62,80.85
  IN4 w0.089: v2(136.78,80.8) 136.78,80.4 137.43,79.75 137.43,77.75 136.61,76.93 134.62,76.93
  IN4 w0.091: 134.62,76.93 133.18,76.93 131.98,75.74 131.98,70.91 132.71,70.18 132.71,68.96 131.71,67.95 131.71,66.44 132.4,65.74 132.4,57.67 125.61,50.88 125.61,46.96 113.41,34.76 113.41,17.06 v2(113.01,16.66)
  BOTTOM w0.076: UH1.BL30 140.32,80.65 136.92,80.65 v2(136.78,80.8) 135.91,80.8 135.55,80.43 134.62,80.43
  BOTTOM w0.089: UH2.AT3 98.48,7.97 99.06,7.97 99.4,7.63 99.62,7.63 99.7,7.55 100.96,7.55
  BOTTOM w0.102: 100.96,7.55 102.12,6.38 104.42,6.38 105.25,7.21 105.74,7.21 106.06,6.89 106.06,6.6 106.89,5.76 110.82,5.76 112.13,7.07 112.13,9.74 114.62,12.23 114.62,14.48 113.01,16.09 v2(113.01,16.66)
  BOTTOM w0.14: 134.62,80.43 133.87,80.43 133.74,80.31 132.15,80.31 RH156.2
XDP_PWRGOOD: length 6.9
  TOP w0.14: JXDP.39 129.23,95.01 129.6,94.64 129.6,93.16 129.95,92.82 129.95,92.35 RH481.2 RH482.2 131.66,90.97 v3(131.76,90.86)
XDP_TDI: length 26.4
  TOP w0.14: v1(135.46,98.56) 136.02,98 v2(136.18,98) ; v2(120.98,98.7) 121.08,98.7 121.39,99.01 JXDP.56
  IN3 w0.091: v2(120.98,98.7) 121.97,98.7 123.55,97.12 124.26,97.12 125,97.86 127.89,97.86 129.02,96.73 129.93,96.73 130.96,95.7 132.41,95.7 132.6,95.89 132.6,96.22 134.38,98 v2(136.18,98)
  BOTTOM w0.14: v2(136.18,98) 135.93,97.75 RH541.1 ; RH477.1 118.99,96.09 119.7,96.09 120,96.39 120,96.69 120.98,97.67 v2(120.98,98.7)
XDP_TDO: length 22.7
  TOP w0.14: JXDP.52 121.39,98.01 120.98,97.6 v2(120.98,96.67) ; v1(133.27,97.94) 132.5,97.94 132.28,98.16 v2(132.28,98.73)
  IN4 w0.091: v2(132.28,98.73) 131.45,99.56 131.09,99.56 129.85,100.81 122.37,100.81 121.58,100.02 121.58,97.27 v2(120.98,96.67)
  BOTTOM w0.14: RH478.1 120.14,95.83 120.98,96.67 v2(120.98,96.67) ; RH540.1 132.49,97.75 132.28,97.96 v2(132.28,98.73)
XDP_TMS: length 24.9
  TOP w0.14: v3(133.1,93.32) 132.16,93.32 131.68,93.79 131.68,93.98 v2(131.33,94.33) ; v2(121.02,99.3) 121.23,99.51 JXDP.58
  IN2 w0.254: v2(121.02,99.3) 121.65,99.3 122.19,98.76 122.19,97.1 123.61,95.68 124.29,95.68 124.65,96.04 124.65,96.33 125.95,97.62 127.01,97.62 130.3,94.33 v2(131.33,94.33)
  BOTTOM w0.14: v2(131.33,94.33) 130.8,94.33 RH542.1 ; RH12.1 119.64,95.85 119.8,95.85 120.24,96.29 120.24,96.59 121.41,97.76 121.41,98.91 v2(121.02,99.3)
XDP_TRST#: length 24.5
  TOP w0.14: JXDP.54 121.4,98.51 120.42,97.53 120.42,96.48 v3(120.23,96.29) 119.85,96.29 v2(119.57,96.57)
  IN6 w0.099: v2(127.97,82.83) 126.86,82.83 122.32,87.36 122.32,95.52 121.75,96.09 121.12,96.09 121.12,96.1 120.04,96.1 v2(119.57,96.57)
  BOTTOM w0.14: RH543.1 128.38,82.83 v2(127.97,82.83)
XTAL24_IN: length 9.2
  TOP w0.14: YH2.1 103.76,26.88 CH47.1 102.99,26.82 RH72.1 ; RH72.1 102.15,27.82 v3(102.19,27.86) ; RH72.1 v2(101.47,26.82)
  BOTTOM w0.089: v2(101.47,26.82) 101.22,26.82 100.98,27.06 99.63,27.06 98.87,26.3 97.6,26.3 97.05,25.75 UH2.A6
XTAL24_OUT: length 10
  TOP w0.14: YH2.3 104.88,26.3 103.63,26.3 103.33,25.99 CH48.1 102.95,25.9 RH72.2 101.87,26.18 v2(101.34,26.18)
  BOTTOM w0.089: v2(101.34,26.18) 101.34,26.43 101.02,26.76 99.86,26.76 99.18,26.08 97.82,26.08 97.68,25.94 97.68,25.94 97.49,25.75 UH2.A5
XTAL_25_IN: length 5.7
  BOTTOM w0.102: UT1.D22 23.12,35.84 23.12,33.55 YT1.1
  BOTTOM w0.127: CT43.1 21.86,32.28 YT1.1
  BOTTOM w0.14: CT43.1 20.63,32.28 v3(20.55,32.2)
XTAL_25_OUT: length 8.3
  BOTTOM w0.102: v3(26.69,34.07) 26.4,34.36 25.78,34.36 24.84,35.31 23.47,35.31 23.35,35.42 UT1.D23
  BOTTOM w0.127: YT1.3 25.33,31.7 CT44.1
  BOTTOM w0.14: v3(26.69,34.07) 27.18,33.58 27.18,32.22 CT44.1
XTALOUTBUFF: length 24.5
  TOP w0.14: v2(207.19,53.37) v3(207.19,54.05)
  IN6 w0.089: 218.12,62.97 218.35,63.2 218.35,63.55 218.61,63.8 219.15,63.8 219.52,64.17 219.52,66.4 v2(219.77,66.66)
  IN6 w0.099: v2(207.19,53.37) 207.19,53.78 208.07,54.66 208.07,57.68 208.09,57.69 210.42,60.03 213.89,60.03 214.36,60.5 214.36,61.26 214.71,61.6 216.76,61.6 218.12,62.97
  BOTTOM w0.089: UV1.J4 220.18,66.25 v2(219.77,66.66)
  BOTTOM w0.14: RPH32.1 v2(207.19,53.37)
XTALSSIN: length 24.1
  TOP w0.14: v2(206.58,52.92) 207.21,52.28 v3(207.28,52.28)
  IN6 w0.089: 219.4,62.97 v2(220.62,64.19)
  IN6 w0.099: v2(206.58,52.92) 207.32,52.92 207.6,53.2 207.6,53.9 208.27,54.58 208.27,57.59 208.29,57.61 210.5,59.82 214.05,59.82 214.78,60.56 215.98,60.56 216.41,60.99 216.72,60.99 218.58,62.86 219.29,62.86 219.4,62.97
  BOTTOM w0.089: v2(220.62,64.19) 220.97,63.85 UV1.H1
  BOTTOM w0.14: RPH32.2 206.69,53.74 206.58,53.63 v2(206.58,52.92)
N48197: length 3.6
  TOP w0.203: PC1103.2 v2(112.71,109.04) v3(113.08,108.68) 113.25,108.5 113.25,108.17 113.74,107.69 PU1100.2
  BOTTOM w0.254: PR1104.2 v2(112.71,109.04)
N48329: length 3.3
  TOP w0.203: PC1104.2 112.92,107.13 v2(113.03,107.02) 113.16,106.89 PU1100.4
  BOTTOM w0.254: PR1111.2 112.92,107.13 v2(113.03,107.02)
N48371: length 4.9
  BOTTOM w0.14: PC1105.2 109.64,106.24 109.06,105.67 v1(106.82,105.67)
  BOTTOM w0.254: PR1111.1 111.05,107.13 110.55,106.64 110.08,106.64 PC1105.2
N48789: length 3.7
  TOP w0.203: PU1100.28 120.66,104.89 120.75,104.79 121.31,104.79 121.52,104.58 v3(121.64,104.58) 121.9,104.58 PC1114.1 PR1129.1
N48933: length 2.8
  BOTTOM w0.14: PC1117.1 v3(121.53,103.31)
  BOTTOM w0.254: PC1117.1 122.56,104.38 PR1126.2
N48941: length 4.7
  TOP w0.203: PC1115.1 122.04,105.66 122.04,105.47 v2(121.67,105.1) 120.88,105.1 120.74,105.24 120.72,105.24 120.67,105.29 PU1100.29
  BOTTOM w0.14: v3(120.89,105.09) 120.91,105.1 v2(121.67,105.1)
  BOTTOM w0.254: v2(121.67,105.1) 121.86,105.29 PR1126.1
N48965: length 3.3
  TOP w0.14: PC1116.1 125.34,106.63 126.52,106.63 v3(126.91,107.02)
  TOP w0.254: PC1116.1 PR1124.2
N48979: length 8.7
  TOP w0.203: PU1100.30 120.7,105.69 120.78,105.61 121.55,105.61 121.98,106.04 121.98,106.69 v2(122.43,107.13) PR1124.1
  BOTTOM w0.254: PR1125.1 125.1,106.08 124,107.17 v3(123.04,107.17) 122.47,107.17 v2(122.43,107.13) 122.43,106.37 PR1128.1
N49205: length 3.4
  TOP w0.203: PU1100.8 113.18,105.29 v2(112.78,104.89)
  BOTTOM w0.254: v2(112.78,104.89) 112.38,105.29 PR1130.2 PC1113.2
N49217: length 3
  BOTTOM w0.14: v3(108.55,105.13) 109.49,105.13 PR1127.2
  BOTTOM w0.254: PC1113.1 110.67,105.79 110.15,105.79 PR1127.2
N49289: length 5.4
  TOP w0.203: v2(112.78,108.09) PR1105.2 112.55,107.58 113.17,107.58 113.46,107.29 PU1100.3
  BOTTOM w0.14: v2(112.78,108.09) v1(114.2,108.09)
  BOTTOM w0.254: PR1105.2 v2(112.78,108.09)
N49471: length 2.7
  TOP w0.14: PR1117.2 126.18,109.81 v3(126.19,109.8)
  TOP w0.254: PC1108.1 124.83,109.8 PR1117.2
N49551: length 4.9
  TOP w0.203: PU1100.33 121.28,106.89 121.53,107.14 v3(121.53,107.61) 121.37,107.77 121.37,108.24 122.05,108.91 PR1115.1 PC1108.2
N49667: length 3.1
  TOP w0.14: v2(115.67,109.76) 115.8,109.64 PU1100.46
  BOTTOM w0.14: v3(114.66,110.05) 115.38,110.05 v2(115.67,109.76) 115.89,109.55 PR1103.2
N49815: length 7.1
  TOP w0.14: PR1116.1 123.8,110.32 124.69,110.32 v3(125.3,110.93)
  TOP w0.203: PU1100.36 120.57,108.09 120.7,108.21 120.7,108.99 122.21,110.5 122.99,110.5 PR1116.1
N50153: length 3.7
  TOP w0.203: PC1101.1 v2(117.54,110.56) 117.4,110.42 PU1100.42
  BOTTOM w0.14: v2(117.54,110.56) v3(118.05,110.05)
  BOTTOM w0.254: PR1101.2 v2(117.54,110.56)
N50385: length 5.4
  TOP w0.14: v3(111.61,100.17) 111.9,100.47 PR1137.1
  TOP w0.203: PR1137.1 PC1129.1 113.86,100.72 115.4,102.26 PU1100.14
N50425: length 44.9
  TOP w0.14: v2(144.36,102.28) 144.3,102.22 144.3,101.96 v1(144.7,101.56)
  TOP w0.254: PR1144.1 114.58,99.39 PR1138.2 v2(114.58,98.03)
  IN3 w0.254: v2(144.36,102.28) 144.36,96.83 143.68,96.15 133.83,96.15 132.98,95.3 130.79,95.3 130.38,94.89 129.45,94.89 126.83,97.51 125.04,97.51 124.37,96.84 123.27,96.84 121.94,98.17 120.49,98.17 120.17,98.5 120.17,99.02 119.76,99.42 115.98,99.42 v2(114.58,98.03)
  BOTTOM w0.254: PH1104.2 142.86,103.27 143.85,102.28 v2(144.36,102.28)
N50433: length 2.8
  TOP w0.203: PR1144.2 114.75,101.05 v3(115.15,101.45) 115.8,102.1 PU1100.15
N50477: length 3.1
  TOP w0.203: PR1110.1 119.7,110.89 119.3,110.5 119,110.5 v3(118.49,109.99) 118.2,109.7 PU1100.40
N50505: length 5.7
  TOP w0.14: v3(121.07,113.2) 121.07,111.68 PR1109.1
  TOP w0.203: PR1109.1 120.59,110.82 119.95,110.18 119.27,110.18 118.6,109.51 PU1100.39
N50517: length 3.9
  TOP w0.203: PU1100.38 119,108.91 119,109.36 119.48,109.84 120.35,109.84 v3(120.59,110.09) 121.55,111.04 PR1108.1
N50567: length 5.6
  TOP w0.14: PR1107.1 122.54,111.2 v3(123.45,112.1)
  TOP w0.203: PR1107.1 120.73,109.48 119.6,109.48 119.4,109.29 PU1100.37
N50631: length 2.1
  BOTTOM w0.14: PR1141.2 114.52,99.55 v3(114.47,99.6)
  BOTTOM w0.254: PR1141.2 115.7,98.78 PC1134.2
N50639: length 4
  TOP w0.203: PC1131.1 v2(115.7,101.1) 115.7,101.55 116.2,102.05 PU1100.16
  BOTTOM w0.14: v2(115.7,101.1) v3(115.7,101.84)
  BOTTOM w0.254: PC1131.1 v2(115.7,101.1)
N50651: length 3
  TOP w0.14: PC1132.1 116.24,98.69 115.85,98.3 115.85,97.59 v1(115.5,97.23)
  TOP w0.254: PR1139.2 PC1132.1
N50739: length 4
  TOP w0.203: PU1100.17 116.6,101.77 v3(116.48,101.66) 116.48,101.14 v2(116.52,101.1) 116.59,101.04 PR1139.1
  BOTTOM w0.254: v2(116.52,101.1) 116.59,101.04 PR1139.1 117.46,100.47 PR1140.1
N51003: length 3.8
  TOP w0.203: PU1100.20 117.8,101.96 117.92,101.84 v3(117.92,101.67) 117.92,101.29 v2(117.8,101.16)
  BOTTOM w0.254: v2(117.8,101.16) 117.8,101.03 118.37,100.47 PR1133.1 PC1128.1
N51011: length 4.9
  TOP w0.14: v2(118.19,96.58) 117.6,96.58 v3(117.48,96.45)
  IN2 w0.254: v2(118.19,96.58) 118.19,97.68 v2(119.44,98.94)
  BOTTOM w0.254: v2(118.19,96.58) 118.11,96.66 PR1135.1 ; PC1128.2 v2(119.44,98.94)
N57527: length 38.7
  TOP w0.14: v2(157.93,105.99) 157.93,106.47 v1(157.67,106.73)
  IN1 w0.254: v2(129.77,96.21) 130.27,96.71 144.97,96.71 148.36,100.1 156.29,100.1 157.43,101.24 157.43,105.5 v2(157.93,105.99)
  BOTTOM w0.254: PR1222.2 158.18,106.24 v2(157.93,105.99) ; PR1209.1 128.25,97.74 PR1210.1 129.77,96.21 v2(129.77,96.21)
N3514407: length 3.1
  TOP w0.203: PU400.5 346.29,21.1 346.51,21.32 346.51,22.09 v3(346.97,22.55) PR405.2
N3514423: length 4.9
  TOP w0.203: 346.85,20.56 346.6,20.3 PU400.3
  TOP w0.254: v2(347.31,21.61) 347.31,21.51 347.9,20.91 PC400.1 347.6,20.56 346.85,20.56
  BOTTOM w0.14: v2(347.31,21.61) 347.31,21.28 v3(347.65,20.94)
  BOTTOM w0.254: PR400.2 347.68,21.98 v2(347.31,21.61)
N3514453: length 4.5
  TOP w0.14: v3(339.18,18.64) 339.62,18.64 PC419.1
  TOP w0.203: PU400.13 342.18,20.3 342.04,20.44 341.43,20.44 PC419.1
N13272409: length 4.7
  TOP w0.14: v1(108.98,63.01) 109.41,63.45 v2(109.41,63.83)
  TOP w0.254: PC800.1 109.41,64.13 v2(109.41,63.83)
  BOTTOM w0.254: PR800.1 PC800.1 109.03,64.14 109.35,63.83 v2(109.41,63.83) PU800.1
N13272413: length 6.3
  TOP w0.14: v1(104.27,63.5) PR806.1
  TOP w0.254: PR806.1 PC807.2 106.85,63.84 v2(107.67,63.84)
  BOTTOM w0.254: PR804.1 107.67,63.97 v2(107.67,63.84) 107.67,63.69 108.06,63.3 PU800.4
N13272497: length 3.3
  BOTTOM w0.254: PU800.5 107.61,63.02 107.01,63.62 v3(106.31,63.62) 105.49,63.62 PC813.1
N13272521: length 2
  TOP w0.14: PR803.2 105.96,60.71 v1(105.4,60.16)
N13347359: length 6
  TOP w0.14: v3(112.52,113.12) 112.47,113.06 112.47,111.67 PR1119.2
  TOP w0.203: PU1100.47 115.4,109.36 113.92,110.84 PR1114.2 PR1119.2
N13351923: length 5.3
  TOP w0.203: v2(119.06,111.77) 119,111.71 118.81,111.71 118.62,111.51 PC1102.1 118.62,110.82 117.8,110 PU1100.41
  BOTTOM w0.14: v3(119.64,111.36) 119.23,111.77 v2(119.06,111.77)
  BOTTOM w0.254: v2(119.06,111.77) 119.06,111.39 118.85,111.17 PR1102.2
N13352071: length 5.4
  TOP w0.14: 112.02,111.17 PR1118.2 111.46,111.17 v3(110.96,111.67)
  TOP w0.203: PU1100.48 115,109.27 113.6,110.66 112.52,110.66 112.02,111.17
N13353452: length 12.5
  TOP w0.14: PR1113.2 109.73,105.14 109.51,104.92 108.04,104.92 105.8,107.16 v1(105.8,107.97)
  TOP w0.203: PU1100.5 112.88,106.49 112.8,106.56 110.64,106.56 110.33,106.24 PR1112.2
  TOP w0.254: PR1113.2 109.74,105.39 PR1112.2 109.55,106.43 PR1143.1
N17034077: length 3
  TOP w0.203: PU400.1 346.29,19.5 346.48,19.31 346.48,18.94 v3(347.06,18.36) 347.38,18.04 PR406.1
N17034092: length 1.1
  TOP w0.14: PR415.1 340.58,22.46 v3(340.16,22.88)
N17198654: length 2.3
  TOP w0.089: v1(205.93,71.33) 205.59,70.99 v2(205.59,70.87) RV479.1
  BOTTOM w0.089: UV1.AG10 205.16,71.3 v2(205.59,70.87)
N17832487: length 3.9
  BOTTOM w0.089: UV5.J1 217.89,100.1 218.35,99.64
  BOTTOM w0.14: v3(220.17,98.22) RV352.2 219.15,98.83 218.35,99.64
N17860472: length 5.1
  BOTTOM w0.089: 217.11,111.85 217.11,111.49 217.44,111.16 217.44,110.61 UV5.J13
  BOTTOM w0.14: v3(218.36,114.05) 217.65,113.34 RV354.2 217.11,111.85
N17888940: length 14.4
  TOP w0.089: v2(219.18,73.67) 219.18,73.46 218.94,73.22 218.62,73.22 RV327.1 218.47,73.07 v3(218.47,72.27)
  BOTTOM w0.102: v2(219.18,73.67) 219.44,73.94 219.44,74.94 219.65,75.14 219.65,77.13 219.43,77.34 219.43,84.78 UV1.J27
N17889477: length 19.3
  TOP w0.089: v1(217.5,69.97) 217.74,70.21 217.74,71.11 v2(217.38,71.47) 216.95,71.9 RV328.1
  BOTTOM w0.102: v2(217.38,71.47) 218.51,71.47 219.65,72.61 219.65,74.85 219.85,75.06 219.85,77.21 219.63,77.43 219.63,84.52 220.67,85.55 UV1.H27
N17890015: length 18.5
  TOP w0.089: v2(217.38,70.81) 217.19,71.01 RV329.1 216.3,70.54 214.58,70.54 v1(214.54,70.58)
  BOTTOM w0.102: v2(217.38,70.81) 218.12,70.81 219.85,72.54 219.85,74.77 220.05,74.97 220.05,77.3 219.84,77.51 219.84,83.02 220.61,83.8 UV1.H25
N17929472: length 9
  TOP w0.14: RV330.1 226.33,58.39 v2(226.31,58.4)
  BOTTOM w0.102: UV1.F2 222.72,64.65 223.1,64.27 223.1,63.78 224.68,62.2 225.12,62.2 226.71,60.61 v3(226.71,59.01) 226.71,58.8 v2(226.31,58.4)
N17930576: length 7.5
  TOP w0.14: RV332.1 225.44,58.12 v2(225.72,58.4)
  BOTTOM w0.102: v2(225.72,58.4) 225.08,59.04 v3(225.08,60.63) 225.08,61.58 224.85,61.81 224.74,61.81 222.7,63.85 UV1.F1
N18066258: length 6
  TOP w0.14: v3(227.98,98.61) 227.38,99.21 227.08,99.21 RV359.2 226.71,99.58 RV357.2 226.72,100.39 228.3,100.39 228.47,100.21 QV22.1
N18135138: length 2.2
  TOP w0.089: RV346.2 221.47,74.22 v2(221.5,74.25) 221.53,74.28 v3(222.48,74.28)
  BOTTOM w0.102: v2(221.5,74.25) 221.9,74.65 UV1.G14
N18135149: length 1.9
  TOP w0.089: RV347.2 221.73,79.48 v2(221.52,79.27) v3(221.1,78.85)
  BOTTOM w0.089: UV1.G20 v2(221.52,79.27)
N19849916: length 1.4
  TOP w0.14: v1(244.67,57.08) 244.35,56.77 PC713.2
N19912586:
  vias: v1(184.1,117.85) v2(181.94,117) v2(181.93,116.4) v2(181.93,115.77) v2(181.92,115.15) v2(185.37,117.1) v2(185.4,116.42) v2(185.42,115.71) v2(185.4,115.02)
N20180024: length 4.5
  TOP w0.14: v1(163.74,110.46) 162.75,109.47 PR1009.2
  TOP w0.254: v2(162.05,107.77) PC1029.1 PR1009.2
  BOTTOM w0.254: PC1029.1 v2(162.05,107.77)
N20194225: length 8
  TOP w0.14: v1(161.15,105.81) 161.52,106.18 v2(162.05,106.18)
  TOP w0.254: PR1002.2 162.69,106.82 v2(162.05,106.18)
  BOTTOM w0.254: PR1004.1 PC1009.1 163.7,102.44 162.21,103.94 162.21,105.34 PR1003.2 162.41,106.18 v2(162.05,106.18)
N25669355: length 5.1
  BOTTOM w0.089: UV6.J13 199.86,110.5 199.43,110.93 199.43,111.86
  BOTTOM w0.14: 199.43,111.86 199.43,112.88 RV365.2 200.42,113.34 v3(201.13,114.05)
N25669840: length 3.9
  BOTTOM w0.102: UV6.J1 199.86,99.09 v3(200.6,98.34) 201.12,97.82 RV363.2
N35393149: length 11.6
  BOTTOM w0.127: RV290.1 193.87,95.69 v1(193.87,94.52) 193.87,92.16 198.08,87.94 198.61,87.94 UV1.AP29
N48708347: length 1.8
  BOTTOM w0.14: PC600.2 283.15,26.08 v3(283.48,25.75)
N48708367: length 5
  TOP w0.14: v2(291.09,30.23) v1(289.84,30.23)
  TOP w0.254: PR610.1 v2(291.09,30.23)
  BOTTOM w0.203: PR608.2 PR610.1 v2(291.09,30.23) 290.89,30.04 PU600.7
N48708425: length 3.5
  BOTTOM w0.203: PU600.9 290.38,29.24 290.91,28.71 v3(290.91,28.63) 290.91,27.72 291.44,27.19 PR605.2
N49570867: length 4.3
  TOP w0.14: v3(131.53,4.5) 131.03,4 v2(131.03,4)
  TOP w0.254: v2(131.03,4) 130.68,3.66 PR501.1 PC500.1
  BOTTOM w0.254: PU500.1 131.53,4.32 131.21,4 v2(131.03,4) 130.65,3.62 PR500.1
N49570895: length 6
  TOP w0.14: v1(136.95,2.7) 136.59,3.06 PR508.1
  TOP w0.254: v2(133.92,3.49) 134.34,3.07 PR504.2 134.77,3.06 PR508.1
  BOTTOM w0.254: PC507.2 134.44,3.49 v2(133.92,3.49) 133.53,3.49 132.88,4.14 PU500.4
N49571010: length 4.3
  BOTTOM w0.14: v1(136.04,2.85) 136.04,3.79 PC512.1
  BOTTOM w0.203: PU500.5 133.33,4.24 133.61,3.96 135.4,3.96 PC512.1
N49571039: length 2.1
  TOP w0.14: v3(133.47,7.03) 132.96,6.52 PR503.2
  TOP w0.508: PC505.1 PR503.2
N50817763: length 5.3
  TOP w0.203: PC333.2 56.08,21.04 55.97,21.04 55.51,20.58 55.51,19.96 PU300.17
  TOP w0.254: PC333.2 56.26,21.8 v2(56.15,21.92)
  BOTTOM w0.14: v3(54.95,21) 56.05,21 PC333.2
  BOTTOM w0.254: v2(56.15,21.92) 56.26,21.8 PC333.2
N50817876: length 4.3
  TOP w0.203: 55.51,14.39 PU300.5
  TOP w0.254: PR316.1 55.19,12.71 55.19,13.32 v2(55.23,13.36) 55.23,14.1 55.51,14.39
  BOTTOM w0.14: PR312.2 54.17,12.67
  BOTTOM w0.254: v2(55.23,13.36) 54.9,13.03 PR311.2 54.17,12.67
N50817886: length 4.7
  TOP w0.14: v3(58.23,13.64) 58.23,13.09 PC327.1
  TOP w0.203: PU300.7 56.31,14.61
  TOP w0.254: 56.31,14.61 56.66,14.26 56.66,12.91 PR314.2 56.92,12.65 PC327.1
N50817889: length 4.9
  TOP w0.127: v3(59.87,13.76) 59.87,14.23 PR317.2
  TOP w0.203: PU300.8 57.51,15.91 58.31,15.11 v2(58.56,15.11)
  TOP w0.254: v2(58.56,15.11) 58.56,15.05 58.87,14.74 PR317.2
  BOTTOM w0.254: PC328.1 58.32,15.11 v2(58.56,15.11)
N50817917: length 2.4
  TOP w0.203: PR315.2 59.24,16.41 v3(58.31,16.41) 57.97,16.41 57.67,16.71 PU300.10
N50817928: length 6.9
  TOP w0.14: PR302.2 50.8,12.01 v3(50.61,12.2)
  TOP w0.203: 53.91,14.69 PU300.1
  TOP w0.254: PR302.2 51.69,12.2 52.17,12.68 PC313.2 52.43,13.15 52.43,13.55 v2(52.55,13.67) 52.55,13.95 53.04,14.44 53.66,14.44 53.91,14.69
  BOTTOM w0.254: PC314.1 52.87,14.54 52.55,14.22 v2(52.55,13.67)
N50817929: length 4.4
  TOP w0.203: 56.34,20 55.91,19.57 PU300.16
  TOP w0.254: 56.34,20 56.61,20.27 v2(56.64,20.27) 57.27,20.27 v3(57.49,20.49) 57.49,21.36 PR321.2
  BOTTOM w0.254: PR323.1 v2(56.64,20.27)
N50817930: length 5.6
  TOP w0.203: 54.31,14.52 PU300.2
  TOP w0.254: PR301.2 52.57,12.38 PC313.1 53.15,12.96 v2(53.15,13.83) 53.26,13.94 53.73,13.94 54.31,14.52
  BOTTOM w0.254: PC311.2 53.95,13.83 v2(53.15,13.83)
N50817943: length 24.6
  TOP w0.203: 54.31,19.74 PU300.20
  TOP w0.254: PC330.2 53.28,21.54 v2(53.39,21.47) PC331.1 53.39,20.66 54.31,19.74
  IN1 w0.254: v2(53.39,21.47) 52.88,21.98 49.95,21.98 49.81,22.12 46.37,22.12 45.97,21.72 40.76,21.72 39.14,23.34 37.81,23.34 v2(36.83,22.36)
  BOTTOM w0.254: PR310.2 37.09,23.57 36.89,23.38 36.89,22.42 v2(36.83,22.36)
N50817947: length 26.5
  TOP w0.14: v2(36.32,22.74) 36.01,22.74 v3(35.62,23.12)
  TOP w0.203: 54.71,20.02 PU300.19
  TOP w0.254: 54.71,20.02 54.31,20.43 PC331.2 54.06,21.01 v2(54.06,21.48) 54.06,21.99 PC332.1
  IN1 w0.254: v2(36.32,22.74) 37.42,23.83 39.15,23.83 40.91,22.07 45.82,22.07 46.22,22.48 46.3,22.55 49.88,22.55 50.09,22.34 53.21,22.34 v2(54.06,21.48)
  BOTTOM w0.254: v2(36.32,22.74) 36.32,23.38 36.13,23.57 PR310.3
N50817961: length 4.6
  TOP w0.203: PU300.15 56.31,19.48 56.45,19.62
  TOP w0.254: 56.45,19.62 58.41,19.62 v3(58.56,19.77) 58.56,21.18 PR322.2
N50817990: length 2.1
  TOP w0.203: 55.11,19.9 PU300.18
  TOP w0.254: 55.11,19.9 55.11,20.47 55.11,20.47 55.11,21.14 PR319.1
N52699143: length 4.2
  TOP w0.14: PC329.1 33.08,1.51 33.24,1.36 35.64,1.36 v1(36.09,1.81)
N52999986: length 68.7
  TOP w0.14: v2(25,76.67) 25,76.09 v1(25.21,75.88)
  TOP w0.254: v2(16.68,78.89) 16.98,78.59 PL104.2 ; PR100.1 43.75,33.68 43.44,33.98 PQ100.1 42.62,33.98 v2(41.87,33.23) 41.77,33.33 41.77,33.64 40.96,34.45 PR103.1
  IN2 w0.099: v2(25,76.67) 18.9,76.67 v2(16.68,78.89)
  IN5 w0.099: v2(41.87,33.23) 41.06,34.04 39.02,34.04 38.73,34.33 38.73,37.65 35.67,40.71 35.67,42.97 34.11,44.53 34.11,45.77 33.52,46.37 33.52,46.93 33.14,47.31 33.14,48.46 32.97,48.63 32.97,48.78 32.43,49.32 32.43,49.65 29.52,52.56 29.52,55.64 26.93,58.23 26.93,66.38 26.62,66.69 26.62,75.04 v2(25,76.67)
N55155823: length 5.3
  BOTTOM w0.127: QV11.3 49.7,23.2 49.42,22.92 49.42,22.56 49.58,22.4 RV120.1
  BOTTOM w0.14: v1(48.34,19.52) 48.59,19.77 RV119.2 48.71,20.7 CV168.2 48.9,21.92 RV120.1
N55155843: length 4.4
  BOTTOM w0.127: RV120.2 51.25,22.67 52.27,22.67
  BOTTOM w0.14: RV120.2 49.76,21.18 v3(49.76,20.52) ; QV12.1 52.45,22.49 52.27,22.67
N55341619: length 11.7
  BOTTOM w0.089: 246.8,91.07 246.61,90.88 245.66,90.88 245.25,90.47 UV10.J13
  BOTTOM w0.102: 246.8,91.07 247.4,91.66 247.4,96.99 246.54,97.84 v3(246.54,99.03) 246.54,99.48 RV391.2
N55342064: length 4.2
  BOTTOM w0.089: UV10.J1 234.93,90.47 234.76,90.64 234.63,90.64
  BOTTOM w0.14: 234.63,90.64 233.66,90.64 233.13,91.16 v3(233.13,91.5) RV389.2
N55351739: length 4.3
  BOTTOM w0.089: 234.63,72.12 234.67,72.12 234.98,72.43 UV9.J1
  BOTTOM w0.14: v3(231.93,71.48) 232.12,71.67 232.81,71.67 233.14,71.34 RV378.2 233.67,71.34 234.44,72.12 234.63,72.12
N55351833: length 11.5
  BOTTOM w0.089: UV9.J13 245.47,72.08 246.1,72.08 246.81,71.38
  BOTTOM w0.102: 247.05,64.97 247.05,71.13 246.81,71.38
  BOTTOM w0.127: 247.05,64.97 247.36,64.66 RV380.2
  BOTTOM w0.14: v3(248.53,66.06) 248.53,64.91 RV380.2
N55360027: length 3
  TOP w0.089: v3(212.68,85.68) 212.88,85.48 213.91,85.48 RV344.2 214.35,85.61 v2(214.75,86)
  BOTTOM w0.089: v2(214.75,86) 215.09,86.35 UV1.R28
N107416912: length 8.2
  TOP w0.14: v2(226.9,58.38) 227.22,58.06 RV501.2
  BOTTOM w0.102: v2(226.9,58.38) 227.13,58.61 v3(227.13,60.66) 227.13,60.87 225.39,62.61 224.74,62.61 UV1.E1
N108873638: length 4.1
  TOP w0.203: v2(345.95,18.55) 345.7,18.3 345.31,18.3 345.2,18.41 PU400.20
  BOTTOM w0.254: v2(345.95,18.55) 346.57,18.55 v3(346.84,18.28) 347.36,17.76 347.36,17.42 347.64,17.14 PR409.1
N109801960: length 4.1
  TOP w0.14: v1(234.13,103.23) 234.34,103.45 QZ6.3 QZ6.2 236.86,103.7 RZ12.2
N109970739: length 5.6
  TOP w0.14: v3(348.53,15.95) 348.03,16.44 PR410.1
  TOP w0.203: PU400.19 344.8,18.33 345.15,17.98 346.85,17.98 347.56,17.27 347.85,17.27 PR410.1
N110700740: length 2.5
  BOTTOM w0.14: v3(161.68,111.08) 161.68,110.73 162.32,110.09 PR1016.2
  BOTTOM w0.254: PR1016.2 PC1036.1
N110703687: length 1.7
  TOP w0.14: PR1008.2 v1(180.66,106.97)
N110833422: length 2.4
  TOP w0.14: PR1008.1 183.33,107.47 v1(184.16,106.63)
  vias: v2(181.64,107.07) v2(181.67,109.04) v2(181.67,108.4) v2(181.66,107.76) v2(185.29,109) v2(185.29,108.29) v2(185.32,107.6) v2(185.32,106.74)
N110836828: length 4.9
  TOP w0.14: v1(184.66,99.67) 181.69,99.67 180.38,100.97 PR1027.2
N110836908: length 2
  TOP w0.14: PR1027.1 184.06,100.97 v1(184.72,101.63)
  vias: v2(181.74,102.27) v2(181.74,100.95) v2(181.76,101.61) v2(181.76,100.31) v2(185.34,102.42) v2(185.34,101.1) v2(185.37,101.76) v2(185.37,100.47)
N110935541: length 2.6
  BOTTOM w0.14: v3(172.47,104.83) 172.47,104.02 171.42,102.98 171.12,102.98
N110936515: length 1.3
  BOTTOM w0.14: PC1047.1 v3(170.82,113.98)
N110936719: length 3.8
  TOP w0.14: v1(162.4,113.1) 161.99,112.7 v2(161.99,112.59)
  TOP w0.254: v2(161.99,112.59) 161.99,112.15 162.24,111.9 PR1018.2
  BOTTOM w0.254: PC1045.1 161.99,111.69 v2(161.99,112.59)
N110936976: length 4.4
  BOTTOM w0.14: v3(173.94,106) 173.2,105.27 173.2,101.88
N111036757: length 3.7
  BOTTOM w0.254: PR1020.2 164.59,111.31 v3(164.59,110.79) 165.19,110.19 166.29,110.19 166.47,110.02 PU1000.13
N111036762: length 2.8
  BOTTOM w0.254: PR1022.2 165.86,110.93 v3(166.02,110.77) 166.44,110.77 166.97,110.24 PU1000.14
N111036767: length 2.4
  BOTTOM w0.254: PR1023.2 166.75,111.43 v3(167.39,110.79) 167.47,110.7 PU1000.15
N111069434: length 4.5
  TOP w0.14: v1(249.11,48.76) 248.84,49.03 247.99,49.03 PR700.2
  TOP w0.203: PR701.2 247.05,50.3 246.82,50.54 PU700.25
  TOP w0.254: PR700.2 PR701.2
N111120800: length 3.8
  TOP w0.14: v1(246.25,46.38) 246.25,46.39 245.38,47.27 PC701.2
  TOP w0.203: PU700.21 244.39,48.31 244.98,47.71 PC701.2
N111796536:
  vias: v3(311.35,32.43)
N111796622: length 2
  TOP w0.14: v3(313.91,37.91) 313.03,37.03 RZ15.1
N111798152: length 2.3
  TOP w0.14: UZ1.12 311.71,34.21 311.51,34.01 v3(311.25,34.01) 310.91,33.66 CZ4.1
N111798158: length 4.3
  TOP w0.14: v3(308.67,36.67) 308.67,36.58 CZ6.1 311.38,35.06 311.43,35.01 UZ1.10
N113626745: length 6.6
  TOP w0.14: RV370.2 208.31,110.07 RV372.2 210.39,110.07 210.95,110.63 QV23.1 210.95,114.07 v1(211.15,114.27)
N113637608: length 5.3
  TOP w0.089: 245.41,65.34 RV385.2 245.34,65.64 245.94,66.24 v3(245.94,66.81)
  TOP w0.14: 245.41,65.34 245.41,64.76 245.86,64.31 245.86,63.98 245.62,63.74 QV24.1 244.68,63.74 244.65,63.71 RV383.2
N113676531: length 19.9
  TOP w0.127: RV398.2 v2(248.43,84.53) 248.43,83.46 247.65,82.69 QV25.1
  TOP w0.14: RV396.2 246.52,97.86 v3(246.33,97.67) v2(245.66,97.67)
  IN6 w0.102: v2(245.66,97.67) v3(246.33,97.67) 247.12,96.89 247.12,90.5 248.03,89.59 248.03,84.93 v2(248.43,84.53)
N113699173: length 1.6
  TOP w0.089: v2(208.94,85.93) 209.26,86.25 RV345.2
  BOTTOM w0.089: v2(208.94,85.93) 208.52,86.35 UV1.AC28
N116140097: length 12.3
  TOP w0.14: RV110.2 62.67,28.9 60.9,28.9 60.15,28.15 57.79,28.15 57.1,28.83 56.76,28.83 53.89,31.71 v2(53.89,31.71)
  BOTTOM w0.127: JEDP1.36 54.05,31.95 54.05,31.87 v2(53.89,31.71)
N116494866: length 2.6
  TOP w0.14: 235.12,51.79 234.94,51.61 234.94,50.03 v1(234.42,49.51)
N116496514: length 2
  TOP w0.14: v1(181.31,117.67) 180.85,117.22 PR1021.2
N118983880: length 2.9
  TOP w0.203: PU300.21 53.91,19.5 53.7,19.72 53.57,19.72 52.77,20.52
  TOP w0.254: 52.77,20.52 52.39,20.9 PR318.1
N119009545: length 44.3
  IN5 w0.099: v2(16.25,63.63) 17.17,63.63 18.72,65.17 18.72,76.55 19.13,76.96 19.13,78.98 19.66,79.51 19.66,98.26 19.55,98.37 v2(19.55,101.58)
  BOTTOM w0.14: v2(19.55,101.58) 19.55,103.32 v3(19.99,103.77)
  BOTTOM w0.254: PR203.2 16.25,64.1 v2(16.25,63.63) ; v2(19.55,101.58) 19.63,101.5 PQ205.1
N119009632: length 24.2
  IN5 w0.254: v2(17.43,69.41) 17.43,77.9 19.22,79.69 19.22,89.21 v2(18.68,89.75)
  BOTTOM w0.254: v2(18.68,89.75) 18.84,89.75 PR205.1 19.37,88.68 19.34,88.65 PR201.2 19.34,87.38 PC200.2
N119009672: length 39.7
  TOP w0.14: v3(20.87,92.49) 20.87,93.05 v2(20.5,93.42)
  IN5 w0.099: v2(20.5,93.42) 20.82,93.1 20.82,92.19 20.19,91.57 20.19,79.38 19.54,78.73 19.54,76.7 19.18,76.33 19.18,63.9 18.96,63.68 v2(18.96,63.66)
  BOTTOM w0.254: v2(20.5,93.42) 20.5,93.94 20.78,94.22 PQ204.1 ; PC220.2 19.65,64 19.3,63.66 v2(18.96,63.66) 17.21,63.66 16.97,63.9 PR203.1 17.1,64.42 17.69,64.42 PR200.2 17.96,64.3 18.21,64.55 18.21,65.08 18.53,65.4 PQ201.4
N119186848: length 3
  BOTTOM w0.14: v3(319.15,36.62) 318.63,36.62 RI23.1 318.14,35.29 318.41,35.02 UI3.7
N119186852: length 7
  TOP w0.14: RI36.1 316.92,33.52 316.15,32.76 v3(315.39,32.76) 314.45,32.76 v2(314.3,32.91)
  BOTTOM w0.14: UI3.5 314.53,33.14 v2(314.3,32.91)
N119942216: length 1
  TOP w0.14: v2(25.38,77.25) 25.68,77.25 v1(26.16,77.73)
N119944306: length 2.6
  TOP w0.203: PU300.3 54.71,14.25
  TOP w0.254: 54.71,14.25 54.71,14.19 v3(54.4,13.88) 54.17,13.65 PR303.2
N119944438: length 3.2
  TOP w0.14: v2(50.93,13.41) 50.41,12.89 49.35,12.89 v1(49.15,13.09)
  BOTTOM w0.508: PR304.2 50.93,12.58 v2(50.93,13.41)
N119944456: length 7.3
  TOP w0.203: PU300.6 55.91,14.4
  TOP w0.254: PC322.2 55.81,12.87 v2(55.81,13.37) 56.05,13.6 v3(56.05,13.84) 56.05,14.27 55.91,14.4
  BOTTOM w0.254: PR308.1 55.69,14.35 55.69,13.49 v2(55.81,13.37) 55.77,13.33 PR305.1 55.98,12.45 56.03,12.45 56.8,11.69 57.24,11.69 57.42,11.52 PQ304.1
N119964762: length 3.3
  BOTTOM w0.14: PR209.2 20.75,102.55 v3(20.45,102.24)
  BOTTOM w0.254: PQ205.2 21.52,101.61 21.87,101.95 PR209.2
N119965248: length 33.8
  TOP w0.14: v2(22.81,65.48) 22.23,66.06 v1(22.23,66.37)
  TOP w0.254: v2(22.81,65.48) 23.43,65.48 PC222.1
  IN5 w0.099: v2(25.46,84.31) 25.46,83.99 23.29,81.82 23.29,78.53 21.43,76.66 21.43,66.86 v2(22.81,65.48)
  BOTTOM w0.254: v2(25.46,84.31) 26.43,84.31 26.67,84.55 PR224.1 25.31,86.52 25.31,88.49 25.86,89.04 26.68,89.04 27.04,89.39 PQ217.3 27.04,91.44 PR223.1
N119965252: length 9.2
  BOTTOM w0.14: v3(20.61,55.95) 22.18,54.38 PQ220.1 22.18,53.78 22.56,53.4 23.2,53.4 23.94,52.66 24.99,52.66 25.77,53.44 25.77,54.63 PR232.2
N119965290: length 31.2
  TOP w0.14: PC222.2 25.15,67.26 v1(25.27,67.38)
  TOP w0.254: PC222.2 PC289.2 25.87,64.52 v2(25.91,64.56)
  IN5 w0.254: v2(25.91,64.56) 25.41,64.56 25.27,64.71 25.27,65.95 23.5,67.73 23.5,76.71 25.05,78.26 25.05,79.41 26.59,80.96 26.59,82.53 v2(28.23,84.17)
  BOTTOM w0.254: PQ217.1 26.07,86.67 PR224.2 27.59,85.16 PR226.1 28.23,84.55 v2(28.23,84.17)
N119967293: length 7.8
  BOTTOM w0.254: PQ219.1 27.75,92.55 28.58,91.73 28.58,87.54 v3(28.09,87.05) 28.09,86.55 PR226.2
N119982519: length 16.3
  TOP w0.254: PR227.2 v2(25.91,65.22)
  TOP w0.508: PC288.2 26.81,57.97 v2(25.78,57.97)
  IN2 w0.508: v2(25.78,57.97) 24.89,57.97 22.99,59.88 v2(22.99,60.66) 22.99,62.73 25.48,65.22 v2(25.91,65.22)
  BOTTOM w0.508: PR232.1 PR222.2 26.73,56.66 PC208.2 26.73,57.68 26.44,57.97 v2(25.78,57.97)
N120139517: length 4.9
  BOTTOM w0.089: UH2.E1 99.33,23.91 100.66,25.23 101.98,25.23
  BOTTOM w0.14: RH71.2 102.68,24.74 v3(102.46,24.95) 102.19,25.23 101.98,25.23
N120174690: length 1.3
  TOP w0.089: v2(93.16,7.85) 92.72,7.85 T20.1
  BOTTOM w0.089: UH2.AV15 92.92,7.85 v2(93.16,7.85)
N120176772: length 4.4
  BOTTOM w0.089: UH2.V44 77.98,17.59 77.93,17.64 77.39,17.64 77.19,17.84 77.12,17.84 77.07,17.88 76.97,17.88 76.93,17.93 76.78,17.93 76.63,18.07 75.06,18.07
  BOTTOM w0.14: 75.06,18.07 75.04,18.07 T2.1
N120176782: length 4
  BOTTOM w0.089: T4.1 76.87,20.91 77.48,20.91 77.51,20.94 77.9,20.94 77.93,20.91 78.27,20.91 78.51,21.14 UH2.L43
N120176822: length 2.1
  TOP w0.089: T8.1 v2(81.09,3.56)
  BOTTOM w0.089: UH2.BD36 81.8,4.6 81.09,3.9 v2(81.09,3.56)
N120177456: length 3.2
  BOTTOM w0.089: UH2.BD17 91.35,4.48 91.35,3.06 91.12,2.83 91.02,2.83 90.87,2.68 90.87,1.76 T17.1
N120264964: length 1.1
  TOP w0.381: RT1.1 28.03,38.4 v2(27.36,38.4)
  BOTTOM w0.089: v2(27.36,38.4) UT1.N16
N120290495: length 2.2
  TOP w0.089: v2(28.01,42.94) 28.39,43.33 28.98,43.33 RT2.1
  BOTTOM w0.102: UT1.N6 v2(28.01,42.94)
N120293690: length 5.5
  TOP w0.14: QV13.2 21.39,78.64 22.09,77.93 22.09,77.05 22.47,76.67 v1(22.47,76.08)
  TOP w0.508: QV13.2 20.07,78.64 19.76,78.94 RV121.2
N120361079: length 3
  TOP w0.127: RD9.1 269.25,6.36 v2(269.27,6.35)
  TOP w0.14: v1(269.83,6.63) 269.55,6.35 v2(269.27,6.35)
  BOTTOM w0.127: v2(269.27,6.35) 269.27,6.33 268.73,5.79 JNGFF2.60
N120361841: length 1.3
  TOP w0.14: RZ18.1 58.74,2.63 v3(58.05,1.94)
N120361881: length 1.5
  TOP w0.254: UZ4.6 56.58,2.47 57.07,1.98 CZ20.1
N120533764: length 4.2
  TOP w0.14: v3(281.76,18.57) 281.76,17.77 RE76.2 281.78,16.06 UE4.14
N120533798: length 7.1
  TOP w0.14: v1(283.93,19.57) 284.37,19.13 284.37,17.53 284.23,17.39 284.23,16.75 283.77,16.29 282.99,16.29 282.63,15.93 RE75.2 282.28,15.41 UE4.13
N120533808: length 1.8
  TOP w0.14: UE4.12 282.61,14.76 RE74.2
N120533818: length 4.2
  TOP w0.14: v3(283.62,11.82) 283.62,12.29 282.63,13.28 RE73.2 282.25,14.11 UE4.11
N120553340: length 9.2
  TOP w0.14: UE3.A59 293.2,14.13 293.04,14.28 292.39,14.28 v2(291.95,13.84) ; v1(288.63,17.83) 288.39,17.59 288.39,16.37 288.27,16.25 288.07,16.25 287.91,16.09 RE43.1 RE44.1 289.1,15.63 v2(289.59,15.63)
  BOTTOM w0.14: v2(291.95,13.84) 291.38,13.84 v2(289.59,15.63)
N120553518: length 6.5
  TOP w0.14: v3(291.11,23.45) 292.05,23.45 RE111.1 292.18,22.97 292.38,22.77 292.86,22.77 293.28,22.35 293.28,21.03 293.9,20.41 293.9,19.59 294.12,19.38 UE3.B52
N120553639: length 13.2
  TOP w0.14: UE3.B61 294.76,14.88 294.82,14.94 295.48,14.94 v2(295.92,14.5) ; RE55.1 287.61,18.88 v2(287.73,19.01)
  BOTTOM w0.14: v2(295.92,14.5) 295.49,14.93 294.96,14.93 293.43,16.46 292.99,16.46 292.99,16.46 292.64,16.46 292.63,16.46 292.56,16.46 292.07,15.96 291.42,15.96 289.25,18.13 288.61,18.13 v2(287.73,19.01)
N120554151: length 2.2
  TOP w0.14: v3(312.71,19) 312.7,18.98 RE69.2 310.9,18.98 310.7,18.79 QE10.2
N120554627: length 8.1
  TOP w0.14: RE62.2 CE48.1 308.15,17.87 308.51,18.23 311.3,18.23 311.53,18.46 312.71,18.46 313.57,19.32 v1(313.57,20.35)
N120918225: length 13.2
  TOP w0.254: PR303.1 54.17,11.25 v3(54.63,10.78) 54.82,10.59 v2(55.42,10.59) 55.42,10.44 55.41,10.43 55.41,10.03 55.72,9.72 56.45,9.72 57.02,9.15 PD303.1
  BOTTOM w0.254: PD304.1 57.34,9.47 56.14,10.68 56.14,11.39 PR305.2 55.77,10.94 v2(55.42,10.59) 54.53,10.59 54.23,10.3 53.6,10.3 52.77,11.12 PR399.1
N120970730: length 2.2
  TOP w0.14: v1(145.8,100.21) 146.31,100.72 PR1200.2
N120971346: length 4.9
  BOTTOM w0.14: 148.43,116.35 148.53,116.25 151.87,116.25 v1(152.89,117.27)
N120971480: length 1.9
  TOP w0.14: v1(158.89,109.91) 158.97,109.99 PR1208.2
N120976432:
  vias: v1(158.87,108.04) v2(159.41,106.38) v2(159.77,105.88) v2(160.05,106.41) v2(160.38,105.88) v2(160.61,108.26) v2(160.71,106.38) v2(160.94,108.77) v2(161.21,108.24)
N120977691: length 0.7
  TOP w0.14: v2(147.4,115.25) 147.4,115.6 v1(147.65,115.86)
  vias: v2(146.85,114.69) v2(147.47,114.64) v2(147.98,115.25) v2(148.08,114.64) v2(148.59,115.22) v2(148.67,114.61)
N121029055: length 4
  BOTTOM w0.089: 91.63,26.74 91.24,26.35 91.24,25.56 91.18,25.5 UH2.B18
  BOTTOM w0.305: RH108.1 90.78,28.29 v3(91.25,27.82) 91.63,27.44 91.63,26.74
N121029061: length 4.6
  BOTTOM w0.089: UH2.C17 91.28,24.88 90.95,25.21 90.95,25.53 91.06,25.64 91.06,26.71 90.93,26.83
  BOTTOM w0.305: 90.93,26.83 v3(89.97,27.8) 89.87,27.9 RH108.2
N121033373: length 2.2
  TOP w0.203: PU400.6 345.2,22.21 345.39,22.4 345.67,22.4 v2(345.77,22.5) 346.08,22.81 PR408.2
N121033408: length 4.1
  TOP w0.203: PR407.2 v2(345.12,22.87) 345.12,22.74 344.8,22.42 PU400.7
  BOTTOM w0.14: v3(346.38,24.32) 345.56,23.49 PR407.2
  BOTTOM w0.254: PR407.2 v2(345.12,22.87)
N121070696: length 4.6
  BOTTOM w0.102: UH2.AG3 98.34,12.75 98.62,13.03 99.06,13.03 99.37,13.33
  BOTTOM w0.305: RH109.1 100.94,14.41 v3(100.92,14.39) 100.92,13.95 100.3,13.33 99.37,13.33
N121070776: length 8
  TOP w0.089: v2(175.65,55.81) 175.7,55.86 176.42,55.86 v3(176.67,56.12)
  BOTTOM w0.254: UH1.G2 174.31,60.21 174.57,60.21 174.88,59.89 174.88,59.01 175.26,58.63
  BOTTOM w0.381: 175.26,58.63 175.76,58.13 175.76,55.92 v2(175.65,55.81) 175.6,55.81 175.24,55.45 175.24,55.37 174.74,54.87 RH24.2
N121163993: length 6.5
  TOP w0.089: v2(173.41,58.05) 173.15,57.8 v3(173.15,57.34)
  BOTTOM w0.254: v2(173.41,58.05) 173.53,58.18 173.53,58.65 173.06,59.14 173.06,60.11 UH1.J2
  BOTTOM w0.381: RH150.2 172.68,55.51 173.21,56.04 173.21,57.86 v2(173.41,58.05)
N121163994: length 4.3
  TOP w0.089: v2(174.28,57.22) 174.3,57.24 174.34,57.24 174.36,57.22 174.58,57.22 v3(174.87,56.93)
  BOTTOM w0.254: 174.08,58.11 174.08,58.62 173.64,59.06 UH1.H1
  BOTTOM w0.381: RH149.2 174.7,56.79 v2(174.28,57.22) 174.37,57.31 174.37,57.79 174.25,57.92 174.25,57.94 174.08,58.11
N121163995: length 5.4
  TOP w0.089: v2(175.25,56.22) v3(175.25,55.37)
  BOTTOM w0.254: UH1.G1 174.5,58.44 174.58,58.37
  BOTTOM w0.381: RH148.2 174.79,55.76 v2(175.25,56.22) 175.25,57.3 174.88,57.67 174.88,58.05 174.78,58.15 174.78,58.16 174.58,58.37
N121174975: length 20.8
  IN6 w0.089: 101.98,4.07 100.26,4.07 97.89,1.7 93,1.7 92.72,1.98 92.72,2.74 92.58,2.88 91.64,2.88 v2(91.24,2.49)
  IN6 w0.099: 101.98,4.07 102.46,4.07 103.23,4.83 103.48,4.83 103.56,4.91 103.56,5.24 v2(103.48,5.32)
  BOTTOM w0.089: UH2.BC17 91.4,4.91 91.68,4.63 91.68,4.45 91.52,4.3 91.52,2.99 91.24,2.7 v2(91.24,2.49)
  BOTTOM w0.127: v2(103.48,5.32) 103.94,5.77 104.52,5.77 104.83,5.47 104.83,5.22
  BOTTOM w0.14: 104.83,5.22 105.21,4.83 RH168.1
N121388945: length 8
  BOTTOM w0.089: UH2.AJ4 98.15,11.94 98.95,11.94 99.05,11.85 99.46,11.85 99.66,11.64 100.69,11.64 101.39,12.34 101.39,12.77 101.64,13.03 101.98,13.03
  BOTTOM w0.127: v3(103.82,13.1) 103.75,13.03 101.98,13.03
  BOTTOM w0.14: v3(103.82,13.1) 104.2,13.48 RH189.1
N121479122: length 8.9
  BOTTOM w0.254: RH465.1 RH466.1 157.12,92.15 158.01,92.15 158.24,91.92 158.24,91.09 v1(158.99,90.34) 159.08,90.26 159.08,88.34 158.94,88.2 158.94,87.97 UH1.AG38
N121480352: length 14
  TOP w0.14: v1(176.19,90.74) 176.54,91.09 v2(176.9,91.09)
  IN4 w0.254: v2(176.9,91.09) 176.77,90.97 172.86,90.97 v2(169.15,87.26)
  BOTTOM w0.254: RH470.1 176.86,91.13 v2(176.9,91.09) 176.86,91.06 RH469.1 ; v2(169.15,87.26) 169.2,87.26 169.29,87.17 169.78,87.17 170.36,86.6 170.36,86.11 UH1.M37
N121480355: length 16.1
  TOP w0.14: v2(177.51,91.1) 177.78,91.1 v1(178.18,90.7)
  IN4 w0.254: v2(168.89,87.82) 168.89,87.82 172.43,91.36 176.29,91.36 176.53,91.6 177.22,91.6 177.51,91.31 v2(177.51,91.1)
  BOTTOM w0.254: RH201.1 177.92,90.48 177.51,90.89 v2(177.51,91.1) 177.51,91.37 177.85,91.72 RH202.1 ; v2(168.89,87.82) 169.67,87.82 170.75,86.73 UH1.M38
N121480375: length 2.2
  TOP w0.127: v2(164.91,66.61) 164.55,66.25 v3(164.47,66.25)
  TOP w0.305: RH473.2 164.27,67.24 v2(164.91,66.61)
  BOTTOM w0.305: UH1.Y12 164.62,66.9 v2(164.91,66.61)
N121507165: length 6
  BOTTOM w0.254: UH1.BR25 138.1,77.14 137.78,76.82 137.23,76.82 136.8,76.39 v3(134.84,76.39) 133.33,76.39 132.86,75.92 RH57.2
N121507167: length 6.4
  BOTTOM w0.254: UH1.BP25 138.37,77.59 136.86,77.59 136.67,77.41 v3(135.65,77.41) 133,77.41 RH58.2
N121507169: length 4.7
  BOTTOM w0.203: UH1.BT29 137.18,80.08 v3(134.78,80.08) 134.01,80.08 133.4,79.47 RH166.2
N121616264: length 1.1
  TOP w0.14: 221.9,10.37 221.54,10.37 v3(221.01,9.84)
N121616283: length 1.4
  TOP w0.127: CE65.1 223.19,10.58 223.01,10.39 UE6.6
N121617744: length 4.8
  TOP w0.14: UZ7.12 241.19,5.86 v2(241.62,6.29) 241.36,6.55 240.79,6.55 240.6,6.74 CZ37.1
  BOTTOM w0.14: v1(243.21,4.77) 243.13,4.77 v2(241.62,6.29)
N121617748: length 5.6
  TOP w0.127: UZ7.10 241.99,5.9 242.25,6.17 242.25,6.87 CZ39.1
  TOP w0.14: CZ39.1 242.6,7.84 242.6,10.18 v3(242.89,10.47)
N121617759:
  vias: v1(238.84,5.47)
N121617766:
  vias: v1(243.98,5.57)
N121673930: length 1.9
  TOP w0.14: PR1112.1 107.89,106.24 v3(107.82,106.18)
  TOP w0.254: PR1112.1 108.83,105.43 PC1106.2
N121674134: length 3.6
  BOTTOM w0.14: PC1130.1 116.59,96.96 v3(116.78,96.77)
  BOTTOM w0.254: PR1140.2 117.73,99.28 117.73,98.7 116.83,97.8 PC1130.1
N121674335: length 3.1
  TOP w0.14: PC1118.1 124.89,104.39 v3(124.8,104.3)
  TOP w0.254: v2(124.22,105.34) 124.88,105.34 PC1118.1
  BOTTOM w0.254: v2(124.22,105.34) 124.22,105.13 124.89,104.45 PR1125.2
N121710332: length 10.5
  BOTTOM w0.254: UH1.AG37 159.1,85.71 159.32,85.94 159.32,87.99 159.47,88.15 159.47,90.53 158.67,91.33 v1(158.67,92.08) 158.67,92.11 158.27,92.51 157.13,92.51 RH197.2 RH198.1
N121712022: length 6.4
  BOTTOM w0.254: v2(155.64,88.05) 155.65,88.05 RH204.1 RH203.2 157.1,89.34 157.86,89.34 158.13,89.07 158.13,88.39 158.23,88.29 158.23,86.43 158.17,86.36 UH1.AH38
N121718437: length 5.5
  TOP w0.127: v1(98.4,36.25) 98.4,36.57 97.79,37.18 v2(97.28,37.18)
  TOP w0.14: DE7.1 98.79,34.97 RE82.2 98.17,36.03 v1(98.4,36.25)
  BOTTOM w0.127: v2(97.28,37.18) 97.3,37.2 JFAN1.3
N121718548: length 7.4
  TOP w0.14: v2(323.34,40.97) 322.96,40.59 DE8.1 322.21,40.09 322.21,39.89 RE84.2 321.1,38.77 319.41,38.77 v3(319.04,39.14)
  BOTTOM w0.14: JFAN2.3 322.5,40.44 323.03,40.97 v2(323.34,40.97)
N121775507: length 4.8
  TOP w0.203: v2(58.55,15.76) 58.18,15.76 57.63,16.31 PU300.9
  TOP w0.254: v2(58.55,15.76) 58.68,15.63 PR324.2
  BOTTOM w0.14: PR325.1 57.61,16.71 57.61,17.3 v3(57.75,17.43)
  BOTTOM w0.254: PR325.1 58.15,16.52 58.55,16.13 v2(58.55,15.76)
N121795600:
  vias: v1(145.37,104.07) v2(145.24,102.93) v2(145.21,102.24) v2(145.82,103.01) v2(145.8,102.32) v2(145.85,101.74) v2(146.5,102.99) v2(146.5,102.36) v2(146.51,101.71)
N121865189: length 2.5
  BOTTOM w0.254: PQ219.2 27.1,95.92 v3(26.7,96.33) PR267.2
N121865231: length 4.6
  TOP w0.14: v2(26.64,99.91) 26.68,99.91 27.62,98.97 v1(28.51,98.97)
  BOTTOM w0.14: v2(26.64,99.91) 26.84,100.11 PR235.2
  BOTTOM w0.254: PR235.2 27.29,100.06 27.29,99.23 PQ232.2
N121981266: length 31.9
  TOP w0.14: v2(110.36,107.96) 110.36,108.09 109.6,108.85 v3(109.6,109.1)
  TOP w0.254: v2(110.36,107.96) 110.49,108.09 PR1105.1
  IN2 w0.254: v2(104.33,83.96) 103.59,84.69 103.59,92.17 103.72,92.29 103.72,94.26 105.22,95.76 105.22,100.94 107,102.71 108.01,102.71 108.89,103.59 108.89,106.49 v2(110.36,107.96)
  BOTTOM w0.254: v2(110.36,107.96) 109.69,107.29 PR1106.2 ; v2(104.33,83.96) 104.35,83.94 PH1100.2
N121981305: length 2.7
  BOTTOM w0.14: v3(120.97,87.88) 121.37,87.47 121.37,86.58 PR1122.2
  BOTTOM w0.254: PH1102.1 PR1122.2
N121981509: length 5.6
  BOTTOM w0.14: PH1101.2 113.73,91.4 113.98,91.15 114.93,91.15 115.82,92.03 115.82,92.29 116.22,92.7 v1(117.27,92.7)
  BOTTOM w0.254: PR1121.1 PH1101.2
N121981539: length 4
  BOTTOM w0.14: v3(149.05,97.33) 149.62,97.9 149.62,99.46 PR1136.1
  BOTTOM w0.254: PH1103.2 150.11,100.88 PR1136.1
N121983108: length 3.1
  BOTTOM w0.254: PR1025.2 171.32,100.17 171.32,99.45 171.77,99.01 172.11,99.01 172.28,98.84 PU1001.1
N121994793: length 101.7
  TOP w0.14: v2(166.89,103.92) 166.89,104.06 v1(166.55,104.4)
  TOP w0.254: PR913.1 166.89,103.77 v2(166.89,103.92) ; PU900.1 219.69,52.7 220.16,53.16 v2(220.16,53.54) PC900.1 220.35,54.17 220.79,53.73 PR900.1
  IN1 w0.099: v2(220.16,53.54) 220.56,53.94 220.56,59.85 219.98,60.44 217.02,60.44 215.58,61.87 212.71,61.87 212.32,62.26 195.34,62.26 194.84,62.76 194.84,90.68 189.8,95.73 179.34,95.73 178.97,96.1 176.51,96.1 175.74,96.86 175.74,99.72 173.38,102.08 169.05,102.08 168.25,102.88 167.93,102.88 v2(166.89,103.92)
  BOTTOM w0.254: v2(220.16,53.54) PC900.1
N121994795: length 3.9
  TOP w0.254: PU900.4 220.01,51.35 v3(220.43,50.92) 220.55,50.81 PR906.1 PR904.2 PC907.2
N121994837: length 5.6
  TOP w0.14: v1(221.92,46.54) 221.23,47.23 PC912.1
  TOP w0.254: PC912.1 220.79,48.4 220.79,49.89 219.79,50.9 PU900.5
N121994849: length 1.4
  TOP w0.14: v1(220.3,45.58) 220.09,45.78 PR903.2
N122017154:
  vias: v2(138.18,111.87)
N122018494: length 7.7
  BOTTOM w0.14: v1(164.22,115.1) 164.22,115.88 162.84,117.26 162.84,118.38 162.34,118.88 159.21,118.88
N122282431: length 4.2
  BOTTOM w0.14: UR1.28 336.5,36.28 336.75,36.03 337.23,36.03 337.68,35.58 337.94,35.58 338.43,35.09 v3(338.43,34.96) 338.42,34.96 338.42,34.15 RR9.1
N122314333: length 7.2
  BOTTOM w0.254: 158.66,88.63 158.57,88.54 158.57,86.02 158.27,85.71 UH1.AH37 ; 158.66,88.63 158.66,89.05 158,89.71 157.11,89.71 156.58,90.25 RH472.1 RH471.1 ; 158.66,88.63 v1(158.65,88.63)
N122397475: length 7.9
  BOTTOM w0.076: 179.9,80.71 179.74,80.87 174.46,80.87 UH1.G29
  BOTTOM w0.14: v3(180.2,79.08) 180.54,79.42 RH145.1 179.9,80.71
