# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BAT2_LED#: length 166.8
  TOP w0.14: v2(301.92,28.14) 302.69,28.91 RE119.1 303.86,29.24 v3(303.86,30.11)
  IN1 w0.099: v2(167.13,9.48) 168.13,10.48 174.26,10.48 175.79,8.94 182.37,8.94 183.37,9.94 205.96,9.94 206.13,9.77 211.19,9.77 213.33,7.63 220.83,7.63 221.23,8.04 227.75,8.04 227.88,8.16 231.88,8.16 232.16,7.88 245.37,7.88 245.67,7.58 250.75,7.58 251.48,6.84 257.44,6.84 258.67,8.07 262.57,8.07 262.63,8.02 266.61,8.02 267.08,8.49 271.94,8.49 276.9,13.44 282.48,13.44 284.14,15.1 v2(284.51,15.1)
  IN3 w0.091: v2(296.5,29.32) 296.5,29.09 296.72,28.86 301.19,28.86 v2(301.92,28.14)
  BOTTOM w0.14: v2(284.51,15.1) 284.51,17.63 284.89,18.01 284.89,20.19 288.56,23.86 289.61,23.86 290.07,24.32 294.32,24.32 294.84,24.85 294.84,25.92 295.68,26.76 295.68,28.23 296.5,29.04 v2(296.5,29.32) ; v2(167.13,9.48) 166.8,9.15 166.8,8.23 166.38,7.81 165.07,7.81 164.5,8.38 163.48,8.38 163.15,8.05 161.2,8.05 160.8,8.45 159.77,8.45 159.27,8.95 JKB.9
BAT_LED#_LV1: length 5.8
  TOP w0.14: LED1.1 347.92,108.09 v3(347.28,107.45) 347.28,106.05 346.52,105.29 RL5.2
BAT_LED#_LV2: length 3.9
  TOP w0.14: RL4.2 v3(347.22,104.4) 348.91,104.4 LED2.1
BAT_LED#_LV3: length 4.9
  TOP w0.14: LED3.1 v3(347.15,102.74) 346.5,103.39 RL3.2
BAT_LED#_LV4: length 7.5
  TOP w0.14: RL2.2 346.46,102.37 347.73,101.1 v3(347.73,100.08) 347.73,98.56 LED4.1
BAT_LED#_LV5: length 9.8
  TOP w0.14: LED5.1 347.04,95.65 v3(347.04,96.85) 347.04,100.34 346.03,101.35 RL1.2
BATBTN#: length 157.6
  TOP w0.14: UE3.A63 293.22,12.13 292.67,11.58 292.67,9.99 v1(292.55,9.86) 292.55,9.76 v2(292.14,9.36) 291.53,9.36 291.32,9.14 RP19.4 ; SW2.3 SW2.4 349.06,115.36 348.1,115.36 346.71,113.98 DL1.2 345.17,113.98 v2(345.05,113.85)
  IN6 w0.099: v2(292.14,9.36) 293.61,10.83 294.26,10.83 295.05,10.04 303.12,10.04 303.46,9.7 311.58,9.7 314.78,12.91 314.78,16.17 318.72,20.11 318.72,23.57 319.95,24.8 319.95,25.46 319.64,25.77 319.33,25.77 319.11,25.99 319.11,26.43 323.86,31.18 323.86,35 324.4,35.54 324.4,37.71 327.81,41.12 327.81,51.6 328.03,51.82 328.03,52.23 329.65,53.85 329.65,57.51 333.67,61.53 333.67,83.03 338.49,87.85 342.82,87.85 344.93,89.97 344.93,104.35 344.1,105.18 344.1,112.9 v2(345.05,113.85)
BATDRV#: length 46
  TOP w0.254: PR319.2 55.18,22.54 v2(55.39,22.74)
  IN2 w0.254: v2(25.46,24.52) 25.78,24.52 28.11,26.86 28.11,27.52 28.59,28 32.62,28 34.25,29.63 37.81,29.63 38.99,28.44 41.89,28.44 43.41,26.92 45.42,26.92 46.96,25.38 50.47,25.38 50.64,25.55 51.78,25.55 52.7,24.62 54.05,24.62 55.39,23.28 v2(55.39,22.74)
  IN5 w0.254: v2(28.96,19.69) 29.29,20.02 29.29,23.3 28.07,24.52 v2(25.46,24.52)
  BOTTOM w0.14: v3(56.26,23.88) 55.39,23.01 v2(55.39,22.74)
BATT++: length 8.1
  TOP w0.14: 27.36,16.81 25.9,16.81 v1(25.02,15.93) ; 27.36,16.81 26.99,17.18 26.56,17.18 v1(26.35,17.38) ; 27.36,16.81 PC110.1 27.56,16.33 26.93,15.69 v1(26.85,15.69)
  TOP w0.508: PC110.1 PC109.1 27.14,17.7 26.61,18.23 v2(26.61,18.68)
BATT_LED#_LV1: length 158.7
  TOP w0.14: v2(273.71,13.65) 274.17,14.11 UE4.25 ; v2(336.3,106.33) v3(337,106.33) 343.94,106.33 344.36,106.75 345.06,106.75 345.25,106.56 345.25,105.99 345.06,105.8 344.55,105.8 344.22,105.47 RL5.1 343.9,104.97 340.49,104.97 340.17,104.66 340.17,102.76 340.39,102.55 RP24.9
  IN6 w0.099: v2(336.3,106.33) 336.17,106.2 336.17,90 328.66,82.5 328.66,78.83 326.14,76.3 326.14,71.13 327.57,69.7 327.57,62.64 325.53,60.59 325.53,58.13 326.27,57.39 326.27,55.95 323.5,53.17 323.5,52.89 321.29,50.68 321.29,45.25 320.18,44.14 318.36,44.14 312.79,38.57 312.79,36.85 310.94,35 310.94,31.93 310.58,31.57 310.58,29.22 311.06,28.74 311.06,23.44 309.85,22.22 308.71,22.22 307.85,21.36 304.3,21.36 303.78,20.84 296.81,20.84 296.65,21 294.62,21 294.21,20.59 294.21,19.71 293.28,18.78 290.99,18.78 290.61,18.4 287.77,18.4 287.62,18.25 285.11,18.25 284.3,17.44 284.3,16.78 282.56,15.04 275.1,15.04 v2(273.71,13.65)
BATT_LED#_LV2: length 144.2
  TOP w0.14: v2(272.54,11.97) 272.54,12.34 v3(273.09,12.89) 273.37,13.17 273.93,13.17 274.22,13.46 UE4.26 ; RP24.4 v2(343.28,103.85) 343.67,103.85 RL4.1
  IN6 w0.099: v2(343.28,103.85) 342.46,103.02 342.46,95.89 329.59,83.03 329.59,77.62 327.34,75.37 327.34,71.26 328.38,70.22 328.38,60.73 327.21,59.56 327.21,55.65 325.7,54.15 325.7,53.32 323.49,51.11 323.49,45.4 317.22,39.13 317.22,33.99 314.79,31.56 314.79,29.27 312.42,26.9 312.42,24.23 309.16,20.96 304.46,20.96 303.85,20.35 295.42,20.35 292.96,17.89 291.5,17.89 291.19,18.2 287.86,18.2 287.7,18.05 285.19,18.05 284.5,17.36 284.5,16.7 282.64,14.84 275.73,14.84 273.55,12.66 273.23,12.66 v2(272.54,11.97)
BATT_LED#_LV3: length 141.3
  TOP w0.14: RP24.3 v2(343.22,103.2) 343.66,103.2 343.85,103.39 RL3.1 ; v3(272.63,11.35) 272.63,11.34 v2(273.23,11.93) 274.1,12.81 UE4.27
  IN6 w0.099: v2(273.23,11.93) 275.93,14.64 282.73,14.64 284.52,16.43 286.37,16.43 287.94,18 291.11,18 291.42,17.69 293.04,17.69 295.5,20.15 303.94,20.15 304.55,20.76 309.24,20.76 312.63,24.15 312.63,26.81 315,29.18 315,31.48 317.42,33.9 317.42,39.04 323.69,45.32 323.69,51.03 325.9,53.24 325.9,54.06 327.41,55.57 327.41,59.48 328.58,60.65 328.58,69.13 328.86,69.42 328.86,75.57 329.79,76.51 329.79,82.94 342.71,95.86 342.71,102.69 v2(343.22,103.2)
BATT_LED#_LV4: length 141.9
  TOP w0.14: v3(273.72,10.55) 273.72,11.73 v2(273.95,11.96) 274.15,12.16 UE4.28 ; RP24.2 v2(343.17,102.55) 343.35,102.37 RL2.1
  IN6 w0.099: v2(343.17,102.55) 342.96,102.34 342.96,95.83 330,82.86 330,76.42 329.06,75.49 329.06,69.33 328.78,69.05 328.78,60.57 327.61,59.4 327.61,55.48 326.11,53.98 326.11,53.16 323.9,50.95 323.9,45.23 317.62,38.96 317.62,33.79 315.2,31.36 315.2,29.1 312.87,26.77 312.87,21.79 310.43,19.36 304.14,19.36 303.54,19.95 296.73,19.95 296.41,19.63 296.41,18.87 296.09,18.54 294.31,18.54 293.26,17.49 291.33,17.49 291.1,17.72 289.16,17.72 288.5,17.06 287.35,17.06 286.52,16.23 284.61,16.23 282.81,14.44 276.43,14.44 v2(273.95,11.96)
BATT_LED#_LV5: length 149.5
  TOP w0.14: UE4.1 275.15,10.35 v2(275.15,9.91) ; v2(344.36,99.07) 344.36,99.08 344.22,99.22 v3(344.22,99.7) RL1.1 343.76,101.35 343.22,101.9 RP24.1
  IN6 w0.099: v2(275.15,9.91) 275.74,10.51 281.88,10.51 282.24,10.87 285,10.87 286.51,9.36 287.96,9.36 288.4,9.8 288.4,10.19 289.05,10.84 292.36,10.84 293.16,11.63 294.59,11.63 295.38,10.85 303.76,10.85 304.11,10.5 311.14,10.5 313.96,13.33 313.96,16.5 317.92,20.45 317.92,24.79 318.4,25.28 318.4,26.58 321.84,30.01 321.84,32.15 323.46,33.77 323.46,35.21 324,35.75 324,37.88 325.54,39.42 325.54,43.71 327.36,45.53 327.36,51.43 327.83,51.9 327.83,52.32 329.45,53.93 329.45,57.59 333.47,61.61 333.47,83.12 338.41,88.06 342.73,88.06 344.17,89.49 344.17,98.88 v2(344.36,99.07)
BATT_PRS#: length 12.4
  TOP w0.14: v1(19,14.03) 19.75,13.28 PR111.1
  TOP w0.254: PR111.1 19.04,12.33 PD102.2 PD102.3 17.8,12.33 17.72,12.25 17.72,10.27 18.52,9.47 v2(18.67,9.47)
  BOTTOM w0.254: BAT100.7 19.35,10.15 v2(18.67,9.47)
BBS_BIT0: length 2.5
  TOP w0.089: RH130.2 84.41,9.85 84.41,9.2 v3(84.49,9.11) v2(84.88,8.73)
  BOTTOM w0.089: v2(84.88,8.73) 84.88,8.73 UH2.AT29
BC_CLK_ECE1117: length 168.3
  TOP w0.14: UE3.A20 v2(305.29,13.13)
  IN1 w0.099: v2(166.68,10.25) 167.16,10.73 174.29,10.73 175.88,9.14 182.29,9.14 183.29,10.14 206.04,10.14 206.22,9.97 211.34,9.97 213.48,7.83 218.96,7.83 219.37,8.24 227.67,8.24 227.8,8.36 231.96,8.36 232.25,8.08 245.45,8.08 245.75,7.78 250.83,7.78 251.56,7.04 257.36,7.04 258.59,8.27 262.66,8.27 262.71,8.22 266.53,8.22 268.06,9.75 272.93,9.75 275.49,12.31 275.49,12.45 275.32,12.62 275.32,12.78 275.44,12.9 275.6,12.9 275.77,12.73 275.91,12.73 276.05,12.87 276.05,13.01 275.3,13.76 275.3,13.92 275.42,14.04 275.58,14.04 276.33,13.29 276.47,13.29 276.61,13.43 276.61,13.57 276.39,13.79 276.39,13.95 276.51,14.07 276.67,14.07 276.89,13.85 277.03,13.85 277.33,14.15 277.82,14.15 277.92,14.06 277.92,13.76 278.02,13.66 278.22,13.66 278.31,13.76 278.31,14.06 278.41,14.15 278.61,14.15 278.71,14.06 278.71,13.76 278.81,13.66 279.01,13.66 279.11,13.76 279.11,14.06 279.21,14.15 279.4,14.15 279.5,14.06 279.5,13.76 279.6,13.66 279.8,13.66 279.9,13.76 279.9,14.06 280,14.15 280.2,14.15 280.3,14.06 280.3,13.76 280.39,13.66 280.59,13.66 280.69,13.76 280.69,14.06 280.79,14.15 280.99,14.15 281.09,14.06 281.09,13.76 281.19,13.66 281.39,13.66 281.48,13.76 281.48,14.06 281.58,14.15 281.78,14.15 281.88,14.06 281.88,13.76 281.98,13.66 282.18,13.66 282.28,13.76 282.28,14.06 282.38,14.15 282.88,14.15 284.97,16.24 285.56,16.24 286.09,16.78 286.09,17.3 286.51,17.71 288.85,17.71 289.14,18 290.56,18 291.26,17.3 293.16,17.3 294.03,16.43 294.03,15.81 294.91,14.93 301.5,14.93 301.98,14.46 303.26,14.46 304.59,13.13 v2(305.29,13.13)
  BOTTOM w0.14: JKB.8 159.77,9.83 161.3,8.3 163.01,8.3 163.36,8.64 CE81.1 165.72,8.07 166.31,8.07 166.56,8.33 166.56,10.13 v2(166.68,10.25)
BC_DAT_ECE1117: length 173.1
  TOP w0.14: v2(288.06,6.45) 288.42,6.8 289.95,6.8 290.79,7.64 RP19.1 ; v2(165.1,10.56) 165.1,11.58 v1(165.27,11.74) ; UE3.B21 v2(302.83,12.88)
  IN2 w0.099: v2(288.06,6.45) 287.61,6.9 282.74,6.9 281.99,6.15 273.96,6.15 271.98,8.13 262.66,8.13 262.65,8.12 262.62,8.12 262.36,8.38 256.91,8.38 255.86,7.33 253.05,7.33 252.3,8.09 245.76,8.09 245.45,7.78 240.32,7.78 238.46,5.92 227.56,5.92 227.56,5.93 227.53,5.93 226.2,7.26 215.22,7.26 215.22,7.26 213.55,7.26 210.58,10.23 210.55,10.23 210.51,10.26 200.28,10.26 200.26,10.24 184.67,10.24 184.07,9.64 178.43,9.64 177.78,10.29 175.14,10.29 174.56,10.87 165.41,10.87 v2(165.1,10.56)
  IN3 w0.091: v2(308.53,8.04) 308.4,8.17 308.4,9.03 307.16,10.27 305.52,10.27 304.93,10.87 304.93,11.95 304,12.88 v2(302.83,12.88)
  IN6 w0.099: v2(288.06,6.45) 289.2,5.31 298.5,5.31 298.7,5.11 300.76,5.11 302.27,6.61 306.15,6.61 306.66,7.13 308.19,7.13 308.53,7.48 v2(308.53,8.04)
  BOTTOM w0.14: JKB.7 160.27,9.67 161.4,8.54 162.91,8.54 163.26,8.89 164.5,8.89 CE82.1 165.15,10.51 v2(165.1,10.56)
BC_INT#_ECE1117: length 160.2
  TOP w0.14: v2(161.74,8.96) 161.34,9.36 v1(161.34,9.41) ; UE3.A19 305.23,12.63 v2(305.36,12.49)
  IN1 w0.099: v2(161.74,8.96) 162.24,9.47 163.2,9.47 163.7,8.96 168.59,8.96 169.86,10.23 174.22,10.23 175.71,8.74 182.46,8.74 183.46,9.74 205.87,9.74 206.05,9.56 211.11,9.56 213.3,7.37 220.86,7.37 221.32,7.83 226.64,7.83 227.83,6.64 236.09,6.64 237.13,7.67 245.28,7.67 245.58,7.37 250.67,7.37 251.4,6.64 257.52,6.64 258.07,7.18 258.84,7.18 259.53,7.87 262.15,7.87 262.21,7.82 266.7,7.82 267.17,8.28 272.03,8.28 276.98,13.24 282.61,13.24 283.47,14.09 284.99,14.09 285.54,14.64 285.54,15.65 286.58,16.7 286.93,16.7 287.21,16.99 288.53,16.99 289.06,17.52 290.27,17.52 291.02,16.77 291.02,15.53 291.75,14.8 293.82,14.8 294.54,14.08 296.98,14.08 297.63,14.73 301.42,14.73 301.89,14.26 303.18,14.26 304.94,12.49 v2(305.36,12.49)
  BOTTOM w0.14: JKB.6 160.77,9.51 161.31,8.96 v2(161.74,8.96)
BEEP: length 340.3
  TOP w0.14: v3(6.16,12.45) 6.61,12.45 8,13.85 JAUDIO.12 8,15.45 8.34,15.79 v2(8.7,15.79) ; v2(302.9,11.93) 302.95,11.88 UE3.B19
  IN6 w0.099: v2(308.59,16.98) 308.37,17.19 304.32,17.19 303.29,16.16 300.96,16.16 300.58,15.78 295.02,15.78 294.08,14.84 291.72,14.84 291.22,15.34 291.22,16.03 289.73,17.52 289.24,17.52 288.58,16.86 287.43,16.86 286.6,16.03 284.69,16.03 282.9,14.23 276.8,14.23 272.99,10.42 262.51,10.42 261.89,9.81 250.51,9.81 249.33,10.98 237.28,10.98 236.83,10.53 234.89,10.53 234.5,10.92 230.94,10.92 230.77,10.92 228.7,13 224.95,13 224.78,12.83 215.69,12.83 215.52,13 200.92,13 200.47,13.45 186.8,13.45 186.2,12.85 169.39,12.85 169,12.47 160.31,12.47 159.47,13.3 125.6,13.3 125.17,12.88 112.96,12.88 112.27,12.18 108.3,12.18 107.61,12.88 101.19,12.88 100.93,13.14 99.44,13.14 99.3,13 95.56,13 95.17,13.39 91.87,13.39 91.67,13.19 79.22,13.19 77.87,11.84 77.87,11.34 77.53,11 75.67,11 74.87,10.21 73.32,10.21 72.94,10.59 72.94,12.38 70.14,15.17 65.56,15.17 65.52,15.21 59.99,15.21 57.43,17.77 57.43,18.37 55.5,20.3 55.5,21.51 54.43,22.59 50.43,22.59 50.33,22.68 48.68,22.68 48.47,22.89 40.52,22.89 38.66,24.75 37.37,24.75 36.59,24.75 36.59,24.75 30.67,24.75 30.27,25.15 24.95,25.15 23.97,24.16 22.49,24.16 21.47,23.14 20.32,23.14 18.5,21.32 18.5,18.41 16.83,16.74 9.64,16.74 v2(8.7,15.79)
  BOTTOM w0.14: v2(308.59,16.98) 308.38,17.19 305.14,17.19 304.24,16.29 304.24,13.27 v2(302.9,11.93)
BIA_PWM_EC: length 288.3
  TOP w0.14: DV2.3 51.67,24.97 v2(51.72,24.93) ; RE122.1 300.15,29.68 300.36,29.47 300.36,29.09 300.1,28.84 299.21,28.84 299.09,28.71 298.07,28.71 v2(297.38,29.4) ; v2(105.94,48.28) v1(105.94,49.04)
  IN1 w0.099: v2(51.72,24.93) 51.84,24.93 54.03,27.11 66.92,27.11 70.93,31.12 71.31,31.12 71.76,31.57 74.55,31.57 74.83,31.29 77.49,31.29 77.87,31.66 79.68,31.66 81.7,33.67 84.72,33.67 87.56,36.51 92.17,36.51 92.67,37 95.34,37 96.06,37.73 98.35,37.73 105.94,45.32 v2(105.94,48.28)
  IN3 w0.089: 175.19,53.27 174.75,53.7 v2(172.15,53.7)
  IN3 w0.091: v2(263.85,21.94) 263.85,21.94 261.42,21.94 253.76,29.6 252.18,29.6 251.23,30.55 230.22,30.55 211.41,49.37 203.99,49.37 202.02,51.34 197.79,51.34 196.42,49.96 178.49,49.96 175.19,53.27
  IN6 w0.099: v2(297.38,29.4) 297.31,29.32 297.31,26.81 295.4,24.9 294.9,24.9 294.01,24.01 291.97,24.01 290.3,22.34 286.78,22.34 286.3,22.82 282.31,22.82 281.14,21.65 278.97,21.65 277.78,20.46 265.33,20.46 263.85,21.94 v2(263.85,21.94)
  BOTTOM w0.127: v2(172.15,53.7) 171.04,52.59 166.25,52.59 160.35,46.69 118.45,46.69 116.63,48.52 114.97,48.52 114.2,47.75 113.36,47.75 112.59,48.52 106.19,48.52 v2(105.94,48.28)
BIA_PWM_PCH: length 199.3
  TOP w0.14: DV2.2 49.64,23.92 v2(49.14,23.41) ; v2(180.63,88.91) 181.26,88.91 v1(181.38,89.04)
  IN1 w0.076: 75.06,15.72 75.32,15.45 77.05,15.45 78.23,16.63 81.74,16.63 v2(82.21,17.1)
  IN1 w0.099: 75.06,15.72 74.61,16.17 71.67,16.17 71.13,16.7 65.42,16.7 64.94,16.22 63.99,16.22 63.64,15.87 60.52,15.87 59.23,17.15 57.67,17.15 57.16,17.66 57.16,21.94 55.58,23.52 54.76,23.52 53.85,22.62 50.21,22.62 49.41,23.41 v2(49.14,23.41)
  IN4 w0.091: v2(121.54,51.7) 121.46,51.78 121.46,62.03 123.01,63.57 123.39,63.57 125.26,65.44 125.26,68.51 127.6,70.84 127.6,78 131.61,82.01 131.61,82.26 133.13,83.78 133.13,89.04 v2(131.94,90.23)
  IN5 w0.089: 101.98,25.59 100.68,25.59 99.83,24.73 99.83,22.92 96.83,19.92 93.61,19.92 92.91,19.22 92.04,19.22 90.94,18.13 85.62,18.13 85.01,17.52 85.01,17.01 84.8,16.8 82.51,16.8 v2(82.21,17.1)
  IN5 w0.099: v2(121.54,51.7) 121.54,51.64 119.03,49.13 119.03,43 104.82,28.79 103.32,28.79 102.54,28.01 102.54,26.04 102.08,25.59 101.98,25.59
  IN6 w0.089: 176.49,89.23 176.52,89.2 179.9,89.2
  IN6 w0.099: v2(131.94,90.23) 133.15,91.44 156.76,91.44 157.39,90.8 170.26,90.8 171.08,89.98 175.74,89.98 176.49,89.23 ; v2(180.63,88.91) 180.34,89.2 179.9,89.2
  BOTTOM w0.089: UH2.W36 81.87,16.76 v2(82.21,17.1)
  BOTTOM w0.14: RH456.2 180.99,88.91 v2(180.63,88.91)
BID_BC: length 3.1
  TOP w0.089: RH566.2 79.58,8.29 v2(79.41,8.29) 79.07,8.29 RH567.1 79.2,8.92 v3(79.2,9.46)
  BOTTOM w0.089: v2(79.41,8.29) 79.48,8.22 UH2.AU41
BID_DIS: length 242.3
  TOP w0.089: v3(78.45,6.6) 78.5,6.6 v2(78.87,6.23) 79.11,5.99 80.04,5.99 RH564.2 RH565.1
  TOP w0.14: v2(299.56,3.43) 299.56,3.46 299.4,3.62 RE112.2
  IN5 w0.089: 101.98,3.63 100.19,3.63 98.2,1.65 93.03,1.65 92.73,1.95 92.73,3.61 92.34,4 89.74,4 89.43,4.31 87.14,4.31 86.49,4.96 85.8,4.96 85.26,5.5 84.62,5.5 84.21,5.08 83.45,5.08 83.01,5.53 82.12,5.53 81.51,6.13 79.29,6.13 79.19,6.23 v2(78.87,6.23)
  IN5 w0.099: v2(105.03,1.91) 105.41,2.29 105.41,2.95 104.73,3.63 101.98,3.63 ; v2(299.56,3.43) 298.93,4.05 282.94,4.05 281.75,5.25 273.86,5.25 272.93,6.18 271.54,6.18 270.67,7.04 262.81,7.04 262.36,7.5 240.91,7.5 239.52,6.11 227.79,6.11 226.45,7.45 217.99,7.45 217.78,7.24 211.34,7.24 210.91,7.68 188.82,7.68 v2(185.87,4.73)
  IN6 w0.099: v2(185.87,4.73) 185.87,4.55 184.05,2.73 182.55,2.73 182.08,3.2 170.15,3.2 169.57,2.63 149.48,2.63 144.73,7.38 142.39,7.38 141.24,6.23 139.87,6.23 139.5,6.6 135.34,6.6 135.14,6.41 133.98,6.41 133.67,6.41 132.45,5.18 130.29,5.18 129.29,6.19 119.06,6.19 115.98,3.1 109.67,3.1 108.75,2.19 105.31,2.19 v2(105.03,1.91)
  BOTTOM w0.089: UH2.BA41 79.43,6.17 78.93,6.17 v2(78.87,6.23)
BOARD_ID: length 8.2
  TOP w0.14: UE3.B10 v2(299.52,11.56) ; v2(299.66,8.15) 299.4,8.15 CE51.1 298.78,7.37 RE67.2 299.8,7.22 299.8,6.26 v3(299.86,6.19)
  BOTTOM w0.14: v2(299.66,8.15) 300.19,8.68 300.19,10.07 299.52,10.74 v2(299.52,11.56)
BOOT_1.2V: length 7.6
  BOTTOM w0.14: 284.61,29.5 282.09,29.5 280.93,30.67 280.93,32.65 281.18,32.9 281.81,32.9 v1(282.14,32.57)
BQ24777_REGN: length 21
  TOP w0.254: PR321.1 57.34,22.93 57.05,23.22 56.22,23.22 55.8,23.64 52.72,23.64 52.39,23.31 PR318.2 51.84,21.71 51.84,21.01 51.51,20.68 v2(51.51,19.18)
  IN3 w0.254: v2(55.12,11.12) 55.12,12.14 54.04,13.22 54.04,15.31 53,16.35 53,18.18 51.97,19.21 51.55,19.21 v2(51.51,19.18)
  BOTTOM w0.254: PR311.1 54.9,11.34 v2(55.12,11.12)
  vias: v3(50.7,20.67)
BST1_3V: length 1.7
  TOP w0.14: 341,24.08 341,24.91 v1(340.39,25.52)
BST1_5V: length 3
  TOP w0.14: PC411.1 344.23,17.19 345.16,16.26 346.36,16.26 v3(346.67,15.95)
BST_0.95V: length 1
  TOP w0.14: 106.47,62.15 105.91,62.15 v1(105.75,62)
  BOTTOM w0.254: 107.16,62.96 PU800.6
  vias: v2(106.62,62.81)
BST_1.05V:
  vias: v3(219.8,49.35)
BST_1V: length 3.8
  TOP w0.508: v2(134.89,4.47) 134.13,4.47 v1(133.91,4.68) 133.87,4.72 PR503.1
  BOTTOM w0.254: PU500.6 133.78,4.65 133.88,4.76 134.1,4.76 134.39,4.47 v2(134.89,4.47)
BST_3V: length 6.3
  TOP w0.14: v1(347.82,28.13) 347.49,28.13 343.8,24.45 343.8,24.08 PR411.2 343.41,24.08
BST_5V: length 1.4
  TOP w0.14: v3(341.64,15.87) 341.89,16.11 PR412.1
BST_+1.35VRUN: length 1.9
  TOP w0.14: PC713.1 244.79,54.43 244.79,54.48 v1(245.77,55.46)
BT_RADIO_DIS#: length 116.1
  TOP w0.14: UE4.23 273.28,15.41 RE72.2 272.15,14.27 v3(272.15,14.12) v2(272.15,13.59)
  IN6 w0.099: v2(272.15,13.59) 273.8,15.24 282.47,15.24 284.1,16.86 284.1,17.52 285.02,18.45 287.54,18.45 287.69,18.6 288.9,18.6 288.9,18.6 290.52,18.6 290.91,18.98 293.2,18.98 294.01,19.79 294.01,20.68 294.54,21.21 296.73,21.21 296.89,21.04 303.69,21.04 304.21,21.56 307.77,21.56 308.62,22.42 309.76,22.42 310.86,23.52 310.86,28.65 310.38,29.13 310.38,31.65 310.74,32.01 310.74,35.08 312.59,36.93 312.59,38.65 318.28,44.34 320.09,44.34 321.09,45.33 321.09,50.77 323.29,52.98 323.29,53.26 326.07,56.03 326.07,57.3 325.32,58.05 325.32,60.68 327.37,62.72 327.37,69.58 325.88,71.07 325.88,76.33 328.43,78.89 328.43,79.25 v2(328.01,79.67)
  BOTTOM w0.14: v2(328.01,79.67) 328.33,79.67 328.8,80.15 DN2.1
BT_RADIO_DIS#_R: length 26.2
  TOP w0.14: v2(341.26,89.62) 342.98,89.62 v1(343.98,88.62)
  IN2 w0.099: v2(328.02,80.27) 329.03,81.29 330.48,81.29 332.94,83.75 332.94,86.9 334.57,88.52 338.89,88.52 339.99,89.62 v2(341.26,89.62)
  BOTTOM w0.14: JNGFF1.46 341.8,90.16 v2(341.26,89.62) ; DN2.2 328.8,81.34 328.02,80.55 v2(328.02,80.27)
CAM_CBL_DET#: length 33.9
  BOTTOM w0.089: 76.98,18.13 77.18,18.13 77.48,17.83 78.23,17.83 78.33,17.73 78.34,17.73 78.38,17.69 UH2.U43
  BOTTOM w0.127: JEDP1.29 57.55,31.73 57.99,31.29 58.72,31.29 60.52,29.49 60.52,28.09 60.71,27.9 v1(60.71,27.8) 60.71,21.32 61.61,20.42 66.13,20.42 67.46,21.75 68.34,21.75 68.61,21.49 68.61,21.21 68.99,20.82 71.44,20.82 72.06,20.2 RH511.1 73.47,20.2 75.22,18.45 76.54,18.45 76.86,18.13 76.98,18.13
CD_WAKE#: length 4.3
  BOTTOM w0.14: UR1.32 336.3,34.68 336.98,33.99 RR10.2 337.35,33.99 RR1.2 338.25,32.34 v3(337.82,31.91)
CFG0: length 49.3
  TOP w0.14: JXDP.9 127.03,87.51 126.77,87.77 126.77,88.38 126.39,88.76 125.54,88.76 v2(125.05,88.27) ; RH183.1 132.45,76.74 132.51,76.81 139.04,76.81 v1(139.38,77.15) 139.73,77.49 v2(139.73,77.6) ; RH488.2 130.86,95.51 131.15,95.8 v2(131.15,96.15)
  IN2 w0.099: v2(139.73,77.6) 139.31,77.19 138.52,77.19 138.34,77.36 133.4,77.36 ; v2(131.15,96.15) 131.15,96 132.6,94.55 132.6,93.21 130.48,91.09 126.22,91.09 125.78,90.65 125.78,89 v2(125.05,88.27)
  IN2 w0.102: v2(125.05,88.27) 125.45,87.86 125.48,87.86 128.7,84.63 128.7,82.17 129.21,81.66 129.36,81.66 131.07,79.95 131.07,79.69 133.4,77.36
  BOTTOM w0.076: v2(139.73,77.6) 139.4,77.28 UH1.BN25
CFG1: length 19.2
  TOP w0.089: v1(140.45,78.56) 139.83,79.18 v2(139.73,79.18)
  TOP w0.14: v2(130.49,87.63) 130.11,88.01 JXDP.11
  IN2 w0.099: 130.89,86.34 130.49,86.74 v2(130.49,87.63)
  IN2 w0.102: v2(139.73,79.18) 139.36,79.55 137.67,79.55 137.08,80.14 136.1,80.14 135.63,80.61 134.14,80.61 133.55,81.2 132.64,81.2 131.27,82.57 131.27,85.96 130.89,86.34
  BOTTOM w0.076: v2(139.73,79.18) 139.4,78.85 UH1.BN27
CFG2: length 26.3
  TOP w0.14: v2(129.92,88.96) 129.87,89.01 JXDP.15 ; RH184.1 133.01,77.07 137.47,77.07 v1(137.61,77.21) 138,77.6 v2(139.08,77.6)
  IN2 w0.102: v2(129.92,88.96) 129.59,88.63 129.59,86.46 130.79,85.26 130.79,82.42 132.43,80.78 133.39,80.78 133.97,80.21 135.5,80.21 135.95,79.76 136.92,79.76 v2(139.08,77.6)
  BOTTOM w0.076: UH1.BN26 139.4,77.93 v2(139.08,77.6)
CFG3: length 22.1
  TOP w0.089: v1(138.48,79.31) 138.61,79.18 v2(139.08,79.18)
  TOP w0.14: v2(130.81,85.82) 131.18,85.82 131.71,86.36 131.71,88.21 130.41,89.51 JXDP.17
  IN2 w0.102: v2(130.81,85.82) 131,85.64 131,82.5 132.52,80.98 133.48,80.98 134.05,80.41 135.57,80.41 136.02,79.95 137,79.95 137.77,79.18 v2(139.08,79.18)
  BOTTOM w0.076: v2(139.08,79.18) 139.4,79.5 UH1.BN28
  BOTTOM w0.14: v2(130.81,85.82) 131.06,85.57 RH474.2
CFG4: length 34.4
  TOP w0.089: 134.62,74.19 v2(134.77,74.04) 135.13,74.39 v3(135.13,74.55)
  TOP w0.14: JXDP.27 126.61,92.01 v2(126.54,92.07) ; RH185.1 134.14,74.67 134.62,74.19
  IN2 w0.102: v2(126.54,92.07) 125.97,91.5 124.92,91.5 122.61,89.19 122.61,87.13 125.07,84.67 125.07,81.06 132.59,73.54 134.28,73.54 v2(134.77,74.04)
  BOTTOM w0.076: v2(134.77,74.04) 135.38,73.43 137.19,73.43 137.33,73.57 137.81,73.57 UH1.BR20
CFG5: length 48.2
  TOP w0.089: v2(140.38,72.88) 140.64,72.88 v1(141.21,72.31)
  TOP w0.14: v2(125.67,92.17) 126,92.51 JXDP.29 ; v2(133.41,71.67) 132.93,71.19 RH186.1
  IN2 w0.099: v2(125.67,92.17) 125.4,91.9 124.75,91.9 124.65,91.81
  IN2 w0.102: v2(140.38,72.88) 139.99,73.26 135.89,73.26 135.74,73.11 132.44,73.11 124.66,80.89 124.66,84.5 122.2,86.97 122.2,89.36 124.65,91.81
  BOTTOM w0.076: UH1.BM20 140.05,73.2 v2(140.38,72.88) 140.38,70.81 140.18,70.62 139.19,70.62 139.08,70.74 139.08,71.15 138.88,71.36 137.06,71.36 136.95,71.25 134.62,71.25
  BOTTOM w0.14: v2(133.41,71.67) 133.84,71.25 134.62,71.25
CFG6: length 36.2
  TOP w0.14: JXDP.33 127.15,93.51 v2(126.59,92.95) ; v2(133.5,74.02) 133.04,73.55 132.4,73.55 RH187.1 131.36,73.9 v1(130.84,73.38)
  IN2 w0.102: v2(133.5,74.02) 132.77,74.76 131.67,74.76 125.28,81.15 125.28,84.75 122.81,87.22 122.81,89.1 125,91.29 126.41,91.29 127,91.88 127,92.55 v2(126.59,92.95)
  BOTTOM w0.14: UH1.BT20 137.28,73.1 134.43,73.1 v2(133.5,74.02)
CFG7: length 38.1
  TOP w0.14: RH188.1 135.83,73.1 v1(135.97,73.24) 136.01,73.28 v2(136.01,74.05) ; v2(125.95,92.95) 127.01,94.01 JXDP.35
  IN2 w0.102: v2(136.01,74.05) 135.28,73.33 132.51,73.33 124.86,80.98 124.86,84.59 122.4,87.05 122.4,89.27 124.83,91.7 125.78,91.7 126.11,92.03 126.11,92.78 v2(125.95,92.95)
  BOTTOM w0.076: UH1.BP20 138.43,73.59 138.2,73.59 138.03,73.77 137.2,73.77 137.07,73.64 136.42,73.64 v2(136.01,74.05)
CFG8: length 23.5
  TOP w0.089: v3(135.23,76.12) 135.41,75.94 v2(135.41,75.64)
  TOP w0.14: v2(124.03,87.85) 123.68,87.51 JXDP.10
  IN2 w0.099: 124.26,87.21 124.03,87.44 v2(124.03,87.85)
  IN2 w0.102: v2(135.41,75.64) 134.76,76.29 133.28,76.29 130.92,78.64 130.29,78.64 127.15,81.78 127.15,82.98 126.6,83.53 126.6,84.86 124.26,87.21
  BOTTOM w0.076: v2(135.41,75.64) 135.8,76.03 137.71,76.03 UH1.BR23
CFG9: length 25.3
  TOP w0.14: JXDP.12 123.44,88.01 v2(123.95,88.52) ; v3(133.81,76.04) 134.14,75.71 v2(134.14,75.64)
  IN2 w0.099: v2(134.14,75.64) 133.69,76.08 133.2,76.08 130.92,78.36 130.4,78.36
  IN2 w0.102: v2(123.95,88.52) 123.62,88.19 123.62,87.56 126.1,85.08 126.1,81.56 129.3,78.36 130.4,78.36
  BOTTOM w0.076: 134.62,75.15 134.77,75 137.19,75 137.33,75.14 137.81,75.14 UH1.BR22
  BOTTOM w0.14: 134.62,75.15 v2(134.14,75.64)
CFG10: length 24.2
  TOP w0.089: v2(136.04,75.64) 136.65,75.03 v1(136.78,75.03)
  TOP w0.14: JXDP.16 124.28,89.01 v2(124.29,88.99)
  IN2 w0.102: v2(124.29,88.99) 124.44,88.85 124.44,87.32 126.81,84.95 126.81,83.61 127.36,83.06 127.36,81.87 130.38,78.85 131.01,78.85 133.3,76.55 135.13,76.55 v2(136.04,75.64)
  BOTTOM w0.076: UH1.BT23 137.06,75.24 136.44,75.24 v2(136.04,75.64)
CFG11: length 28.8
  TOP w0.14: v2(133.5,75.62) 132.55,75.62 v3(132.39,75.79) ; v2(125.25,89.51) JXDP.18
  IN2 w0.099: v2(133.5,75.62) 131.76,75.62 125.89,81.49
  IN2 w0.102: 125.89,81.49 125.89,85 123.42,87.47 123.42,88.85 123.97,89.4 125.14,89.4 v2(125.25,89.51)
  BOTTOM w0.076: UH1.BT22 137.39,74.78 134.62,74.78
  BOTTOM w0.127: 134.35,74.78 v2(133.5,75.62)
  BOTTOM w0.14: 134.62,74.78 134.35,74.78
CFG12: length 34.4
  TOP w0.089: v2(139.73,72.88) 139.73,72.41 v1(139.42,72.11)
  TOP w0.14: JXDP.28 123.74,92.01 123.74,92.01 v2(124.01,91.74)
  IN2 w0.102: v2(139.73,72.88) 139.71,72.89 132.37,72.89 124.46,80.81 124.46,84.42 122,86.88 122,89.44 123.81,91.26 123.81,91.54 v2(124.01,91.74)
  BOTTOM w0.076: UH1.BM19 140.05,72.55 v2(139.73,72.88)
CFG13: length 35.1
  TOP w0.089: v1(137.63,71.73) 137.33,72.03 136.43,72.03 v2(136.06,71.66)
  TOP w0.14: v2(124.01,92.33) 123.84,92.51 JXDP.30
  IN2 w0.102: v2(136.06,71.66) 135.03,72.69 132.29,72.69 124.25,80.72 124.25,84.34 121.79,86.8 121.79,89.52 123.51,91.24 123.51,91.83 v2(124.01,92.33)
  BOTTOM w0.076: UH1.BR19 138.1,72.27 137.82,71.99 137.2,71.99 137.13,72.05 136.45,72.05 v2(136.06,71.66)
CFG14: length 38
  TOP w0.089: v2(135.42,71.66) 136.09,70.99 v1(136.09,70.8)
  TOP w0.14: JXDP.34 123.48,93.51 v2(124.64,92.34)
  IN2 w0.102: v2(124.64,92.34) 124.24,92.74 123.84,92.74 123.31,92.21 123.31,91.32 121.59,89.61 121.59,86.71 124.05,84.25 124.05,80.64 132.27,72.42 134.66,72.42 v2(135.42,71.66)
  BOTTOM w0.076: v2(135.42,71.66) 136.02,72.26 137.27,72.26 137.33,72.19 137.63,72.19 137.75,72.32 137.75,72.58 137.94,72.77 138.47,72.77 UH1.BP19
CFG15: length 36.1
  TOP w0.14: v1(134.39,71.22) 134.09,71.52 v2(134.09,71.7) ; v2(124.66,92.97) 124.47,92.97 123.44,94.01 JXDP.36
  IN2 w0.099: 132.43,72.16 133.63,72.16 v2(134.09,71.7)
  IN2 w0.102: v2(124.66,92.97) 123.78,92.97 123.1,92.3 123.1,91.41 121.39,89.69 121.39,86.63 123.85,84.17 123.85,80.55 132.24,72.16 132.43,72.16
  BOTTOM w0.14: UH1.BT19 134.88,72.49 v2(134.09,71.7)
CFG16: length 26.9
  TOP w0.089: v3(138.39,75.5) 138.43,75.53 v2(138.43,76.03)
  TOP w0.14: JXDP.6 123.7,86.51 124.45,87.26 124.45,88.47 v2(124.94,88.95)
  IN2 w0.102: v2(124.94,88.95) 124.64,88.66 124.64,87.4 127.01,85.03 127.01,83.7 127.56,83.15 127.56,81.95 130.46,79.05 131.09,79.05 133.32,76.82 137.64,76.82 v2(138.43,76.03)
  BOTTOM w0.076: UH1.BP23 138.75,75.7 v2(138.43,76.03)
CFG17: length 25.8
  TOP w0.089: v2(139.08,76.03) 139.57,75.54 v1(140.11,75.54)
  TOP w0.14: v2(125.05,87.67) 125.05,87.18 123.87,86.01 JXDP.4
  IN2 w0.102: v2(139.08,76.03) 138.01,77.1 133.38,77.1 130.87,79.6 130.87,79.86 129.28,81.45 129.13,81.45 128.5,82.08 128.5,84.55 125.38,87.67 v2(125.05,87.67)
  BOTTOM w0.076: v2(139.08,76.03) 139.4,75.7 UH1.BN23
CFG18: length 32.7
  TOP w0.089: v1(139.47,73.9) 139.08,74.29 v2(139.08,74.45)
  TOP w0.14: v2(125.32,90.8) 125.11,91.01 JXDP.24
  IN2 w0.102: v2(139.08,74.45) 138.7,74.08 138.09,74.08 137.2,74.96 131.79,74.96 125.48,81.27 125.48,84.83 123.01,87.3 123.01,89.02 124.8,90.8 v2(125.32,90.8)
  BOTTOM w0.076: UH1.BN22 139.4,74.78 v2(139.08,74.45)
CFG19: length 31.6
  TOP w0.089: v1(137.73,73.53) 137.73,73.76 v2(138.43,74.45)
  TOP w0.14: JXDP.22 123.65,90.51 123.75,90.61 124.9,90.61 v2(125.31,90.2)
  IN2 w0.102: v2(125.31,90.2) 125.31,90.15 124.77,89.6 123.89,89.6 123.22,88.93 123.22,87.39 125.69,84.92 125.69,81.4 131.92,75.17 137.72,75.17 v2(138.43,74.45)
  BOTTOM w0.076: UH1.BP22 138.75,74.78 v2(138.43,74.45)
CFG_RCOMP: length 4.9
  BOTTOM w0.254: RH59.1 v3(133.61,76.81) 136.57,76.81 136.96,77.21 UH1.BT25
CHAGER_SRC:
  vias: v1(50.48,8.33) v2(49.53,8.86) v2(49.53,8.28) v2(49.53,7.69) v2(51.31,8.89) v2(51.31,8.3) v2(51.31,7.72)
CHARGER_SCL: length 4.4
  TOP w0.14: PR309.2 59.87,18.89 v3(59.87,19.64)
  TOP w0.203: PR309.2 58.79,17.81 58.79,17.59 58.47,17.27 58.05,17.27 57.81,17.51 PU300.12
CHARGER_SDA: length 2.5
  TOP w0.203: PR306.2 58.76,16.9 57.98,16.9 57.77,17.11 PU300.11
CHARGER_SMBCLK: length 269.4
  TOP w0.14: v2(292.86,22.09) 292.3,21.54 290.73,21.54 RE23.1 ; v2(295.07,19.13) 295.52,19.58 UE3.B50
  TOP w0.254: PR309.1 61.02,18.37 v3(61.4,17.99) 61.54,17.85 v2(61.54,17.28)
  IN1 w0.076: v2(100.12,19) 99.19,19.93 94.56,19.93 93.82,20.68 89.93,20.68 88.19,18.94 78.49,18.94 77.46,17.9 75.66,17.9 75.18,18.38 75.06,18.38
  IN1 w0.099: v2(61.54,17.28) 61.91,17.65 63.53,17.65 64.14,18.26 66.09,18.26 66.61,17.74 69.01,17.74 69.65,18.38 70.26,18.38 70.44,18.55 70.44,18.74 70.62,18.92 70.87,18.92 71.05,18.74 71.05,18.39 71.23,18.21 71.48,18.21 71.66,18.39 71.66,18.74 71.83,18.92 72.08,18.92 72.26,18.74 72.26,18.23 72.44,18.06 72.69,18.06 72.87,18.23 72.87,18.74 73.05,18.92 73.3,18.92 73.48,18.74 73.48,18.55 73.65,18.38 75.06,18.38
  IN3 w0.091: v2(295.07,19.13) 294.98,19.13 293.57,17.73 291.61,17.73 290.78,16.9 290.78,14.87 290.01,14.09 288.38,14.09 v2(288.21,13.93)
  IN5 w0.089: 101.98,18.11 101.01,18.11 v2(100.12,19)
  IN5 w0.099: v2(288.21,13.93) 284.44,13.93 284,13.49 275.7,13.49 275.14,12.93 272.21,12.93 272.02,12.75 267.04,12.75 266.13,13.65 255.48,13.65 250.09,19.04 222.74,19.04 221.78,20 221.78,23.89 219.12,26.55 187.19,26.55 187.01,26.73 182.3,26.73 178.44,22.87 178.44,19.29 175.02,15.86 160.15,15.86 160.11,15.82 129.7,15.82 129.63,15.76 106.3,15.76 104.27,17.79 102.3,17.79 101.98,18.11
  BOTTOM w0.14: v2(292.86,22.09) 292.86,21.82 295.07,19.6 v2(295.07,19.13)
CHARGER_SMBDAT: length 265.8
  TOP w0.14: RE22.1 294.9,22.36 v3(294.95,22.31) 295.24,22.01 v2(295.36,22.01) 295.77,21.6 UE3.A47
  TOP w0.254: v2(60.95,17.28) 60.75,17.48 PR306.1
  IN5 w0.089: 101.98,19.69 97.87,19.69 97.23,19.05 93.15,19.05 91.33,17.23 85.6,17.23 83.62,15.25 77.98,15.25 77.34,15.89 76.32,15.89 76.19,16.02 76.19,16.27 76,16.46 75.27,16.46 75.06,16.25
  IN5 w0.099: 101.98,19.69 102.86,19.69 106.54,16.01 129.37,16.01 129.58,16.22 175.09,16.22 178.24,19.36 178.24,22.94 182.22,26.93 187.1,26.93 187.27,26.75 219.2,26.75 221.98,23.98 221.98,20.08 222.75,19.31 250.1,19.31 255.54,13.88 269.81,13.88 270.51,13.18 275.11,13.18 275.62,13.69 283.85,13.69 v2(284.66,14.5) ; v2(60.95,17.28) 61.36,17.69 61.8,17.69 62.55,16.94 65.87,16.94 66.43,16.37 69.14,16.37 69.83,15.68 74.49,15.68 75.06,16.25
  BOTTOM w0.14: v2(295.36,22.01) 294.24,23.13 292.43,23.13 291.34,22.04 288.18,22.04 286.44,20.3 286.44,18.23 287.16,17.51 287.16,17.07 285.54,15.44 285.54,14.97 285.07,14.5 v2(284.66,14.5)
CHG_BTS: length 2.9
  TOP w0.14: PR307.1 50.13,18.21 48.45,18.21 v3(48.26,18.4)
CHG_BTS_C: length 1
  TOP w0.14: 49.19,16.91 v3(48.24,16.91)
CHG_LGATE: length 18.6
  TOP w0.14: v3(52.03,19.12) 52.03,18.83 v2(51.82,18.61)
  IN5 w1.016: 50.61,18.23 48.77,18.23 47.68,17.14 47.68,3.13 48.13,2.68
  vias: v2(48.9,2.42) v2(49.48,2.42) v2(52.26,18.17)
CHG_SW: length 14.3
  TOP w0.508: PR313.2 v1(35.75,6.08) v2(35.75,6.8)
  IN1 w1.016: 42.55,8.26 42.55,8.96 49.4,15.82 50.61,15.82
  vias: v2(36.53,7.29) v2(36.53,6.7) v2(37.11,7.29) v2(37.11,6.7) v2(37.69,7.29) v2(37.69,6.7) v2(38.28,7.29) v2(38.28,6.7) v2(38.86,7.29) v2(38.86,6.7) v2(39.29,4.44) v2(39.29,3.86) v2(39.88,4.44) v2(39.88,3.86) v2(40.46,4.44) v2(40.46,3.86) v2(41.05,4.44) v2(41.05,3.86) v2(42.23,7.25) v2(42.86,7.25) v2(51.56,15.95) v2(52.16,15.95)
CHG_UGATE: length 13.9
  TOP w0.14: v1(43.37,17.03) 42.88,17.52 42.88,18.23 v2(43,18.36)
  IN1 w1.016: 50.42,17.03 48.39,17.03 43.82,12.45 ; 42.61,13.66 42.61,17.47
  vias: v2(42.23,12.52) v2(42.42,18.36) v2(42.81,12.52) v2(51.56,16.61) v2(52.16,16.61)
CLINK_CLK: length 328.2
  IN1 w0.099: v2(338.8,90.21) 338,89.41 338,87.8 337.11,86.9 335.92,86.9 335.33,86.32 335.33,85.12 334.42,84.21 334.42,57.77 332.54,55.88 332.54,48.36 328.28,44.11 328.28,41.24 331.59,37.93 331.59,34.51 328.23,31.14 326.86,31.14 326.14,30.42 326.14,27.05 325.27,26.18 325.27,23.64 323.35,21.72 321.83,21.72 320.49,20.39 320.49,13.78 318.26,11.55 315.97,11.55 315.66,11.24 315.66,9.95 v2(316.2,9.41)
  IN5 w0.099: v2(102.9,5.32) 103.34,5.76 117.49,5.76 119.36,7.63 127.38,7.63 128.1,6.91 133.16,6.91 134.37,8.12 144.98,8.12 146.95,6.15 151.31,6.15 152.04,5.41 159.46,5.41 159.71,5.16 165.39,5.16 166.05,4.5 170.05,4.5 171.68,2.87 180.62,2.87 186.24,8.49 211.23,8.49 211.66,8.07 215.61,8.07 216.82,9.28 230.95,9.28 231.43,8.8 231.65,8.8 232.13,8.32 252.24,8.32 253,9.08 261.91,9.08 263.04,7.95 274,7.95 275.9,6.05 284.51,6.05 285.69,4.87 301.06,4.87 302.5,6.3 306.7,6.3 307.24,6.84 309.44,6.84 312.35,9.76 315.85,9.76 v2(316.2,9.41)
  BOTTOM w0.089: UH2.AV2 99.17,7.45 99.55,7.45 99.63,7.37 100.83,7.37 101.98,6.22
  BOTTOM w0.127: v2(102.9,5.32) 102.9,5.35 102.27,5.98 102.22,5.98 101.98,6.22
  BOTTOM w0.14: JNGFF1.34 v2(338.8,90.21)
CLINK_DATA: length 324.3
  IN1 w0.099: v2(338.81,89.4) 338.81,88.32 334.62,84.13 334.62,57.68 332.74,55.8 332.74,48.28 332,47.54 332,34.34 328.12,30.47 327.16,30.47 326.67,29.98 326.67,22.41 325.55,21.29 322.18,21.29 321.36,20.46 321.36,13.9 316.89,9.43 v2(316.84,9.43)
  IN5 w0.099: v2(316.84,9.43) 316.32,9.96 309.64,9.96 306.4,6.71 302.33,6.71 300.9,5.28 285.92,5.28 284.74,6.45 276.07,6.45 274.14,8.38 263.3,8.38 262.18,9.5 252.66,9.5 251.9,8.74 234.25,8.74 233.17,9.81 214.24,9.81 213.11,8.69 186.16,8.69 180.53,3.07 171.77,3.07 170.13,4.7 166.14,4.7 165.48,5.36 159.79,5.36 158.81,6.35 147.05,6.35 145.08,8.32 119.72,8.32 117.46,6.06 103.05,6.06 v2(102.31,5.32)
  BOTTOM w0.089: UH2.AV3 98.61,7.58 98.91,7.27 99.47,7.27 99.56,7.19 100.68,7.19 101.7,6.17
  BOTTOM w0.127: 101.7,6.17 101.7,5.98 102.31,5.37 v2(102.31,5.32)
  BOTTOM w0.14: JNGFF1.32 338.3,89.91 v2(338.81,89.4)
CLINK_RST#: length 328.6
  IN1 w0.099: v2(316.14,8.8) 315.37,9.57 315.37,11.67 316.04,12.34 318.33,12.34 320.23,14.24 320.23,20.46 321.72,21.95 323.24,21.95 325.03,23.75 325.03,26.84 325.86,27.67 325.86,30.55 326.7,31.39 328.17,31.39 331.39,34.62 331.39,36.4 328.08,39.71 328.08,44.19 332.33,48.45 332.33,55.97 334.22,57.85 334.22,84.3 335.13,85.2 335.13,86.95 336.42,88.25 337.55,88.25 337.8,88.5 v2(337.8,90.1)
  IN5 w0.089: v2(101.49,5.32) 101.51,5.3 101.69,5.3 101.98,5.01
  IN5 w0.099: 101.98,5.01 102.08,4.91 105.1,4.91 105.49,5.3 107.09,5.3 107.46,4.94 109.95,4.94 110.43,4.46 116.49,4.46 118.74,6.71 133.27,6.71 134.48,7.92 144.89,7.92 146.86,5.95 151.22,5.95 151.96,5.21 159.38,5.21 159.63,4.96 165.31,4.96 165.97,4.3 169.93,4.3 171.56,2.66 180.7,2.66 186.32,8.29 211.15,8.29 211.57,7.86 217.55,7.86 217.74,8.06 226.74,8.06 228.03,6.77 234.77,6.77 236.1,8.1 252.31,8.1 253.09,8.88 261.82,8.88 262.97,7.74 273.93,7.74 275.82,5.85 284.43,5.85 285.61,4.67 301.15,4.67 301.77,5.29 306.96,5.29 308.18,6.51 309.97,6.51 311.96,8.5 315.84,8.5 v2(316.14,8.8)
  BOTTOM w0.089: UH2.AW2 99,6.99 99.19,6.8 100.04,6.8 101.49,5.35 v2(101.49,5.32)
  BOTTOM w0.14: JNGFF1.30 v2(337.8,90.1)
CLK_27M_IN: length 12.3
  BOTTOM w0.102: 221.44,64.52 221.44,65.01 UV1.H3
  BOTTOM w0.14: 221.44,64.52 222.01,63.95 222.01,63.69 223.2,62.49 v3(223.2,60.64) 223.2,58.9 223.2,58.9 223.2,58.18 CV575.1 222.72,57.7 222.72,55.74 223.74,54.72 YV1.1
CLK_27M_OUT: length 12
  BOTTOM w0.14: UV1.H2 221,64.51 221.58,63.93 221.58,63.52 221.74,63.36 221.74,63.17 221.58,63.01 221.58,62.81 221.78,62.61 221.97,62.61 222.13,62.77 222.33,62.77 222.64,62.46 222.64,61.97 222.5,61.83 222.17,61.83 222.05,61.71 222.05,61.4 222.17,61.28 222.5,61.28 222.64,61.14 222.64,60.86 222.5,60.72 222.12,60.72 222,60.59 222,60.28 222.12,60.16 222.5,60.16 222.64,60.02 v3(222.64,58.94) 222.64,58.49 CV576.1 222.07,57.9 222.28,57.69 222.28,57.1 YV1.3
CLK_PCI_MEC: length 224.1
  TOP w0.14: v2(306.9,18.31) 306.9,18.27 306.38,17.75 RE62.1 305.51,17.66 v3(305.47,17.62) 305.47,17.63 UE3.A29
  IN3 w0.091: v2(306.9,18.31) 306.43,17.84 304.31,17.84 303.9,18.24 301.8,18.24 301.55,17.99 300.34,17.99 299.9,18.43 299.9,20.2 298.96,21.15 297.2,21.15 296.74,21.61 291.98,21.61 290.96,20.59 284.28,20.59 283.45,19.77 283.09,19.77 282.28,18.96 282.28,17.08 275.8,10.6 274.67,10.6 272.04,7.96 262.89,7.96 262.68,8.17 259.92,8.17 257.83,6.09 246.75,6.09 246.14,5.48 244.37,5.48 242.02,7.83 236.28,7.83 234.39,5.95 226.51,5.95 225.31,4.75 214.97,4.75 210.63,9.09 174.68,9.09 173.97,9.8 169.05,9.8 167.81,8.56 156.39,8.56 156.09,8.87 152.98,8.87 151.76,7.65 146.4,7.65 144.71,9.33 136.2,9.33 135.43,8.56 128.41,8.56 128.11,8.86 121.82,8.86 120.4,7.44 118.77,7.44 115.59,4.26 v2(107.48,4.26)
  BOTTOM w0.14: CH198.1 107.67,4.07 v2(107.48,4.26) 107.44,4.22 106.48,4.22 RH168.2
CLK_PCIE_CR: length 259
  IN2 w0.107: v2(97.17,24.18) 97.35,24 97.35,23.83 97.68,23.5 99.37,23.5 99.94,24.07 99.94,24.79 100.73,25.59 101.84,25.59 102.41,26.16 102.41,27.97 103.16,28.71 109.67,28.71 112.47,25.9 143.78,25.9 146.02,23.67 147.64,23.67 148.16,23.15 148.16,20.47 148.63,20 152.41,20 152.59,19.81 154.55,19.81 156.92,17.44 156.92,16.91 157.97,15.87 180.25,15.87 180.95,15.17 244.39,15.17 245.08,14.48 256.91,14.48 258.44,16.01 260.34,16.01 261.89,17.57 264.94,17.57 265.16,17.79 267.57,17.79 268.73,16.63 278.97,16.63 279.29,16.95 281.49,16.95 284.52,19.97 290.69,19.97 290.83,20.12 292.64,20.12 295,22.48 296.05,22.48 296.33,22.76 297.2,22.76 297.64,23.2 304.15,23.2 304.84,23.88 311.24,23.88 313.53,26.17 317.29,26.17 322.45,31.33 325.1,31.33 326.87,33.11 331.08,33.11 331.69,32.5 333.2,32.5 333.45,32.75 333.45,32.93 v2(333.62,33.09)
  BOTTOM w0.089: UH2.E6 97.17,23.76 v2(97.17,24.18)
  BOTTOM w0.152: v2(333.62,33.09) 333.65,33.12 333.65,33.2 333.68,33.24 UR1.5
CLK_PCIE_CR#: length 258.9
  IN2 w0.107: v2(97.94,24.16) 97.77,24.32 97.64,24.32 97.55,24.23 97.55,23.91 97.76,23.71 99.29,23.71 99.73,24.15 99.73,24.88 100.65,25.79 101.76,25.79 102.21,26.24 102.21,28.05 103.07,28.91 109.75,28.91 112.56,26.11 143.87,26.11 146.1,23.87 147.73,23.87 148.36,23.24 148.36,20.56 148.72,20.2 152.49,20.2 152.67,20.02 154.63,20.02 157.13,17.52 157.13,17 158.05,16.07 180.34,16.07 181.03,15.38 244.47,15.38 245.16,14.69 256.83,14.69 258.35,16.21 260.25,16.21 261.81,17.77 264.85,17.77 265.07,17.99 267.65,17.99 268.81,16.83 278.89,16.83 279.21,17.15 281.41,17.15 284.43,20.18 290.6,20.18 290.74,20.32 292.55,20.32 294.92,22.68 295.96,22.68 296.25,22.97 297.12,22.97 297.55,23.4 304.07,23.4 304.75,24.09 311.16,24.09 313.44,26.37 317.21,26.37 322.37,31.53 325.01,31.53 326.79,33.31 331.17,33.31 331.78,32.7 333.11,32.7 333.25,32.83 333.25,32.9 v2(333.03,33.12)
  BOTTOM w0.101: UH2.D5 97.94,24.24 v2(97.94,24.16)
  BOTTOM w0.152: v2(333.03,33.12) 333.28,33.37 UR1.6
CLK_PCIE_SSD: length 180.2
  IN2 w0.107: v2(96.29,19.43) 96.01,19.71 96.01,19.84 96.14,19.96 97.8,19.96 97.97,19.8 101.68,19.8 103.14,18.34 130.37,18.34 130.67,18.03 153.47,18.03 154.67,16.83 154.67,16.49 156.68,14.48 179.63,14.48 180.32,13.79 215.74,13.79 216.14,13.39 244.12,13.39 244.61,12.9 259.36,12.9 260.55,14.09 262.41,14.09 262.71,14.39 262.71,14.79 v2(262.95,15.03)
  BOTTOM w0.089: v2(96.29,19.43) 96.67,19.05 UH2.R7
  BOTTOM w0.152: v2(262.95,15.03) 262.95,10.09 261.91,9.05 261.27,9.05 261.26,9.04 JNGFF2.55
CLK_PCIE_SSD#: length 180.1
  IN2 w0.107: v2(262.22,15.03) 262.42,15.03 262.51,14.94 262.51,14.48 262.33,14.3 260.47,14.3 259.28,13.1 244.69,13.1 244.2,13.6 216.22,13.6 215.82,13.99 180.4,13.99 179.72,14.68 156.76,14.68 154.87,16.57 154.87,16.92 153.55,18.23 130.76,18.23 130.45,18.54 103.22,18.54 101.76,20 98.05,20 97.89,20.16 96.05,20.16 95.81,19.92 95.81,19.72 v2(95.53,19.43)
  BOTTOM w0.089: UH2.R8 95.91,19.05 v2(95.53,19.43)
  BOTTOM w0.152: v2(262.22,15.03) 262.33,15.03 262.62,14.74 262.62,10.23 261.78,9.38 261.43,9.38 261.37,9.44 261.37,9.48 261.31,9.54 JNGFF2.53
CLK_PCIE_TBT: length 90
  IN1 w0.107: v2(96.28,24.6) 96.28,24.42 96.1,24.24 90.58,24.24 89.03,22.69 89.03,21.72 87.4,20.09 81.3,20.09 80.73,19.52 78.53,19.52 77.56,18.55 76.2,18.55 75.14,19.61 65.37,19.61 64.76,20.21 63.96,20.21 63.76,20.01 60.72,20.01 60.28,20.46 60.28,21.9 57.33,24.85 53.43,24.85 52.52,23.94 50.83,23.94 49.81,24.95 46.47,24.95 45.57,24.05 45.42,23.9 43.92,23.9 41.22,26.6 40.35,26.6 39.03,25.28 34.22,25.28 33.4,26.1 33.4,26.74 32.24,27.9 29.65,27.9 28.64,28.91 28.64,31.23 27.42,32.45 27.42,32.94 28.31,33.83 28.31,35.15 29.26,36.1 29.26,36.61 29.05,36.83 29.05,36.99 29.15,37.09 v2(29.31,37.09)
  BOTTOM w0.089: v2(96.28,24.6) 96.52,24.37 UH2.D7
  BOTTOM w0.102: v2(29.31,37.09) UT1.V19
CLK_PCIE_TBT#: length 90.1
  IN1 w0.107: v2(96.34,23.95) 96.26,24.04 90.67,24.04 89.23,22.6 89.23,21.64 87.49,19.89 81.39,19.89 80.81,19.31 78.61,19.31 77.65,18.35 76.11,18.35 75.06,19.4 65.28,19.4 64.68,20.01 64.05,20.01 63.85,19.81 60.63,19.81 60.05,20.4 60.05,21.84 57.24,24.65 53.52,24.65 52.6,23.73 50.74,23.73 49.73,24.75 46.56,24.75 45.65,23.85 45.5,23.69 45.33,23.69 43.83,23.69 41.13,26.4 40.43,26.4 39.11,25.08 34.14,25.08 33.2,26.02 33.2,26.65 32.16,27.7 29.57,27.7 28.44,28.83 28.44,31.15 27.22,32.36 27.22,33.03 28.11,33.91 28.11,35.23 29.06,36.19 29.06,36.53 28.84,36.74 28.84,36.91 v2(28.66,37.09)
  BOTTOM w0.089: UH2.D8 96.13,24.16 v2(96.34,23.95)
  BOTTOM w0.102: v2(28.66,37.09) UT1.T19
CLK_PCIE_WLAN: length 328.7
  IN2 w0.107: v2(339.93,86.37) 340.06,86.37 340.41,86.02 340.41,85.84 340.3,85.73 339.86,85.73 339.08,86.52 336.47,86.52 335.52,85.56 335.52,84.53 331.12,80.14 330.45,80.14 329.95,79.64 329.95,76.2 331.33,74.81 331.33,70.53 330.28,69.48 330.28,65.22 331.96,63.53 332.96,63.53 338.28,58.22 338.28,52.71 335.61,50.04 335.61,35.06 334.65,34.1 334.65,32.5 334.14,31.99 326.54,31.99 325.38,30.83 322.64,30.83 318.49,26.67 318.49,26.09 316.65,24.25 313.49,24.25 311.44,22.2 304.18,22.2 303.06,21.08 297.42,21.08 297.16,21.33 294.65,21.33 293.93,20.61 293.93,19.93 293.19,19.19 291.49,19.19 290.97,18.67 288.93,18.67 288.73,18.46 285.32,18.46 282.62,15.76 279.41,15.76 279.08,16.09 268.32,16.09 267.13,17.28 265.35,17.28 265.15,17.08 263.68,17.08 262.75,16.16 261.35,16.16 259.07,13.87 244.9,13.87 244.09,14.69 218.18,14.69 218.18,14.68 180.75,14.68 180.06,15.38 157.49,15.38 156.39,16.48 156.39,17.14 154.57,18.96 147.63,18.96 145.58,21.02 145.58,23.34 143.52,25.4 114.89,25.4 114.52,25.03 108.61,25.03 107.95,24.37 107.95,23.76 107.53,23.34 107.2,23.34 106.39,24.15 104.17,24.15 102.07,22.06 100.59,22.06 100.1,22.54 97.95,22.54 97.79,22.7 97.79,22.94 97.85,23.01 v2(98.29,23.01)
  BOTTOM w0.089: v2(98.29,23.01) 97.82,23.01 97.76,22.95 UH2.G4
  BOTTOM w0.152: JNGFF1.39 340.05,84.68 340.16,84.78 340.16,86.14 v2(339.93,86.37)
CLK_PCIE_WLAN#: length 328.8
  IN2 w0.107: v2(97.38,23.01) 97.58,22.81 97.58,22.62 97.87,22.34 100.02,22.34 100.5,21.85 102.16,21.85 104.25,23.95 106.3,23.95 107.12,23.14 107.62,23.14 108.15,23.67 108.15,24.28 108.7,24.82 114.61,24.82 114.97,25.19 143.44,25.19 145.38,23.25 145.38,20.93 147.55,18.76 154.48,18.76 156.19,17.06 156.19,16.4 157.41,15.17 179.97,15.17 180.67,14.48 218.26,14.48 218.26,14.48 244,14.48 244.82,13.67 259.15,13.67 261.44,15.95 262.84,15.95 263.76,16.88 265.23,16.88 265.43,17.08 267.04,17.08 268.23,15.88 279,15.88 279.33,15.55 282.71,15.55 285.41,18.26 288.81,18.26 289.02,18.46 291.06,18.46 291.58,18.98 293.27,18.98 294.13,19.85 294.13,20.52 294.74,21.13 297.08,21.13 297.33,20.87 303.14,20.87 304.27,22 311.52,22 313.58,24.05 316.74,24.05 318.69,26 318.69,26.59 322.73,30.63 325.46,30.63 326.62,31.78 334.22,31.78 334.85,32.41 334.85,34.01 335.81,34.98 335.81,49.95 338.48,52.62 338.48,58.3 333.05,63.74 332.04,63.74 330.48,65.3 330.48,69.39 331.53,70.45 331.53,74.9 330.15,76.28 330.15,79.55 330.53,79.93 331.21,79.93 335.72,84.45 335.72,85.48 336.56,86.32 338.99,86.32 339.78,85.53 340.39,85.53 340.61,85.76 v2(340.61,86.39)
  BOTTOM w0.089: UH2.E5 97.61,23.24 v2(97.38,23.01)
  BOTTOM w0.152: v2(340.61,86.39) 340.49,86.27 340.49,84.73 340.55,84.67 JNGFF1.41
CLK_PEG_VGA: length 157.9
  IN6 w0.089: v2(202.25,74.19) 202.25,73.97 201.77,73.5 201.77,69.7 201.25,69.18 200.71,69.18 200.69,69.2 198.57,69.2
  IN6 w0.107: v2(96.34,18.68) 96.5,18.83 96.5,19.04 97.5,20.05 101.85,20.05 102.94,18.96 129.76,18.96 130.45,18.28 150.64,18.28 151.27,18.91 180.85,18.91 181.42,19.48 181.42,20.09 179.81,21.7 179.81,25.05 181.36,26.6 181.36,31.19 193.99,43.82 193.99,60.4 193.1,61.29 193.1,67.66 194.65,69.2 198.57,69.2
  BOTTOM w0.089: UH2.U7 96.34,18.24 v2(96.34,18.68)
  BOTTOM w0.102: v2(202.25,74.19) 201.86,73.8 UV1.AL13
CLK_PEG_VGA#: length 157.8
  IN6 w0.089: v2(202.2,73.4) 202.29,73.49 202.43,73.49 202.53,73.39 202.53,73.06 202.44,72.97 202.04,72.97 201.96,72.88 201.96,69.62 201.33,69 198.57,69
  IN6 w0.107: 198.57,69 194.73,69 193.31,67.57 193.31,61.38 194.2,60.49 194.2,43.74 181.56,31.1 181.56,26.51 180.01,24.96 180.01,21.79 181.62,20.18 181.62,19.39 180.93,18.7 151.36,18.7 150.73,18.08 130.36,18.08 129.68,18.76 102.85,18.76 101.77,19.85 97.59,19.85 96.7,18.96 96.7,18.82 96.88,18.64 v2(96.95,18.64)
  BOTTOM w0.089: UH2.U5 96.96,18.38 96.96,18.63 v2(96.95,18.64)
  BOTTOM w0.102: UV1.AK13 v2(202.2,73.4)
CLK_REQ#: length 34.4
  TOP w0.14: QV39.3 198.31,55.8 198.71,56.19 198.71,58.92 v2(197.92,59.71)
  IN2 w0.089: 201.64,62.97 203.49,64.82 203.49,71.18 v2(203,71.67)
  IN2 w0.099: 201.64,62.97 198.38,59.71 v2(197.92,59.71)
  BOTTOM w0.102: UV1.AK12 203,72.55 v2(203,71.67)
  BOTTOM w0.14: RPH32.4 205.69,54.21 205.03,53.55 200.23,53.55 199.53,54.25 199.53,55.66 198.8,56.39 198.8,58.83 v2(197.92,59.71)
CLK_SMB: length 13
  TOP w0.254: PR106.1 19.43,16.83 22.21,14.06 PD101.2 22.21,13.24 22.29,13.15 22.29,12.15 22.24,12.1 v3(22.24,11.5) 22.16,11.43 22.16,10.51 v2(21.87,10.22)
  BOTTOM w0.254: v2(21.87,10.22) 21.87,10.27 22.19,10.58 22.19,10.96 22.35,11.12 BAT100.5
CLK_TP_SIO: length 124
  TOP w0.14: CE77.1 216.38,7.88 v2(217.12,8.62) ; UE3.A37 300.77,21.06 300.97,21.25 300.97,21.88 301.58,22.49 v2(301.58,22.63) 301.88,22.93 RE24.2
  IN3 w0.091: v2(217.12,8.62) 219.54,11.04 230.27,11.04 231.08,11.85 232.67,11.85 233.44,12.62 252.04,12.62 253.76,14.33 256.38,14.33 256.6,14.55 260.49,14.55 261.39,15.46 263.75,15.46 264.39,14.82 266.6,14.82 268.49,16.71 270.24,16.71 272.31,18.78 277.55,18.78 278.57,19.8 279.43,19.8 281.97,22.34 290.17,22.34 291.28,23.45 300.76,23.45 v2(301.58,22.63)
  BOTTOM w0.14: JTP.1 223.4,13.59 223.01,13.98 223.01,14.74 223.75,15.48 228.22,15.48 228.63,15.07 DE4.2 230.39,15.07 230.63,14.83 230.63,12.85 230.21,12.43 226.49,12.43 225.88,11.82 225.88,11.65 225.49,11.25 224.78,11.25 222.84,9.31 222.84,8.96 221.61,7.74 218,7.74 v2(217.12,8.62)
CLKA0: length 35.2
  TOP w0.17: RV348.2 218.62,111.83 218.62,111.19 218.44,111.02 218.19,110.76 218.19,109.76 217.92,109.5 217.74,109.5 v2(217.5,109.73)
  IN6 w0.097: v2(217.5,109.73) 217.05,109.29 217.05,108.6 216.7,108.25 216.35,108.25 215.59,107.48 215.59,107.19 215.25,106.85 211.35,106.85 210.06,105.56 210.06,98.88 213.02,95.91 213.02,92.14 213.63,91.53 213.63,88.56 214.02,88.18 214.9,88.18 215.26,87.82 215.38,87.82 215.57,87.63 v2(215.57,87.62)
  BOTTOM w0.089: v2(215.57,87.62) 215.57,87.69 215.21,88.05 UV1.R30
  BOTTOM w0.114: v2(217.5,109.73) 217.58,109.73 217.89,109.42 UV5.J12
CLKA0#: length 35.8
  TOP w0.17: RV348.1 219.25,112.09 218.95,111.78 218.95,111.06 218.67,110.78 218.52,110.63 218.52,109.62 218.06,109.17 217.68,109.17 v2(217.48,108.96)
  IN6 w0.097: v2(215.58,88.45) 215.73,88.45 215.83,88.35 215.83,88.11 215.71,87.99 215.33,87.99 214.97,88.35 214.09,88.35 213.81,88.63 213.81,91.6 213.2,92.21 213.2,95.98 210.23,98.95 210.23,105.49 211.42,106.68 215.32,106.68 215.76,107.12 215.76,107.41 216.42,108.08 216.77,108.08 217.23,108.53 217.54,108.53 217.69,108.68 217.69,108.84 217.57,108.96 v2(217.48,108.96)
  BOTTOM w0.089: v2(215.58,88.45) 215.2,88.83 UV1.R31
  BOTTOM w0.114: v2(217.48,108.96) 217.88,108.56 UV5.J11
CLKA1: length 35.9
  TOP w0.17: v2(199.47,109.73) 199.53,109.67 199.57,109.67 199.63,109.61 199.75,109.61 200.01,109.87 200.01,110.7 199.76,110.96 199.76,111.83 RV361.2
  IN6 w0.097: v2(199.47,109.73) 199.88,109.73 200,109.62 200,109.45 199.88,109.34 198.93,109.34 198.71,109.12 198.71,108.62 199.26,108.08 201.11,108.08 202.69,106.5 204.1,106.5 209.36,101.24 209.36,98.76 212.39,95.74 212.39,92.09 211.44,91.15 211.44,90.04 209.88,88.48 v2(209.81,88.48)
  BOTTOM w0.089: v2(209.81,88.48) 209.44,88.85 UV1.AB31
  BOTTOM w0.114: UV6.J12 199.59,109.36 199.47,109.48 v2(199.47,109.73)
CLKA1#: length 36.5
  TOP w0.17: RV361.1 200.09,111.76 200.09,111.09 200.34,110.84 200.34,109.74 199.89,109.28 199.71,109.28 199.46,109.03 v2(199.46,108.96)
  IN6 w0.097: v2(199.46,108.96) 199.25,109.17 199,109.17 198.88,109.05 198.88,108.7 199.33,108.25 201.18,108.25 202.76,106.67 204.17,106.67 209.53,101.31 209.53,98.84 212.56,95.81 212.56,92.02 211.62,91.08 211.62,89.97 210.19,88.54 210.19,88.25 210.03,88.1 209.67,88.1 209.39,88.38 v2(208.97,88.38)
  BOTTOM w0.089: UV1.AC31 208.97,88.38 v2(208.97,88.38)
  BOTTOM w0.114: v2(199.46,108.96) 199.46,108.96 199.85,108.56 UV6.J11
CLKB0: length 34.2
  TOP w0.17: v2(243.92,72.01) 244.06,72.14 244.26,72.14 244.58,71.83 246.88,71.83 RV374.2
  IN6 w0.097: v2(224.03,73.41) 223.62,73.41 223.55,73.49 223.55,73.69 223.63,73.78 223.63,74.5 224.05,74.92 225.4,74.92 227.23,76.74 230.56,76.74 230.94,77.12 231.72,77.12 234.76,80.17 236.22,80.17 236.32,80.27 238.33,80.27 241,77.6 241,75.65 242.7,73.95 242.7,72.91 243.24,72.38 243.61,72.38 243.92,72.06 v2(243.92,72.01)
  BOTTOM w0.089: v2(243.92,72.01) 244.31,72.4 UV9.J12 ; v2(224.03,73.41) 224.4,73.04 UV1.D12
CLKB0#: length 34.3
  TOP w0.17: RV374.1 246.83,72.16 244.72,72.16 244.4,72.48 244.18,72.48 243.94,72.72 v2(243.94,72.81)
  IN6 w0.097: v2(243.94,72.81) 243.68,72.55 243.31,72.55 242.88,72.98 242.88,74.02 241.17,75.73 241.17,77.67 238.4,80.44 236.25,80.44 236.15,80.34 234.69,80.34 231.64,77.3 230.87,77.3 230.49,76.92 227.16,76.92 225.33,75.09 223.98,75.09 223.46,74.57 223.46,73.86 v2(223.08,73.48)
  BOTTOM w0.089: v2(223.08,73.48) 223.35,73.2 223.35,73.19 UV1.E12 ; UV9.J11 243.56,72.43 v2(243.94,72.81)
CLKB1: length 34.9
  TOP w0.17: RV387.2 246.83,90 246.22,90 245.76,89.54 244.83,89.54 244.6,89.77 244.6,89.91 v2(244.73,90.04)
  IN6 w0.097: v2(244.73,90.04) 244.41,90.04 244.04,89.67 243.65,89.67 243.35,89.37 242.11,89.37 240.98,88.24 240.98,83.57 238.25,80.84 235.99,80.84 235.89,80.74 233.41,80.74 230.35,77.68 225.06,77.68 223.73,79.01 223.73,79.31 223.58,79.47 223.32,79.47 v2(223.12,79.26)
  BOTTOM w0.089: v2(223.12,79.26) 223.51,79.65 UV1.E20
  BOTTOM w0.114: UV10.J12 244.31,90.45 v2(244.73,90.04)
