# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SD_RCLK_P_R: length 2.8
  BOTTOM w0.102: UR1.16 331.42,37.48 331.29,37.34 331.17,37.34 330.94,37.58 330.81,37.58 v4(330.56,37.82) 330.21,38.18 329.82,38.18 RR3.1
SD_REG2: length 1.5
  BOTTOM w0.14: CR16.1 338,39.51 v3(338.19,39.7)
SIO_EXT_SCI#: length 275.7
  TOP w0.089: RH383.2 77,9.91 v3(77.1,9.81) 77.92,9.81 78.04,9.94 79.78,9.94 79.84,9.99 81.14,9.99 81.32,9.81 81.32,9.24 81.53,9.03 83.38,9.03 84.05,8.35 85.1,8.35 85.52,7.93 86.02,7.93 v2(86.2,7.76)
  TOP w0.14: UE3.A33 302.77,21.48 v2(303.02,21.73)
  IN2 w0.089: 101.98,11.57 100.97,11.57 99.93,10.52 95.22,10.52 94.59,9.89 92.26,9.89 91.69,9.32 90.53,9.32 90.28,9.06 89.19,9.06 88.48,8.36 86.8,8.36 v2(86.2,7.76)
  IN2 w0.099: v2(314.88,11.71) 314.52,11.71 309.64,6.82 301.67,6.82 301.02,6.18 300.08,6.18 299.46,6.8 296.84,6.8 296.44,6.4 292.77,6.4 292.22,6.94 287.85,6.94 287.69,7.1 282.65,7.1 281.9,6.35 275,6.35 273.02,8.33 262.69,8.33 262.45,8.58 256.82,8.58 255.78,7.54 253.14,7.54 252.4,8.29 245.68,8.29 245.37,7.98 240.23,7.98 238.39,6.13 227.64,6.13 227.51,6.26 226.27,7.5 213.62,7.5 210.65,10.47 200.2,10.47 200.18,10.44 184.59,10.44 183.98,9.84 178.51,9.84 177.86,10.49 175.23,10.49 174.63,11.08 164.19,11.08 163.28,10.17 154.74,10.17 154.52,10.38 154.52,11.12 152.35,13.29 114.46,13.29 112.88,11.71 102.79,11.71 102.64,11.57 101.98,11.57
  IN3 w0.091: v2(314.88,11.71) 314.58,12.01 314.58,12.37 314.58,19.46 311.66,22.38 308.33,22.38 307.77,21.83 303.12,21.83 v2(303.02,21.73)
  BOTTOM w0.089: UH2.AV29 86.07,7.62 v2(86.2,7.76)
SIO_EXT_SMI#: length 247.9
  TOP w0.089: v2(79.95,12.65) 79.55,13.04 78.87,13.04 v3(78.6,12.77) 78.23,12.4 76.2,12.4 RH110.1
  TOP w0.14: v2(297.65,8.68) 297.78,8.82 297.78,9.52 297.77,9.53 UE3.A6 ; RE140.1 284.91,8.9 284.91,9.77 v2(284.9,9.77)
  IN5 w0.089: 101.98,13.92 101.04,13.92 100.59,13.46 99.63,13.46 98.94,14.15 96.58,14.15 96.08,14.65 92.12,14.65 90.54,13.06 80.37,13.06 v2(79.95,12.65)
  IN5 w0.099: 101.98,13.92 106.32,13.92 106.58,13.66 115.25,13.66 115.45,13.46 123.88,13.46 124.03,13.62 174.49,13.62 180.12,19.25 180.12,22.82 182.82,25.52 186.51,25.52 186.71,25.33 217.83,25.33 218.82,24.34 218.82,19.87 221.35,17.34 246.17,17.34 252.28,11.24 261.57,11.24 262.21,11.87 264.49,11.87 265.96,10.4 268.63,10.4 269.04,10.82 270.65,10.82 270.96,11.13 283.55,11.13 v2(284.9,9.77) 285.7,9.77 286.69,8.79 287.81,8.79 289.26,10.25 292.18,10.25 293.24,11.31 294.64,11.31 297.27,8.68 v2(297.65,8.68)
  BOTTOM w0.089: UH2.AF41 v2(79.95,12.65)
SIO_EXT_WAKE#: length 249.4
  TOP w0.14: v3(283.01,18.09) 282.73,17.81 v2(282.73,17.59) ; v2(297.52,12.21) 297.02,11.71 UE3.B5
  IN6 w0.089: 75.06,11.73 75.44,12.11 77.57,12.11 78.84,13.38 91.3,13.38 92.05,14.13 95.84,14.13 96.74,13.23 99.27,13.23 99.37,13.32 101.06,13.32 101.31,13.08 101.98,13.08
  IN6 w0.099: v2(282.73,17.59) 281.85,16.71 278.85,16.71 277.58,15.44 273.46,15.44 272.05,14.03 268.53,14.03 265.19,10.69 262.49,10.69 261.81,10.01 250.59,10.01 249.41,11.19 237.2,11.19 236.75,10.74 234.97,10.74 234.59,11.12 230.85,11.12 228.78,13.2 224.86,13.2 224.7,13.04 215.77,13.04 215.61,13.2 201,13.2 200.55,13.65 186.71,13.65 186.12,13.05 169.3,13.05 168.92,12.67 160.39,12.67 159.55,13.5 125.52,13.5 125.09,13.08 112.88,13.08 112.19,12.38 108.38,12.38 107.69,13.08 101.98,13.08 ; 75.06,11.73 73.94,10.61 v2(73.48,10.61)
  BOTTOM w0.089: 75.06,9.99 76.05,9.99 76.34,9.7 78.04,9.7 UH2.AN44
  BOTTOM w0.127: 75.06,9.99 74.11,9.99 v2(73.48,10.61) 73.42,10.68 72.85,10.68 RH523.2
  BOTTOM w0.14: v2(282.73,17.59) 282.73,15.08 284.29,13.52 284.29,12.37 285.88,10.78 285.88,9.95 287.16,8.67 290.63,8.67 291.3,9.34 291.3,9.8 294.45,12.95 296.75,12.95 297.49,12.21 v2(297.52,12.21)
SIO_PWRBTN#: length 362.4
  TOP w0.14: v2(82.68,34.98) 82.35,34.65 82.27,34.65 80.39,32.77 75.6,32.77 74.63,31.8 v1(74.63,27.19) 74.63,24.82 74.98,24.47 74.98,22.53 74.38,21.93 v2(73.97,21.93) ; v2(295.17,16.25) 295.04,16.38 UE3.B58
  IN2 w0.089: v2(94.07,8.58) 94.46,8.96 96.25,8.96 96.8,9.52 97.65,9.52 97.98,9.85
  IN2 w0.099: 97.98,9.85 99.78,9.85 100.28,10.35 105.55,10.35 106.51,11.31 113.05,11.31 114.12,12.39 152.56,12.39 153.88,11.08 153.88,10.46 154.66,9.67 155.69,9.67 156.96,8.4 168.92,8.4 170.63,10.11 174.18,10.11 174.6,9.68 177.53,9.68 178.18,9.04 199.91,9.04 200.53,9.66 210.24,9.66 214.04,5.87 226.68,5.87 227.25,5.29 238.73,5.29 240.61,7.17 245.74,7.17 246.04,7.47 252.06,7.47 252.8,6.73 256.11,6.73 257.16,7.78 262.11,7.78 262.37,7.52 270.52,7.52 272.5,5.55 282.24,5.55 282.99,6.3 284.77,6.3 285.71,5.36 291.57,5.36 v2(292.1,5.9)
  IN3 w0.089: 75.06,17.92 76.24,16.73 77.51,16.73 77.88,16.37 77.88,16.06 79.83,14.11 84.7,14.11 85.12,13.69 85.12,13.14 85.42,12.84 85.42,12.09 86.74,10.78 86.74,10 87.97,8.78 88.79,8.78 89.25,9.24 90.83,9.24 91.83,8.23 93.73,8.23 v2(94.07,8.58)
  IN3 w0.091: v2(82.68,34.98) 83.06,34.6 83.62,34.6 85.19,36.18 85.6,36.18 86.08,36.66 86.56,36.66 87.07,37.17 94.74,37.17 95.84,38.26 97.97,38.26 101.17,41.46 101.17,42.43 112.28,53.54 112.46,53.54 117.54,58.62 117.54,64.01 119.07,65.54 119.73,65.54 122.79,68.61 122.79,71.39 124.6,73.19 124.6,84.8 128.56,88.77 128.56,92.3 131.05,94.79 133.2,94.79 v2(133.86,95.45) ; v2(292.1,5.9) 292.99,6.78 292.99,10.37 294.52,11.9 294.52,15.59 v2(295.17,16.25) ; 75.06,17.92 74.88,18.09 74.88,21.02 v2(73.97,21.93)
  BOTTOM w0.089: v2(94.07,8.58) 93.96,8.46 UH2.AT13
  BOTTOM w0.14: RH6.2 v2(133.86,95.45)
SIO_RCIN#: length 247
  TOP w0.089: RH518.1 92.84,11.88 92.67,11.71 92.67,10.44 v3(92.52,10.3) 92.52,9.33 v2(91.92,8.73)
  TOP w0.14: v2(305.17,16.48) 305.02,16.63 UE3.A27
  IN2 w0.089: 101.98,10.15 100.34,10.15 98.92,8.73 94.75,8.73 94.24,8.21 92.44,8.21 v2(91.92,8.73)
  IN2 w0.099: v2(306.92,5.93) 306.24,6.61 301.74,6.61 300.45,5.32 295.94,5.32 295.78,5.16 285.63,5.16 284.69,6.1 283.07,6.1 282.32,5.35 272.41,5.35 270.44,7.32 262.28,7.32 262.03,7.58 257.24,7.58 256.19,6.53 252.72,6.53 251.98,7.27 246.13,7.27 244.9,6.04 243.57,6.04 242.92,6.69 240.41,6.69 238.81,5.09 233.07,5.09 232.36,4.38 227.89,4.38 226.6,5.67 213.94,5.67 210.15,9.46 200.62,9.46 199.99,8.84 178.09,8.84 177.45,9.48 174.52,9.48 174.13,9.88 170.68,9.88 169,8.2 156.88,8.2 155.91,9.17 153.69,9.17 152.11,10.74 152.11,11.74 151.67,12.19 114.21,12.19 113.13,11.11 106.59,11.11 105.63,10.15 101.98,10.15
  BOTTOM w0.089: v2(91.92,8.73) 91.47,8.28 UH2.AT17
  BOTTOM w0.14: v2(306.92,5.93) 306.64,6.21 306.64,10.63 307.72,11.71 307.72,12.82 306.92,13.61 304.83,13.61 304.48,13.95 304.48,16.14 304.83,16.48 v2(305.17,16.48)
SIO_SLP_A#: length 263.6
  TOP w0.14: UE3.B28 303.45,16.38 303.24,16.16 302.63,16.16 v2(302.18,15.71)
  IN2 w0.089: 101.98,3.82 101.93,3.82 101.92,3.8 100.6,3.8 98.36,1.56 98.35,1.56 98.29,1.5 93.41,1.5 93.06,1.85 92.94,1.85 92.73,2.06 92.73,2.19 92.61,2.31 92.42,2.49 v2(92.36,2.49)
  IN2 w0.099: 101.98,3.82 105.4,3.82 106.88,2.33 108.5,2.33 109.31,1.52 114.15,1.52 119.03,6.4 135.31,6.4 136.63,7.72 144.81,7.72 147.39,5.14 148.99,5.14 151.55,2.57 168.22,2.57 v2(168.81,3.16)
  IN3 w0.091: v2(302.18,15.71) 302.33,15.71 302.75,15.29 303.15,15.29 304.09,14.35 308.1,14.35 308.38,14.07 308.38,10.45 309.76,9.07 309.76,6.74 309.04,6.02 v2(309.04,5.46)
  IN6 w0.099: v2(309.04,5.46) 309.04,4.57 307.09,2.62 268.38,2.62 266.6,4.4 263.79,4.4 262.66,3.27 254.02,3.27 252.63,4.66 247.81,4.66 244.48,1.32 243.96,1.32 243.96,1.32 239.2,1.32 238.54,1.98 215.53,1.98 210.26,7.25 184.89,7.25 181.04,3.4 169.8,3.4 169.55,3.16 v2(168.81,3.16)
  BOTTOM w0.089: v2(92.36,2.49) 92.23,2.62 92.23,3.72 92.44,3.93 92.44,4.38 92.44,4.65 92.58,4.79 UH2.BC15
  BOTTOM w0.14: v2(168.81,3.16) 168.81,3.65 170.11,4.96 174.37,4.96 176.12,6.71 JAPS.6
SIO_SLP_S0#: length 124.6
  TOP w0.127: v3(165.19,2.6) 165.4,2.39 173.74,2.39 RZ61.1
  TOP w0.14: RZ59.1 177.57,2.9 174.82,2.9 RZ61.1 ; v3(165.19,2.6) 164.55,3.24 164.55,3.32 v2(164.35,3.51) 163.45,3.51 162.35,2.41 159.04,2.41 158.2,3.25 157.24,3.25 RE125.1
  IN6 w0.089: 101.98,7.01 101.67,6.71 99.77,6.71 98.01,4.94 96.94,4.94 96.68,4.68 96.34,4.68 95.72,4.68 95.61,4.79 92.75,4.79 92.19,4.22 88.69,4.22 88.06,3.59 87.46,3.59 v2(86.92,3.05) ; v2(86.92,3.05) 86.92,3.06 v2(86.92,3.05)
  IN6 w0.099: v2(163.7,6.42) 163.44,6.16 158.6,6.16 157.63,5.19 152.26,5.19 151.55,5.9 148.2,5.9 144.82,9.27 135.74,9.27 134.71,8.25 134.55,8.25 126.96,8.25 126.22,8.99 118.63,8.99 117.89,8.25 117.34,8.25 115.48,6.39 105.27,6.39 104.95,6.71 104.95,6.87 104.33,7.49 102.46,7.49 101.98,7.01
  BOTTOM w0.089: v2(86.92,3.05) 86.92,3.06 v2(86.92,3.05) ; v2(86.92,3.05) 86.83,3.14 86.83,3.88 86.65,4.06 86.65,4.38 86.62,4.42 86.62,4.8 UH2.BC26
  BOTTOM w0.14: DZ1.2 171.32,8.46 171.62,8.16 JAPS.15 171.62,6.26 171.32,5.97 166.99,5.97 164.54,3.51 v2(164.35,3.51) 163.7,4.16 v2(163.7,6.42)
SIO_SLP_S3#: length 494.3
  TOP w0.14: v2(117.2,10.24) 120.18,10.24 123.08,13.13 123.08,14.25 122.3,15.02 117.29,15.02 116.26,16.05 116.26,17.04 114.27,19.03 109.5,19.03 108.36,20.17 108.36,21.57 108.23,21.7 108.23,25.28 107.97,25.54 107.97,29.37 120.27,41.67 v1(120.27,45.91) 120.27,50.17 120.64,50.54 v2(121.01,50.54) ; RZ81.1 120.3,56.85 v2(120.31,56.85) ; UE3.A35 301.77,21.17 301.9,21.31 301.9,21.93 v2(302.44,22.46) RE35.2 ; UZ20.2 182.25,4.83 181.95,4.54 180.03,4.54 179.45,5.13 179.45,5.58 179.45,5.59 179.45,5.6 179.75,5.9 179.75,7.2 v2(179.44,7.51) 178.63,8.33 v2(178.63,10.36) ; v2(166.46,3.5) 167.28,4.33 UZ21.2
  IN2 w0.099: v2(121.01,50.54) 120.44,51.12 120.44,52.63 120.88,53.07 121.88,53.07 122.54,53.73 122.54,55.65 121.34,56.85 v2(120.31,56.85)
  IN3 w0.091: v2(315.03,8.95) 315.45,9.37 315.45,11.43 315.48,11.46 315.48,11.95 315.45,11.98 315.45,12.04 314.96,12.53 314.96,12.69 314.97,12.69 314.97,19.62 314.85,19.73 311.82,22.77 308.17,22.77 307.61,22.21 304.38,22.21 304.13,22.46 v2(302.44,22.46)
  IN5 w0.089: v5(23.46,44.85) 23.39,44.85 23.06,45.18 23.06,46.34 23.41,46.69 23.41,47.13 ; 20.69,34.3 20.69,40.23 20.58,40.35
  IN5 w0.099: v2(23.01,22.95) 23.45,23.39 23.45,24.69 21.62,26.53 21.62,28.32 21.37,28.57 21.37,32.06 20.69,32.74 20.69,34.3 ; v2(19.5,51.69) 18.45,50.64 18.45,42.47 20.58,40.35 ; 23.41,47.13 23.41,50.58 v2(22.68,51.3)
  IN6 w0.089: 75.06,8.18 76.18,8.18 76.56,8.56 77.58,8.56 77.75,8.72 78.46,8.72 78.54,8.64 78.56,8.64 78.57,8.64 78.9,8.64 79.21,8.94 79.54,8.94 79.84,8.64 79.87,8.64 80.52,7.98 82.13,7.98 82.15,7.96 83.35,7.96 83.72,7.59 85.08,7.59 86.07,6.6 86.93,6.6 87.07,6.46 87.45,6.46 88.42,7.43 88.42,7.88 89.23,8.7 89.96,8.7 90.26,8.39 90.26,7.93 90.58,7.61 90.89,7.61 91.43,8.15 92.51,8.15 92.8,7.86 92.8,7.64 93.1,7.34 v2(93.1,7.3) 93.31,7.3 94.03,8.02 94.32,8.02 95,8.7 98.58,8.7 99.83,9.95 101.98,9.95
  IN6 w0.099: 101.98,9.95 101.99,9.95 102.15,9.79 106.02,9.79 106.32,9.49 107.04,9.49 107.52,9.98 116.94,9.98 v2(117.2,10.24) 117.6,10.63 126.34,10.63 126.65,10.94 146.7,10.94 147.35,10.29 149.38,10.29 150.12,9.56 150.12,8.01 150.4,7.72 151.63,7.72 152.1,8.19 154.26,8.19 156.33,10.26 159.22,10.26 159.87,9.61 163.61,9.61 164.42,8.79 169.21,8.79 171.01,10.59 174.51,10.59 174.96,10.14 178.41,10.14 v2(178.63,10.36) 179.07,10.8 186.99,10.8 187.63,11.44 199.63,11.44 200.48,10.59 210.96,10.59 213.57,7.98 226.78,7.98 227.98,6.78 236.14,6.78 236.82,7.47 246.07,7.47 256.08,7.47 256.81,8.2 262.64,8.2 262.98,7.86 274.06,7.86 275.13,6.79 282.65,6.79 283.75,7.88 291.91,7.88 293.32,9.29 294.17,9.29 294.49,9.61 302.69,9.61 303.02,9.28 312.32,9.28 312.85,8.75 314.83,8.75 v2(315.03,8.95) ; 75.06,8.18 73.37,8.18 72.79,8.76 72.79,9.32 71.93,10.17 71.93,11.42 71.53,11.82 70.31,11.82 69.73,12.41 67.03,12.41 66.86,12.24 65.42,12.24 65.24,12.43 56.97,12.43 56.24,13.17 56.24,13.52 56.21,13.54 56.21,13.54 56.21,13.55 56.21,16.06 56.31,16.16 56.31,17.97 55.88,18.4 55.47,18.4 52.76,21.12 51.79,21.12 51.34,20.67 50.93,20.67 49.92,21.68 48.26,21.68 48.05,21.88 40.1,21.88 38.24,23.74 37.78,23.74 37.78,23.74 35.71,23.74 35.68,23.71 30.84,23.71 30.67,23.54 30.67,23.01 30.11,22.45 28.07,22.45 27.19,23.32 25.11,23.32 24.31,22.53 23.43,22.53 v2(23.01,22.95)
  BOTTOM w0.089: UT1.D2 23.35,44.96 v5(23.46,44.85) ; UH2.AW15 92.79,6.78 93.1,7.09 v2(93.1,7.3)
  BOTTOM w0.14: v2(166.46,3.5) 167.35,2.61 176.34,2.61 177.55,3.82 177.55,5.66 178.12,6.24 JAPS.2 178.12,8.01 178.25,8.14 178.82,8.14 v2(179.44,7.51) ; v2(22.68,51.3) 22.61,51.38 20.38,51.38 20.07,51.69 v2(19.5,51.69)
SIO_SLP_S4#: length 358.4
  TOP w0.14: UZ22.2 121.74,64.52 v2(121.74,64.53) ; v2(121.67,50.81) 121.67,42.39 108.45,29.17 108.45,25.74 109.32,24.87 109.32,20.19 110.01,19.51 113.87,19.51 114.47,19.51 116.74,17.24 116.74,16.25 117.49,15.5 122.5,15.5 126.03,11.97 v2(126.03,7.11) ; v2(302.31,18.71) 302.31,19.52 302.52,19.72 UE3.B36 ; v1(297.4,2.84) 296.95,3.29 v2(296.95,3.4) 296.95,3.51 RE38.2
  IN2 w0.089: v2(93.68,2.06) 94.07,1.68 98.22,1.68 98.28,1.74 98.28,1.74 100.64,4.1 101.03,4.1 101.15,4.22 101.15,4.83 101.25,4.92 101.93,4.92 101.98,4.87
  IN2 w0.099: v2(169.61,3.79) 169.39,4 163.95,4 162.92,2.97 151.76,2.97 149.19,5.54 147.56,5.54 144.98,8.12 136.46,8.12 135.14,6.8 129.29,6.8 128.98,7.11 v2(126.03,7.11) 125.68,7.11 125.37,6.8 118.87,6.8 113.99,1.92 110.16,1.92 108.64,3.44 107.49,3.44 107.44,3.39 106.39,3.39 104.91,4.87 101.98,4.87 ; v2(121.74,64.53) 121.74,63.45 121.32,63.03 121.32,57.16 122.74,55.73 122.74,53.64 121.95,52.85 121.95,51.09 v2(121.67,50.81) ; v2(296.95,3.4) 297.33,3.02 300.52,3.02 301.11,3.62 303.2,3.62 303.38,3.79 309.78,3.79 310.39,4.4 311.01,4.4 313.75,7.14 314.33,7.14 v2(314.48,7.29)
  IN3 w0.091: v2(302.31,18.71) 302.31,19.47 303.79,20.94 312.01,20.94 313.78,19.16 313.78,8.54 314.57,7.75 314.57,7.38 v2(314.48,7.29)
  IN6 w0.099: v2(296.95,3.4) 296.37,2.82 268.47,2.82 266.69,4.6 263.7,4.6 262.58,3.47 254.1,3.47 252.71,4.86 247.73,4.86 244.39,1.52 243.88,1.52 243.88,1.52 239.29,1.52 238.63,2.18 215.61,2.18 210.35,7.45 184.78,7.45 180.94,3.6 169.79,3.6 v2(169.61,3.79)
  BOTTOM w0.089: v2(93.68,2.06) 93.4,1.77 92.88,1.77 92.74,1.91 92.74,2.05 92.73,2.06 92.73,2.36 92.74,2.37 92.74,2.5 92.74,2.5 92.74,2.64 92.41,2.96 92.41,3.65 92.65,3.89 92.65,4.34 92.68,4.37 UH2.BD15
  BOTTOM w0.14: v2(169.61,3.79) 170.54,4.71 174.63,4.71 176.62,6.7 JAPS.5
SIO_SLP_S5#: length 251
  TOP w0.14: v1(168.15,6.74) v2(167.51,6.74) ; v2(305.5,11.72) 305.09,12.13 UE3.A18
  IN2 w0.089: v2(94.17,6.56) 94.47,6.56 94.73,6.82 94.73,7.93 94.98,8.19 95.84,8.19 96.52,7.5 97.33,7.5 97.52,7.69 98.9,7.69 99.79,8.58 101.98,8.58
  IN2 w0.099: 101.98,8.58 102.07,8.58 102.84,9.35 115.74,9.35 117.56,11.17 146.2,11.17 146.23,11.21 146.56,11.21 147.01,10.76 149.59,10.76 151.99,8.36 151.99,8.19 151.99,8.19 151.99,7.4 152.63,6.76 159.42,6.76 159.95,6.24 162.41,6.24 163.1,6.93 167.32,6.93 v2(167.51,6.74) 168.91,6.74 169.52,7.35 178.7,7.35 179.39,8.03 200.32,8.03 200.93,8.64 209.84,8.64 214.46,4.01 227.12,4.01 227.63,3.5 238.82,3.5 240.35,5.03 245.28,5.03 246.15,5.9 251.08,5.9 251.25,5.73 270.9,5.73 272.12,4.51 285.71,4.51 285.75,4.55 296.03,4.55 296.19,4.72 300.72,4.72 301.58,5.57 303.24,5.57 303.72,5.09 307.25,5.09 307.63,5.47 v2(308.36,5.47)
  IN3 w0.091: v2(308.36,5.47) 308.36,5.37 308.29,5.43 308.29,6.79 308.95,7.44 308.95,9.34 306.57,11.72 v2(305.5,11.72)
  BOTTOM w0.089: UH2.BA13 93.61,6.26 93.9,6.56 v2(94.17,6.56)
  BOTTOM w0.14: v2(167.51,6.74) 167.75,6.98 DZ1.3 168.69,9.39 RZ89.1 171.08,10.36 175.52,10.36 177.12,8.75 JAPS.4
SIO_SLP_SUS#: length 226.5
  TOP w0.14: RE111.2 291.33,24.24 290.6,23.52 289.27,23.52 285.31,19.56 v2(285.31,18.87)
  IN2 w0.089: 101.98,8.78 99.74,8.78 98.83,7.86 97.44,7.86 97.26,7.68 96.59,7.68 95.91,8.37 95.76,8.37 94.91,8.37 94.55,8.01 94.55,7.08 94.4,6.93 93.94,6.93 93.79,6.78 93.79,6.65 v2(93.08,5.94)
  IN2 w0.099: v2(284.15,5.29) 283.57,4.71 272.2,4.71 270.98,5.93 251.36,5.93 251.16,6.13 246.08,6.13 245.18,5.23 240.24,5.23 238.72,3.7 227.71,3.7 227.2,4.21 214.54,4.21 209.92,8.84 200.84,8.84 200.24,8.23 179.31,8.23 178.62,7.55 163.44,7.55 162.33,6.44 160.03,6.44 159.5,6.97 157.06,6.97 156.44,7.59 153.04,7.59 149.68,10.96 147.1,10.96 146.65,11.41 146.15,11.41 114.33,11.41 113.37,10.45 106.78,10.45 105.88,9.55 102.76,9.55 101.98,8.78
  IN3 w0.091: v2(284.15,5.29) 284.99,6.13 284.99,8.26 286.17,9.45 286.17,14.71 285.88,15 285.88,18.3 v2(285.31,18.87)
  BOTTOM w0.089: UH2.BB13 93.55,5.7 93.31,5.94 v2(93.08,5.94)
SIO_SLP_WLAN#: length 231
  TOP w0.089: v2(93.08,8.6) v3(93.51,9.03)
  TOP w0.14: UE3.B45 298.02,19.66 298.08,19.59 298.08,18.83 v2(297.6,18.34)
  IN2 w0.099: v2(296.1,5.76) 295.7,5.36 293.24,5.36 292.26,6.34 290.28,6.34 289.69,5.75 285.6,5.75 284.85,6.5 282.9,6.5 282.15,5.75 272.58,5.75 270.61,7.72 262.45,7.72 262.2,7.98 257.07,7.98 256.03,6.93 252.88,6.93 252.14,7.68 245.92,7.68 245.62,7.37 240.48,7.37 238.6,5.5 227.36,5.5 226.75,6.1 214.11,6.1 210.35,9.86 200.45,9.86 199.82,9.24 178.26,9.24 177.61,9.88 174.97,9.88 174.5,10.36 170.51,10.36 168.99,8.84 165.55,8.84 164.96,9.42 160.49,9.42 160.03,9.88 154.74,9.88 154.08,10.54 154.08,11.22 152.67,12.63 114.08,12.63 112.96,11.51 106.43,11.51 105.47,10.55 100.22,10.55 99.7,10.04 97.79,10.04 97.55,9.8 96.58,9.8 96.57,9.8 95.27,9.8 94.87,9.41 94.34,9.41 93.9,8.98 93.45,8.98 93.08,8.61 v2(93.08,8.6)
  IN3 w0.091: v2(296.1,5.76) 296.1,6.61 296.13,6.63 296.13,10.29 296.93,11.1 296.93,12.89 296.55,13.27 296.55,17.29 v2(297.6,18.34)
  BOTTOM w0.089: v2(93.08,8.6) 93.08,8.48 93.61,7.95 UH2.AV13
SM_PG_CTRL: length 204.8
  TOP w0.14: 121.98,54.5 v2(122.01,54.48) ; 121.98,54.5 123.06,54.5 UC1.4 ; 121.98,54.5 121.75,54.74 120.95,54.74 RH525.2
  IN3 w0.091: v2(293.5,29.6) 292.59,28.69 292.59,27.52 290.85,25.78 289.1,25.78 288.32,25.01 281.62,25.01 279.61,23 277.25,23 276.74,22.48 267.79,22.48 266.15,20.84 260.96,20.84 260.69,21.11 260.69,21.11 260.64,21.16 259.05,22.75 258.72,22.75 257.84,21.88 255.51,21.88 252.29,18.66 231.57,18.66 231.02,18.11 229.87,18.11 229.11,17.35 223.23,17.35 223.01,17.12 222.28,17.12 221.61,16.45 179.17,16.45 178.9,16.18 168.73,16.18 168.29,16.62 168.29,26.47 164.15,30.61 161.13,30.61 143.81,47.93 v2(130.72,47.93)
  BOTTOM w0.127: v2(130.72,47.93) 128.56,47.93 v2(122.01,54.48)
  BOTTOM w0.254: v2(293.5,29.6) 293.24,29.35 PR608.1
SMBALERT#: length 3.2
  TOP w0.089: RH505.2 81.45,5.81 80.51,5.81 80.32,5.62 v2(79.78,5.62) 79.39,5.62 v3(79.26,5.5)
  BOTTOM w0.089: v2(79.78,5.62) UH2.BB41
SMBCLK: length 4.9
  TOP w0.14: QH4.6 74.49,6.37 74.88,6.77 RH458.2 v2(76.04,7.37)
  BOTTOM w0.089: v2(76.04,7.37) 76.32,7.65 77.05,7.65 77.43,7.27 77.93,7.27 UH2.AW44
SMBDATA: length 11.2
  TOP w0.14: QH4.3 71.39,5.07 RH459.2 70.92,5.76 v2(71.38,6.22) 70.93,6.68 v3(70.54,6.68)
  IN5 w0.089: v2(78.21,5.79) 77.81,6.19 75.42,6.19 75.06,5.82
  IN5 w0.099: 75.06,5.82 71.78,5.82 v2(71.38,6.22)
  BOTTOM w0.089: v2(78.21,5.79) 78.23,5.79 78.38,5.64 UH2.BB43
SML0_SMBCLK: length 8
  BOTTOM w0.089: 75.9,6.74 77.84,6.74 78.17,6.41 UH2.AY44
  BOTTOM w0.127: 75.9,6.74 75.64,6.99 75.64,7.55 75.45,7.74 v3(73.37,7.74) 72.97,7.74 72.71,8.01 71.69,8.01 RH501.2
SML0_SMBDATA: length 11.3
  IN5 w0.089: 75.06,6.37 78.14,6.37 79.25,5.26 80.67,5.26 v2(80.75,5.34)
  IN5 w0.099: v2(72.29,7.58) 72.29,7.16 73.08,6.37 75.06,6.37
  BOTTOM w0.089: UH2.BB39 80.59,5.5 v2(80.75,5.34)
  BOTTOM w0.14: RH502.2 71.59,6.88 v2(72.29,7.58)
SML0ALERT#: length 3.7
  TOP w0.089: RH503.2 v2(82.04,7.19)
  BOTTOM w0.089: UH2.BA40 81.79,6.17 82.04,6.42 82.04,7.18 v2(82.04,7.19)
SML1_SMBCLK: length 238.8
  TOP w0.089: RH460.2 78.32,7.22 78.5,7.05 v2(78.76,7.05)
  TOP w0.14: UE3.B6 v2(297.52,11.51)
  IN1 w0.076: v2(78.76,7.05) 78.76,8.31 79.28,8.82 84.27,8.82 84.55,9.1 85.82,9.1 86.17,9.45 87.33,9.45 87.81,8.97 88.7,8.97 89.03,9.3 91.21,9.3 92.71,10.8 94.83,10.8 94.94,10.92 97.34,10.92 97.89,10.36 101.23,10.36 101.82,10.95 101.98,10.95
  IN1 w0.099: v2(297.52,11.51) 297.1,11.93 297.1,12.51 296.44,13.17 295.05,13.17 293.61,14.6 291.66,14.6 290.82,15.44 290.82,16.42 290.53,16.71 287.37,16.71 286.72,16.06 286.72,15.33 285.28,13.89 283.55,13.89 282.64,12.98 282.64,12.55 282.25,12.15 276.47,12.15 272.19,7.88 267.33,7.88 266.86,7.42 262.04,7.42 261.99,7.47 259.69,7.47 258.98,6.76 258.22,6.76 258.01,6.55 258,6.55 257.69,6.24 251.23,6.24 250.55,6.92 245.47,6.92 245.12,7.27 239.39,7.27 238.36,6.24 227.67,6.24 226.54,7.37 221.42,7.37 220.98,6.93 212.54,6.93 210.3,9.16 205.88,9.16 205.71,9.34 183.62,9.34 182.62,8.34 179.05,8.34 178.41,7.7 175.83,7.7 173.75,9.77 170.02,9.77 168.55,8.31 156.81,8.31 156.39,8.73 151.23,8.73 151.09,8.87 147.99,8.87 146.15,10.71 144.8,10.71 144.46,11.06 129.37,11.06 128.59,11.85 103.36,11.85 102.46,10.95 101.98,10.95
  BOTTOM w0.089: UH2.AW42 78.83,7.12 v2(78.76,7.05)
SML1_SMBDAT: length 241.9
  TOP w0.089: RH461.2 77.09,7.07 v2(76.87,7.28)
  TOP w0.14: v2(297.33,9.21) 297.27,9.27 UE3.A5 ; v2(282.12,12.84) v3(282.49,12.47)
  IN1 w0.076: 101.98,11.15 101.72,11.15 101.1,10.53 97.99,10.53 97.32,11.2 95.19,11.2 94.84,11.54 92.16,11.54 91.6,10.99 91.6,10.04 91.03,9.47 88.96,9.47 88.63,9.14 87.87,9.14 87.4,9.62 86.07,9.62 85.74,9.94 84.76,9.94 84.41,9.58 84.41,9.19 84.2,8.99 79.21,8.99 78.42,8.2 78.42,7.9 77.81,7.28 v2(76.87,7.28)
  IN1 w0.099: v2(282.12,12.84) 276.86,12.84 272.11,8.08 267.25,8.08 266.78,7.62 262.13,7.62 262.07,7.67 259.61,7.67 258.9,6.96 258.14,6.96 258.04,6.87 258.04,6.87 257.61,6.44 251.31,6.44 250.64,7.12 245.55,7.12 245.2,7.47 237.25,7.47 236.22,6.44 227.75,6.44 226.57,7.63 221.39,7.63 220.91,7.15 212.6,7.15 210.39,9.36 205.97,9.36 205.79,9.54 183.54,9.54 182.54,8.54 178.97,8.54 178.33,7.9 175.91,7.9 173.83,9.98 169.94,9.98 168.47,8.51 156.89,8.51 156.47,8.93 151.31,8.93 149.33,10.91 144.88,10.91 144.5,11.3 129.43,11.3 128.65,12.07 103.25,12.07 102.32,11.15 101.98,11.15
  BOTTOM w0.089: v2(76.87,7.28) 77.12,7.04 UH2.AW45
  BOTTOM w0.14: v2(282.12,12.84) 282.05,12.77 282.05,10.03 284.68,7.4 289.39,7.4 289.5,7.29 296.21,7.29 296.95,8.04 296.95,8.81 297.33,9.19 v2(297.33,9.21)
SML1ALERT#: length 2.5
  TOP w0.089: v2(86.23,8.52) 86.03,8.72 v3(86.03,9.23) 86.03,9.74 RH504.2
  BOTTOM w0.089: UH2.AT27 86.47,8.28 v2(86.23,8.52)
SNB_0.95V: length 1.8
  BOTTOM w0.14: 111.51,57.79 PR802.2 111.51,56.49 v3(111.89,56.1)
SNB_1.05V: length 2.1
  TOP w0.14: PR902.2 v1(214.5,56.75)
SNB_1V: length 3.1
  BOTTOM w0.14: PR502.2 128.14,9.53 128.14,9.86 v1(127.42,10.59)
SNUB_1.2V: length 2.4
  BOTTOM w0.14: v3(263.3,26.73) 263.91,26.73 264.62,27.44 PC611.1
SNUB_3V: length 2.3
  TOP w0.14: v1(333.33,31.14) 334.71,31.14 335.34,31.77
SNUB_5V: length 2.7
  TOP w0.14: v1(341.05,11.41) 339.28,13.18 PR414.2
SP7_SDWP: length 15.5
  IN6 w0.099: v2(337.74,35.09) 337.21,35.62 336.88,35.62 335.66,36.84 335.66,39.7 333.69,41.66 v2(333.69,44.01)
  BOTTOM w0.14: v1(334.71,44.44) 334.57,44.29 333.97,44.29 v2(333.69,44.01) 333,43.32 QR1.1 ; v2(337.74,35.09) 337.04,35.79 336.65,35.79 336.56,35.88 UR1.29
SP7_SDWP_C: length 7.5
  TOP w0.14: v2(329.52,43.32) 329.13,42.93 329.13,42.02 329.45,41.71 329.45,40 328.76,39.3 JCR.11
  BOTTOM w0.14: v2(329.52,43.32) 329.52,43.71 329.77,43.97 QR1.3
SPK_DET#: length 346
  TOP w0.14: v2(302.72,4.55) 302.19,5.08 301.64,5.08 301.32,4.76 RE139.1 ; v2(9.3,15.79) 9.6,15.49 JAUDIO.16 ; v2(59.69,3.31) 60.39,2.61 RH572.1
  IN1 w0.099: v2(59.69,3.31) 59.63,3.25 58.33,3.25 57.27,4.31 57.27,7.61 57.14,7.74 55.87,7.74 52.78,10.83 52.78,11 52.78,12.44 53.22,12.87 57.06,12.87 57.58,13.39 v2(57.58,13.5)
  IN2 w0.089: 75.06,1.67 81.66,1.67 82.24,2.24 83.33,2.24 84.53,3.45 85.36,3.45 85.81,3.9 87.51,3.9 88.31,3.1 v2(89.36,3.1) 89.77,3.1 90.67,3.99 92.38,3.99 92.81,4.42 97,4.42 97.06,4.37 97.24,4.18 98.31,4.18 99.21,5.09 99.21,5.55 100.05,6.38 101.98,6.38
  IN2 w0.099: 101.98,6.38 106.52,6.38 106.77,6.13 115.49,6.13 117.78,8.43 135.35,8.43 135.95,9.03 145.2,9.03 147.58,6.66 150.82,6.66 152.26,5.21 155.84,5.21 156.28,5.66 159.39,5.66 159.61,5.43 163.2,5.43 163.63,5 171.33,5 171.52,4.81 174.94,4.81 176,5.88 182.74,5.88 184.09,7.23 200.66,7.23 201.22,7.8 209.48,7.8 214.7,2.57 225.97,2.57 226.82,1.72 244.11,1.72 247.31,4.92 250.66,4.92 251.83,3.76 262.83,3.76 263.93,4.86 267.62,4.86 269.46,3.03 296.38,3.03 296.5,3.15 296.5,3.66 296.75,3.91 302.08,3.91 v2(302.72,4.55) ; 75.06,1.67 74.49,1.67 73.53,2.63 73.13,2.63 72.72,2.22 70.06,2.22 69.51,1.67 66.23,1.67 65.28,2.62 64.16,2.62 64.14,2.6 60.4,2.6 v2(59.69,3.31)
  IN6 w0.099: v2(57.58,13.5) 57.72,13.64 57.72,14.07 57.21,14.58 57.21,18.29 55.3,20.2 55.3,21.43 54.34,22.39 50.34,22.39 50.25,22.48 48.59,22.48 48.39,22.69 40.44,22.69 38.58,24.55 37.45,24.55 36.51,24.55 30.52,24.55 30.12,24.95 25.04,24.95 24.05,23.96 22.58,23.96 20.94,22.32 20.1,22.32 18.7,20.92 18.7,18.33 16.91,16.54 10.04,16.54 v2(9.3,15.79)
  BOTTOM w0.089: v2(89.36,3.1) 89.68,3.42 89.68,3.83 89.51,3.99 89.51,4.31 89.75,4.55 UH2.BD21
SPK_DET#_EC: length 24.2
  TOP w0.14: UE3.B42 299.52,19.23 v2(299.5,19.2) ; v2(300.23,6.6) 300.86,5.97 RE139.2 301.56,5.67 301.85,5.38 302.58,5.38 303.61,4.35 v1(305.2,4.35)
  BOTTOM w0.14: v2(299.5,19.2) 299.07,18.77 299.07,17.92 298.07,16.93 298.07,10.47 298.9,9.65 298.9,7.39 298.59,7.08 298.59,5.46 298.79,5.25 299.29,5.25 299.64,5.61 299.64,6.01 v2(300.23,6.6)
SPKR: length 112.7
  TOP w0.127: JAUDIO.14 8.8,13.64 8.83,13.61 v2(8.83,13.55)
  TOP w0.14: v2(74.73,3.95) 74.73,3.36 74.49,3.12 RH82.2
  IN2 w0.099: v2(62.87,4.39) 62.45,4.81 59.92,4.81 59.74,4.63 57.7,4.63 57.41,4.92 57.41,11.44 56.82,12.02 56.82,15.25 57.06,15.49 57.06,18.35 55.53,19.88 55.53,21.53 53.01,24.05 51.67,24.05 50.88,24.85 46.82,24.85 45.22,26.44 42.25,26.44 41.57,27.12 35.43,27.12 34.61,26.3 34.33,26.3 33.1,27.52 32.64,27.52 31.87,26.75 28.7,26.75 25.85,23.9 25.13,23.9 23.7,22.47 22.5,22.47 21.08,21.05 19.13,21.05 18.5,20.42 18.5,18.7 17.39,17.59 15.24,17.59 11.55,13.9 9.18,13.9 v2(8.83,13.55)
  IN5 w0.089: v2(87.05,2.29) 86.89,2.29 86.49,2.7 85.39,2.7 84.93,3.15 82.91,3.15 81.96,2.2 75.33,2.2 75.06,2.47
  IN5 w0.099: 75.06,2.47 74.89,2.64 74.89,3.78 v2(74.73,3.95) 74.59,3.81 72.21,3.81 71.74,4.28 69.55,4.28 68.83,3.56 68.39,3.56 68.11,3.29 66.48,3.29 65.04,4.73 63.21,4.73 v2(62.87,4.39)
  BOTTOM w0.089: v2(87.05,2.29) 87.26,2.51 87.26,2.89 87.33,2.96 87.33,3.31 87.01,3.63 87.01,3.95 86.86,4.1 UH2.BD26
SRCCLKREQ1#: length 21.2
  IN3 w0.089: 75.06,8.58 75.11,8.58 75.35,8.82 83,8.82 83.52,8.3 83.52,7.79 83.72,7.59 85.1,7.59 85.65,8.14 86.51,8.14 87.22,7.42 v2(87.25,7.42)
  IN3 w0.091: 75.06,8.58 74.51,8.58 73.81,7.88 73.81,6.84 73.66,6.69 71.2,6.69 70.74,6.23 70.74,6.21 v2(70.74,6.21)
  BOTTOM w0.089: UH2.AW24 87.59,7.02 87.59,7.08 v2(87.25,7.42)
  BOTTOM w0.14: RH549.2 70.54,6.01 70.74,6.22 70.74,6.21 v2(70.74,6.21)
SRCCLKREQ2#: length 19.9
  TOP w0.14: RH550.2 70.03,10.18 v2(70.23,9.98) v3(69.81,9.56)
  IN3 w0.089: v2(87.29,8.72) 86.91,9.1 84.64,9.1 84.54,9 79.59,9 78.88,9.71 75.06,9.71
  IN3 w0.091: v2(70.23,9.98) 70.47,10.21 71.68,10.21 72.18,9.71 75.06,9.71
  BOTTOM w0.089: UH2.AT24 87.76,8.28 87.32,8.72 v2(87.29,8.72)
SRCCLKREQ8#: length 12.7
  BOTTOM w0.089: UH2.BD32 84.17,4.6 84.17,4.34 84.2,4.31 84.2,3.29 83.27,2.36 83.07,2.36 82.38,1.66 v3(80.7,1.66) 80.58,1.55 75.66,1.55 75.06,2.15
  BOTTOM w0.14: 75.06,2.15 74.68,2.53 RP22.7
SRCCLKREQ9#: length 12.7
  BOTTOM w0.089: 75.06,2.73 76.01,1.77 80.04,1.77 80.24,1.98 81.68,1.98 v3(81.9,2.2) 82.9,3.2 83.41,3.2 83.73,3.51 83.73,3.99 83.73,4.24 83.83,4.34 83.83,4.82 84.07,5.05 UH2.BC32
  BOTTOM w0.14: 75.06,2.73 74.76,3.03 RP22.6
SRCCLKREQ10#: length 14.1
  BOTTOM w0.089: UH2.BB31 84.46,5.3 84.35,5.19 84.35,4.41 84.38,4.38 84.38,3.17 83.58,2.37 83.58,2.23 83.45,2.1 83.16,2.1 82.95,1.89 v3(82.95,1.44) 82.93,1.44 82.91,1.42 82.91,1.41
  BOTTOM w0.14: RP22.8 74.51,2.03 75.2,1.34 82.84,1.34 82.91,1.41
SRCCLKREQ11#: length 12.6
  BOTTOM w0.089: 75.06,4.48 75.84,3.69 76.5,3.69 77.22,2.98 77.22,2.47 77.52,2.17 79.74,2.17 80.01,2.45 81.25,2.45 81.73,2.93 81.95,2.93 82.67,3.64 83.15,3.64 83.35,3.84 83.35,4.38 83.35,4.38 83.35,4.63 83.35,4.63 83.35,4.69 83.49,4.82 UH2.BC33
  BOTTOM w0.14: RP23.8 74.56,4.97 75.06,4.48
SRCCLKREQ12#: length 14.4
  TOP w0.14: v1(73.76,7.86) 74.3,7.32 v2(74.3,7.3)
  IN3 w0.089: 75.06,8.11 75.22,8.11 75.76,8.64 77.95,8.64 78.75,7.84 82.91,7.84 83.45,7.3 83.45,6.73 83.3,6.57 v2(82.89,6.57)
  IN3 w0.091: 75.06,8.11 74.71,8.11 74.45,7.85 74.45,7.45 v2(74.3,7.3)
  BOTTOM w0.089: UH2.BA33 83.32,6.15 v2(82.89,6.57)
  BOTTOM w0.14: RP23.5 73.89,6.47 73.8,6.56 73.8,6.8 v2(74.3,7.3)
SRCCLKREQ13#: length 11.6
  IN3 w0.089: v2(82.92,7.13) 82.4,7.65 78.7,7.65 77.89,8.45 75.93,8.45 75.06,7.58
  IN3 w0.091: v2(74.93,7.3) 74.93,7.45 75.06,7.58
  BOTTOM w0.089: v2(82.92,7.13) 83.14,6.91 UH2.AW33
  BOTTOM w0.14: v2(74.93,7.3) 74.93,7.12 74.72,6.9 74.72,6.22 74.47,5.97 RP23.6
SRCCLKREQ14#: length 12.9
  BOTTOM w0.089: 75.06,5.19 75.94,4.31 76.25,4.31 77.53,3.03 77.53,2.57 77.76,2.35 79.53,2.35 80.39,3.2 81.82,3.2 82.47,3.86 83.02,3.86 83.16,3.99 83.16,4.75 83.25,4.83 83.25,5.15 83.46,5.37 UH2.BB33
  BOTTOM w0.14: 75.06,5.19 74.78,5.47 RP23.7
SRCCLKREQ15#: length 11.6
  BOTTOM w0.089: 75.06,3.43 76.49,1.99 79.92,1.99 80.14,2.21 81.4,2.21 81.84,2.65 82.04,2.65 82.81,3.41 83.27,3.41 83.53,3.67 83.53,4.3 83.59,4.35 UH2.BD33
  BOTTOM w0.14: 75.06,3.43 74.61,3.43 74.51,3.53 RP22.5
SSD_CLK_REQ#: length 221.4
  TOP w0.127: 68.32,7.24 67.68,7.89 67.14,7.89 66.92,8.11 66.75,8.11 v2(66.32,8.54)
  TOP w0.14: 68.32,7.24 68.39,7.17 RP2.8
  IN5 w0.089: 75.06,8.42 76.01,8.42 76.77,7.65 77.06,7.65 77.43,7.29 77.99,7.29 78.47,7.77 79.13,7.77 79.15,7.75 82.41,7.75 v2(82.99,8.32)
  IN5 w0.099: v2(66.32,8.54) 66.32,8.58 66.95,9.21 69,9.21 69.46,8.75 71.43,8.75 71.54,8.86 73.14,8.86 73.58,8.42 75.06,8.42
  IN6 w0.089: v2(82.99,8.32) 83.07,8.41 84.53,8.41 84.6,8.33 85.37,8.33 86.15,9.11 87.59,9.11 88.11,8.59 88.87,8.59 89.29,9.01 90.29,9.01 90.48,9.2 91.54,9.2 91.76,9.42 92.31,9.42 92.78,8.96 94.31,8.96 96,10.65 97.38,10.65 97.91,10.12 99.33,10.12 99.56,10.36 101.98,10.36
  IN6 w0.099: 101.98,10.36 102.16,10.36 102.33,10.19 105.96,10.19 106.6,10.83 106.81,10.83 107.46,10.18 113.17,10.18 113.82,10.83 126.26,10.83 126.59,11.17 146.76,11.17 146.79,11.14 147.44,10.49 149.47,10.49 150.32,9.64 150.32,9.46 151.38,8.39 151.88,8.39 154.18,8.39 156.25,10.46 159.3,10.46 159.95,9.81 163.69,9.81 164.51,8.99 169.13,8.99 170.93,10.79 177.47,10.79 177.73,11.05 186.95,11.05 187.55,11.64 199.72,11.64 200.57,10.79 212.05,10.79 213.1,9.74 217.35,9.74 218.91,8.18 227.86,8.18 228.79,9.11 230.3,9.11 231.68,7.73 256.06,7.73 256.73,8.4 262.72,8.4 263.06,8.06 268.95,8.06 v2(269.88,8.99)
  BOTTOM w0.089: v2(82.99,8.32) 82.99,8.3 83.12,8.43 UH2.AT33
  BOTTOM w0.14: v2(269.88,8.99) 269.07,9.79 JNGFF2.52
SSD_PCIE_WAKE#: length 3.7
  TOP w0.127: RD59.1 RD8.1 266.91,9.28 v2(266.81,9.18)
  TOP w0.14: v2(266.81,9.18) 266.54,8.9 v3(266.54,8.56)
  BOTTOM w0.127: JNGFF2.54 266.93,9.29 v2(266.81,9.18)
SSD_PWR_EN: length 191.3
  TOP w0.14: v2(247.78,9.36) 247.78,7.76 v1(247.02,6.99) 244.06,4.03 244.06,2.09 RZ74.1 RZ75.1
  IN2 w0.089: 101.98,15.41 101.44,15.41 100.84,16.01 98.97,16.01 98.54,15.58 94.64,15.58 91.52,18.7 91.52,20 91.14,20.38 88.22,20.38 86.91,19.07 79.17,19.07 77.81,20.43 v2(77.17,20.43)
  IN2 w0.099: v2(247.78,9.36) 247.33,8.91 245.45,8.91 245.12,8.58 239.98,8.58 238.97,7.57 235.99,7.57 235.19,6.77 227.88,6.77 226.51,8.13 216.03,8.13 215.14,9.03 213.72,9.03 211.31,11.44 175.42,11.44 174.7,12.16 155.19,12.16 152.67,14.68 150.99,14.68 150.67,14.99 121.91,14.99 121.73,15.18 102.3,15.18 102.07,15.41 101.98,15.41
  BOTTOM w0.089: UH2.M44 78.11,20.63 77.96,20.63 77.83,20.76 77.58,20.76 77.46,20.63 77.37,20.63 v2(77.17,20.43)
STRAP0: length 8.2
  BOTTOM w0.127: RV308.1 219.77,60.6 219.77,63.99 220.2,64.42 UV1.J2
  BOTTOM w0.14: RV316.2 220.98,59.08 220.98,59.6 221.15,59.77 v3(221.15,60.31) 220.06,60.31 RV308.1
STRAP1: length 16.4
  TOP w0.089: v2(219.81,68.33) 220.07,68.33 220.45,67.95 220.9,67.95 221.07,68.12 221.07,68.47 221.32,68.72 222.59,68.72 222.67,68.64 223.47,68.64 223.56,68.55 224.32,68.55 224.61,68.84 225.36,68.84 226.2,68 226.67,68 227.55,67.13
  TOP w0.127: 227.55,67.13 230.64,64.04
  TOP w0.14: RV307.1 RV315.2 231.21,64.04 230.64,64.04
  BOTTOM w0.102: UV1.J7 220.2,68.75 219.81,68.36 v2(219.81,68.33)
STRAP2: length 12.7
  TOP w0.089: 226.06,67.08 222.01,67.08 221.53,67.56 v2(221.4,67.56)
  TOP w0.127: 226.06,67.08 v3(226.89,66.25) 227.46,65.68 227.46,65.22 228.54,64.14 229.31,64.14 RV306.1
  TOP w0.14: RV306.1 RV314.2
  BOTTOM w0.102: v2(221.4,67.56) 221.29,67.45 220.6,67.45 220.2,67.85 UV1.J6
STRAP3: length 11.2
  TOP w0.089: 227.74,63.87 227.42,64.19 227.08,64.19 226.8,64.47 226.8,65.31 226.43,65.68 225.98,65.68 225.22,66.45 v3(224.98,66.45) 224.53,66.45 224.33,66.25 223.11,66.25 222.75,66.62 222.02,66.62 221.56,67.08 221.25,67.08 220.82,66.65 v2(220.6,66.65)
  TOP w0.127: RV310.2 RV302.1
  TOP w0.14: 227.74,63.87 RV310.2
  BOTTOM w0.102: UV1.J5 220.2,67.05 v2(220.6,66.65)
STRAP4: length 6.9
  BOTTOM w0.127: RV301.1 219.39,60.79 v3(219.39,61.69) 219.48,61.78 219.48,64.14 219.81,64.47 219.81,65.06 UV1.J3
  BOTTOM w0.14: RV301.1 218.1,59.5 RV309.2
SUS_ON: length 3.1
  TOP w0.14: UE3.A9 299.27,9.48 299.05,9.25 v3(299.05,8.75) 299.05,8.68 RE39.2
SUS_ON_EC: length 428.8
  TOP w0.14: v2(120.89,49.97) 120.89,41.95 108.21,29.27 108.21,25.64 109.08,24.77 109.08,20.09 109.91,19.27 113.97,19.27 114.37,19.27 116.5,17.14 116.5,16.15 117.39,15.26 122.4,15.26 123.32,14.35 123.32,13.03 122.84,12.55 122.84,12.49 117.81,7.47 117.81,7.36 v2(117.81,7.36) ; RT240.1 14.07,28.38 v2(13.77,28.08) ; v2(279.27,7.63) 279.27,5.85 277.5,4.07 v2(271.02,4.07) ; RE39.1 297.82,6.1 v2(298.14,5.78) 298.45,5.47 RE30.1 RE38.1 ; v2(123.34,64.36) 122.86,63.87 UZ22.1
  IN2 w0.099: v2(123.34,64.36) 121.84,62.86 121.84,58.04 122.42,57.46 122.88,57.46 123.7,56.64 123.7,54.32 122.15,52.76 122.15,50.53 121.59,49.97 v2(120.89,49.97)
  IN3 w0.091: v2(165.86,3.49) 166.72,4.35 168.2,4.35 169.87,6.02 175.24,6.02 176.3,7.08 182.78,7.08 183.6,7.91 210.16,7.91 215.09,2.97 233.89,2.97 236.19,5.27 242.75,5.27 243.86,4.16 246.86,4.16 247.05,4.35 249.37,4.35 249.88,3.85 263.87,3.85 264.8,4.77 267.53,4.77 268.58,3.72 270.41,3.72 270.77,4.07 v2(271.02,4.07)
  IN5 w0.099: v2(298.14,5.78) 296,7.92 296,9.34 294.44,10.91 293.41,10.91 292.34,9.84 291.83,9.84 289.17,7.19 279.71,7.19 v2(279.27,7.63)
  IN6 w0.089: 101.98,6.18 101.96,6.18 101.86,6.08 99.9,6.08 99.24,5.42 99.24,3.8 98.63,3.2 97.52,3.2 97.4,3.32 97.4,3.84 97.09,4.14 95.5,4.14 95.39,4.25 93,4.25 92.22,3.48 91.68,3.48 90.57,2.37 90.11,2.37 89.9,2.16 87.76,2.16 87.26,2.67 86.76,2.67 86.52,2.9 84.62,2.9 84.05,2.34 79.77,2.34 78.94,1.51 75.06,1.51
  IN6 w0.099: v2(13.77,28.08) 13.41,27.72 13.41,27.25 8.92,22.76 8.51,22.76 5.76,20.01 5.76,17.93 7.89,15.8 7.89,9.71 10.18,7.42 11.15,7.42 16.15,2.42 18.86,2.42 19.43,1.85 25.91,1.85 26.67,2.61 28.07,2.61 28.83,1.85 31.24,1.85 31.76,2.37 32.5,2.37 33.54,1.33 57.67,1.33 57.85,1.51 57.86,1.51 59.03,2.68 59.9,2.68 62.39,5.17 63.07,5.17 63.18,5.28 69.32,5.28 70.92,3.68 72.68,3.68 74.85,1.51 75.06,1.51 ; v2(165.86,3.49) 165.86,3.57 164.31,5.11 158.66,5.11 158.13,4.59 150.32,4.59 149.77,5.14 148.1,5.14 145.02,8.23 135.55,8.23 134.73,7.41 134.39,7.41 133.26,7.41 132.83,6.98 130.03,6.98 129.4,7.62 126.75,7.62 125.97,8.39 118.88,8.39 117.85,7.36 v2(117.81,7.36) 117.31,7.36 115.68,5.73 109.7,5.73 108.87,4.9 107.43,4.9 106.77,5.56 105.11,5.56 104.49,6.18 101.98,6.18
SUS_ON_EC_P: length 305.5
  TOP w0.14: UZ23.1 v2(105.22,53.36) 104.9,53.68 104.9,54.24 105.09,54.43 RZ91.1 ; UZ10.3 183.01,10.86 183.71,11.57 183.71,16.6 181.37,18.93 181.37,22.82 181.04,23.15 181.04,24.52 181.23,24.71 181.23,28.1 v1(180.1,29.23) v2(178.8,30.53) ; v2(129.92,68.85) 129.91,68.84 129.16,68.84 128.67,69.33 125.76,69.33 UZ18.1 ; v2(119.13,65.99) 119.43,66.29 RZ87.1 120.59,66.04 UZ22.4
  IN1 w0.089: v2(139.07,67.37) 139.07,67.36 138.56,66.85 137.68,66.85 136.93,67.59 134.85,67.59 134.62,67.36
  IN1 w0.099: 134.62,67.36 131.93,64.67 131.41,64.67 130.88,65.2 130.88,67.89 v2(129.92,68.85)
  IN2 w0.099: v2(291.54,27.82) 289.62,25.9 287.07,25.9 286.4,26.58 282.27,26.58 281.73,27.11 278.78,27.11 274.86,23.2 268.39,23.2 267.33,22.13 264.31,22.13 264.09,22.36 263.69,22.36 263.29,21.96 260.49,21.96 259.36,23.09 258.52,23.09 257.37,21.94 254.57,21.94 253.15,20.52 251.76,20.52 v2(251.56,20.71) ; v2(129.92,68.85) 129.36,68.3 129.36,67.65 128.37,66.66 124.13,66.66 123.52,66.05 119.19,66.05 v2(119.13,65.99)
  IN3 w0.089: 181.1,68.21 176,68.21 175.08,69.12 161.09,69.12 159.56,70.65 156.49,70.65 155.12,69.27 144.96,69.27 144.73,69.5 142.6,69.5 142.39,69.3 142.22,69.3 140.7,67.78 139.49,67.78 v2(139.07,67.37)
  IN3 w0.091: 181.1,68.21 182.56,68.21 v2(183.2,67.57)
  IN5 w0.099: v2(251.56,20.71) 251.56,20.93 250.56,21.93 250.56,25.07 249.44,26.2 227.52,26.2 223.88,29.84 186.08,29.84 184.55,28.3 181.03,28.3 v2(178.8,30.53)
  IN6 w0.099: v2(105.22,53.36) 113.19,53.36 116.73,56.91 116.73,62.27 119.13,64.66 v2(119.13,65.99) ; v2(183.2,67.57) 183.78,67.57 185.9,65.46 188.92,65.46 190.04,64.34 190.04,62.42 192.69,59.77 192.69,44.45 180,31.77 180,31.72 v2(178.8,30.53)
  BOTTOM w0.254: v2(291.54,27.82) 292.39,27.82 292.75,28.18 PR606.1
SUS_ON_EC_ST: length 118.7
  TOP w0.14: UZ15.4 180.02,85.11 v2(179.87,85.26) ; RZ91.2 106.31,54.1 106.62,53.79 106.62,53.35 107.13,52.84 107.13,52.32 107.38,52.06 UZ23.4 108.84,52.06 RZ88.1 109.59,51.32 v3(111.96,51.32) 112.8,51.32 113.88,50.24 113.88,49.32 114.03,49.17 114.03,48.53 v2(113.67,48.17)
  IN2 w0.099: v2(113.67,48.17) 113.92,48.42 116.23,48.42 117.33,49.51 121.67,49.51 124.72,52.56 124.72,56.94 124.28,57.37 124.28,61.3 126.42,63.43 130.43,63.43 v2(130.9,63.9)
  IN3 w0.089: 181.1,69.21 180.28,68.39 176.07,68.39 175.16,69.3 161.16,69.3 159.64,70.82 156.42,70.82 155.05,69.45 145.03,69.45 144.18,70.3 141.48,70.3 140.4,69.22 v2(140.4,68.97) ; 179.9,85.26 v2(179.87,85.26)
  IN3 w0.091: 179.9,85.26 179.99,85.26 182.25,83 183.45,83 184.28,82.18 184.28,75.7 181.17,72.59 181.17,69.28 181.1,69.21
  IN6 w0.089: 134.62,67.7 134.94,68.02 138.37,68.02 139.32,68.97 v2(140.4,68.97)
  IN6 w0.099: v2(130.9,63.9) 132.47,63.9 133.92,65.35 133.92,67 134.62,67.7
SUS_ON_P: length 10.8
  TOP w0.14: v2(127.64,68.27) 127.95,68.27 RZ80.1 127.88,67.56 UZ18.4 ; RZ72.1 134.48,70.06 v2(134.9,69.64)
  BOTTOM w0.14: v2(134.9,69.64) 134.61,69.34 128.7,69.34 v2(127.64,68.27)
SUSACK#: length 238.9
  TOP w0.14: v2(298.5,12.16) 298.02,11.68 UE3.B7 ; v1(185.23,3.87) 184.59,4.51 v2(184.59,4.76)
  IN2 w0.089: v2(90.42,2) 90.44,2 90.69,2.25 90.69,2.75 90.99,3.06 92.07,3.06 93.02,4.01 96.91,4.01 97.68,3.24 99.11,3.24 99.57,3.7 99.57,5.4 100.15,5.98 101.98,5.98
  IN2 w0.099: v2(184.59,4.76) 184.59,4.47 183.91,3.78 182.63,3.78 182.11,3.26 170.99,3.26 169.84,4.42 163.63,4.42 163.06,4.99 159.49,4.99 159.24,5.24 156.58,5.24 156.07,4.74 150.56,4.74 149.04,6.26 147.41,6.26 145.08,8.58 136.36,8.58 134.98,7.2 129.58,7.2 129.05,7.74 125.69,7.74 125.15,7.2 118.7,7.2 116.84,5.34 112.6,5.34 111.91,4.66 108.38,4.66 108.17,4.87 107.46,4.87 106.35,5.98 101.98,5.98
  IN3 w0.091: v2(298.91,3.43) 298.91,4.12 298.55,4.48 298.55,8.02 298.62,8.09 298.62,9.58 297.94,10.26 297.94,11.95 298.16,12.16 v2(298.5,12.16)
  IN5 w0.099: v2(298.91,3.43) 298.48,3.85 282.86,3.85 281.67,5.05 273.78,5.05 272.85,5.98 271.46,5.98 270.62,6.82 262.75,6.82 262.27,7.3 240.99,7.3 239.6,5.9 227.7,5.9 226.36,7.25 218.07,7.25 217.86,7.04 211.26,7.04 210.83,7.48 189.84,7.48 186.68,4.31 185.04,4.31 v2(184.59,4.76)
  BOTTOM w0.089: v2(90.42,2) 89.97,2.45 89.97,2.95 90.03,3.02 90.03,3.5 90.07,3.54 90.17,3.64 90.17,4.13 89.98,4.31 89.98,5.09 90.28,5.39 UH2.BB19
SUSCLK: length 333.8
  TOP w0.14: RD9.2 266.6,6.36 266.17,6.79 v2(266.17,9.18) ; v3(339.4,99.44) 339.61,99.22 340.18,99.22 v2(340.35,99.39) RN1.2
  IN1 w0.099: v2(266.17,9.18) 267.75,10.77 270.36,10.77 272.47,12.88 273.59,12.88 275.07,14.35 282.8,14.35 284.89,16.44 285.47,16.44 285.89,16.86 285.89,17.38 286.42,17.91 288.77,17.91 289.05,18.2 290.91,18.2 291.51,17.6 293.29,17.6 294.23,16.66 297.61,16.66 298.65,17.69 301.28,17.69 301.79,18.21 303.09,18.21 303.85,18.97 305.92,18.97 307.87,20.92 314.4,20.92 318.37,24.89 318.37,25.5 318.37,39.42 320.76,41.81 323.57,41.81 326.99,45.23 326.99,45.73 329.5,48.24 329.5,54.28 333.41,58.19 333.41,66.48 332.84,67.05 332.84,72.97 331.66,74.15 331.66,86.54 338.52,93.4 338.52,96.72 340.35,98.55 v2(340.35,99.39)
  IN6 w0.089: v2(93.01,9.53) 93.37,9.88 94.64,9.88 95.8,11.05 97.5,11.05 98.03,10.52 99.2,10.52 99.44,10.76 101.98,10.76
  IN6 w0.099: 101.98,10.76 102.33,10.76 102.5,10.59 105.77,10.59 106.42,11.24 106.97,11.24 107.63,10.58 113,10.58 113.66,11.24 126.09,11.24 126.42,11.57 146.93,11.57 146.95,11.55 147.27,11.23 147.6,10.9 149.63,10.9 150.72,9.81 150.72,9.63 151.55,8.79 151.72,8.79 154.01,8.79 156.08,10.86 159.47,10.86 160.12,10.21 162.96,10.21 163.8,11.05 169.57,11.05 169.71,11.19 177.24,11.19 177.49,11.45 186.78,11.45 187.38,12.04 199.88,12.04 200.73,11.19 212.22,11.19 213.25,10.15 228.09,10.15 228.74,9.51 230.47,9.51 231.78,8.2 248.28,8.2 248.89,8.8 262.89,8.8 263.13,8.56 265.55,8.56 v2(266.17,9.18)
  BOTTOM w0.089: UH2.AN15 92.69,9.83 v2(93.01,9.53)
SUSCLK_R: length 8.9
  TOP w0.14: v2(340.82,92.74) 341.26,93.19 v3(341.26,98.75) RN1.1
  BOTTOM w0.14: v2(340.82,92.74) 340.8,92.73 JNGFF1.42
SW_1.2V: length 13.1
  IN6 w1.016: v2(272.16,29.47) 272.48,29.79 280.04,29.79 282.03,27.8 284.35,27.8
  vias: v2(270.89,29.47) v2(285.69,27.95) v2(286.13,28.33)
SW_+1.35VRUN:
  vias: v1(241.77,57.37) v2(240.25,55.24) v2(240.25,54.6) v2(240.27,54) v2(240.3,53.36) v2(240.55,58.25) v2(240.55,57.64) v2(240.55,57.01) v2(240.56,56.4) v2(240.56,55.76) v2(240.79,55) v2(240.79,54.36) v2(240.81,53.72) v2(241.16,53.23) v2(241.43,55) v2(241.43,54.36) v2(241.54,53.68) v2(242.09,54.99) v2(242.08,54.36) v2(242.18,53.68) v2(242.83,53.67) v2(243.46,58.17) v2(243.46,57.54)
SYS_PEX_RST_MON#: length 40
  TOP w0.127: v3(198.91,51.75) 199.59,51.06 RV187.1 200.61,50.17 200.99,49.79 200.99,49.36 200.03,48.4
  TOP w0.14: 200.03,48.4 199.93,48.3 UV14.4 ; v3(198.91,51.75) 198.44,52.22 RV50.2 197.82,53.11 RV208.1 199.03,54.33 DV8.2 v2(199.63,53.43)
  IN6 w0.089: 217.71,62.97 218.03,63.29 218.03,64.16 v2(218.92,65.05)
  IN6 w0.099: v2(199.63,53.43) 200.63,52.42 203.32,52.42 204.43,53.53 206.62,53.53 207.87,54.78 207.87,57.76 207.89,57.78 210.37,60.26 213.83,60.26 214.14,60.56 214.14,61.35 214.59,61.81 216.55,61.81 217.71,62.97
  BOTTOM w0.089: UV1.L3 218.52,65.45 v2(218.92,65.05)
SYS_RESET#: length 205.7
  TOP w0.127: v2(115.25,47.39) 116.07,46.58 116.07,39.87 106.33,30.14 102.03,30.14 99.15,27.26 99.15,25.71 100.12,24.75 100.12,23.22 101.76,21.58 102.16,21.58 105.58,18.16 v1(106.55,18.16) 106.69,18.02 108.87,18.02 109.44,17.45 112.94,17.45 113.54,16.84 113.54,16.47 113.41,16.33 113.41,12.51 111.58,10.68 106.43,10.68 104.7,8.95 104.7,7.78 104.85,7.63 104.85,5.32
  TOP w0.14: v2(104.33,5.32) 104.85,5.32 RH571.1
  IN4 w0.091: v2(124.8,93.87) 124.7,93.87 123.11,92.29 122.99,92.29 122.99,86.93 124.47,85.44 124.47,71.28 121.63,68.44 121.63,67.28 117.43,63.08 117.43,52.76 116.97,52.3 116.97,49.11 v2(115.25,47.39)
  IN6 w0.099: v2(165.25,3.53) 164.83,3.95 163.45,3.95 162.77,3.27 157.4,3.27 156.28,4.39 150.24,4.39 149.69,4.94 148.02,4.94 144.98,7.98 142.14,7.98 140.99,6.84 140.12,6.84 139.75,7.2 135.09,7.2 134.89,7.01 134.23,7.01 134.23,7.01 133.42,7.01 133,6.58 129.86,6.58 129.27,7.18 126.61,7.18 125.81,7.99 119.93,7.99 116.37,4.43 109.01,4.43 108.15,3.56 107.18,3.56 107,3.39 106.26,3.39 v2(104.33,5.32)
  BOTTOM w0.089: UH2.AW1 99.41,7.04 99.43,7.01 100.54,7.01 101.47,6.08 101.47,5.85 101.88,5.44
  BOTTOM w0.127: 101.88,5.44 101.88,5.14 102.13,4.89 103.9,4.89 v2(104.33,5.32)
  BOTTOM w0.14: v2(165.25,3.53) 167.45,5.72 172.21,5.72 172.66,6.17 172.66,6.83 172.62,6.87 JAPS.13 ; v2(124.8,93.87) 124.8,94.2 RH8.2
TB_HDMI_HPLUG: length 58.6
  IN5 w0.089: v2(25.22,46.64) 25.22,47.13
  IN5 w0.099: 25.22,47.13 24.26,48.09 24.26,48.76 24.78,49.28 24.78,49.74 24.13,50.38 24.13,52.99 22.96,54.17 22.96,55.7 23.5,56.24 23.5,57.49 24.08,58.07 24.08,59.39 24.38,59.7 24.38,62.69 23.59,63.48 23.59,65.57 21.83,67.34 21.83,76.5 24.16,78.83 24.16,80.86 24.87,81.57 v2(24.87,81.62)
  BOTTOM w0.102: v2(25.22,46.64) 25.22,46.41 24.73,45.92 UT1.G1
  BOTTOM w0.127: RV122.1 16.8,87.37 16.41,87.37 15.88,86.84 15.88,83.32 20.32,78.88 21.48,78.88 24.23,81.62 v2(24.87,81.62)
  BOTTOM w0.14: QV14.3 16.86,87.76 17.12,87.5 RV122.1
TBT_BATLOW#: length 2.8
  TOP w0.089: 23.94,47.13 23.89,47.07 23.89,46.53 v5(24.13,46.29)
  TOP w0.14: RT25.2 24.47,47.24 24.06,47.24 23.94,47.13
  BOTTOM w0.089: UT1.F2 24.03,45.51 24.03,46.19 v5(24.13,46.29)
TBT_CIO_PLUG_EVENT#: length 94.3
  TOP w0.089: v2(79.27,17.23) 79.87,16.64 v1(80.27,16.64)
  TOP w0.14: RT23.2 32.45,47.47 v2(32.47,47.44)
  IN6 w0.089: 31.62,47.13 29.73,45.23 27.89,45.23 27.26,44.59 27.26,44.03 26.34,43.11 26.34,42.45 24.79,40.9 24.79,39.58 23.53,38.32 22.68,38.32 22.4,38.04 22.4,37.1 23.73,35.77 26.39,35.77 27.48,34.67 27.48,34.3 ; v2(79.27,17.23) 80.06,18.02 80.06,18.73 77.95,20.84 75.06,20.84
  IN6 w0.099: 31.62,47.13 31.94,47.44 v2(32.47,47.44) ; 27.48,34.3 27.48,32.85 27.43,32.79 27.43,31.53 29.23,29.72 32.5,29.72 35.82,33.03 39.81,33.03 40.1,32.75 42.66,32.75 46.4,29.01 50.12,29.01 50.55,28.58 56.26,28.58 58.8,26.04 62.23,26.04 65.05,23.23 71.15,23.23 73.54,20.84 75.06,20.84
  BOTTOM w0.089: v2(79.27,17.23) 79.68,17.64 UH2.U41 ; UT1.W2 30.48,45.5 30.48,45.9 31.37,46.79 31.57,46.79 31.69,46.91 31.7,46.91 31.87,47.08 31.9,47.08 31.9,47.09 32.34,47.09
  BOTTOM w0.127: v2(32.47,47.44) 32.46,47.43 32.46,47.21 32.34,47.09
TBT_CLK_REQ#: length 104.6
  TOP w0.127: 68.87,4.49 68.57,4.49 68.34,4.26 68.07,4.26 v2(67.81,4.01)
  TOP w0.14: 68.87,4.49 69.22,4.83 69.22,5.72 68.86,6.08 RP2.7
  IN1 w0.099: v2(37.87,25.99) 37.58,26.27 34.3,26.27 33.91,26.66 33.91,27.02 33.15,27.79 33.15,30.93 33.96,31.75 33.96,33.73 35.03,34.79 35.03,35.72 33.43,37.32 33.43,40.68 32.38,41.73 32.38,43.16 v2(32.86,43.63)
  IN2 w0.099: v2(56.26,9.15) 54.42,9.15 54.08,9.49 54.08,10.05 54.5,10.47 54.5,11.37 56.22,13.09 56.22,15.49 56.46,15.74 56.46,18.1 54.93,19.63 54.93,21.28 52.76,23.45 51.38,23.45 50.59,24.25 46.57,24.25 44.97,25.84 42,25.84 41.34,26.5 38.38,26.5 v2(37.87,25.99)
  IN5 w0.089: 75.06,4.19 75.16,4.09 75.16,3.59 76.37,2.38 81.89,2.38 82.84,3.33 85,3.33 85.46,2.88 86.56,2.88 86.78,2.66 87.2,2.66 87.43,2.43 87.43,2.29 88.01,1.72 v2(88.01,1.72)
  IN5 w0.099: v2(56.26,9.15) 56.51,9.15 58.87,6.79 61.83,6.79 62.36,6.27 63.53,6.27 64.78,5.02 65.71,5.02 66.13,4.61 66.13,3.92 66.57,3.49 67.29,3.49 v2(67.81,4.01) 68.28,4.48 71.82,4.48 72.29,4.01 73.21,4.01 73.55,4.35 74.9,4.35 75.06,4.19
  BOTTOM w0.089: 32.22,43.89 32.36,43.89 32.61,43.63 v2(32.86,43.63) 33.04,43.82 33.55,43.82 33.66,43.93 ; v2(88.01,1.72) 87.72,2 87.72,2.35 87.62,2.45 87.62,2.75 87.69,2.82 87.69,3.46 87.47,3.69 UH2.BE25
  BOTTOM w0.102: 32.22,43.89 UT1.AC5
  BOTTOM w0.127: RT21.2 33.66,43.93
TBT_DDC_CLK: length 74.1
  IN6 w0.099: v2(34.15,47.02) 33.77,47.02 33.2,47.6 33.2,48.81 32.06,49.94 30.28,49.94 28.61,51.61 28.61,56.66 27.48,57.79 27.48,61.43 25.11,63.8 25.11,65.9 23.93,67.08 23.93,81.39 26.21,83.68 26.21,89.64 27.18,90.6 27.18,94 26.47,94.7 17.77,94.7 15.98,92.91 15.98,91.27 v2(15.46,90.75)
  BOTTOM w0.076: UT1.Y2 30.94,45.49 30.94,45.9 31.4,46.36 32.17,46.36 32.4,46.6 32.47,46.6 32.94,47.08 33.29,47.08
  BOTTOM w0.14: QX1.1 15.69,90.98 v2(15.46,90.75) ; 33.29,47.08 33.61,47.39 RT33.2 33.74,47.43 v2(34.15,47.02)
TBT_DDC_DATA: length 69.8
  IN6 w0.089: 32.78,47.13 32.37,46.72 v2(32.02,46.72)
  IN6 w0.099: v2(16.51,92.61) 18.4,94.5 26.39,94.5 26.98,93.91 26.98,90.69 26.14,89.85 26.12,89.85 26.12,89.84 26.01,89.72 26.01,83.77 23.72,81.48 23.72,66.99 24.9,65.81 24.9,63.72 27.27,61.36 27.27,57.73 28.41,56.58 28.41,51.53 30.2,49.74 31.98,49.74 33,48.73 33,47.34 32.78,47.13
  BOTTOM w0.076: 32.21,46.81 32.11,46.81 v2(32.02,46.72) 31.88,46.58 31.39,46.58 30.71,45.9 UT1.Y1
  BOTTOM w0.102: RT34.2 33.02,47.41 32.42,46.81 32.21,46.81
  BOTTOM w0.14: v2(16.51,92.61) 16.77,92.86 QX1.4
TBT_FORCE_PWR: length 97.9
  TOP w0.14: v3(21.84,32.32) 21.84,32.47 v2(21.34,32.97) 20.99,32.62 RT38.2
  IN2 w0.099: v2(77.34,19.06) 77.73,18.68 77.73,12.64 77.53,12.44 75.58,12.44 73.6,14.42 73.6,20.27 74.98,21.66 74.98,23.37 73.5,24.85 60.27,24.85 56.02,29.1 48.05,29.1 45.8,31.35 40.67,31.35 38.51,33.51 30.66,33.51 29.87,34.3 22.23,34.3 22.1,34.17 22.1,33.73 v2(21.34,32.97)
  IN3 w0.089: v2(24.77,44.26) 24.32,43.81 23.1,43.81 22.81,43.51 22.81,42.13 21.98,41.3 21.98,37.09 22.55,36.52 22.55,35.37 21.94,34.76 21.94,34.3
  IN3 w0.091: v2(21.34,32.97) 21.94,33.57 21.94,34.3
  BOTTOM w0.089: UH2.P43 78.68,19.38 78.49,19.19 78.45,19.19 78.41,19.15 78.16,19.15 78.12,19.19 78.03,19.19 77.9,19.06 77.73,19.06 77.6,18.93 77.47,18.93 v2(77.34,19.06) ; v2(24.77,44.26) 25.08,44.57 UT1.H4
TBT_I2C_CLK: length 31.8
  IN2 w0.099: v2(11.85,39.33) 12.24,39.73 12.64,39.73 13.06,39.32 13.06,38.91 13.37,38.59 13.85,38.59 14.03,38.41 14.35,38.41 14.69,38.75 14.69,39.17 16.06,40.54 17.19,40.54 19.49,42.84 19.49,44.04 20.08,44.63 20.08,46.77 21.26,47.95 22.96,47.95 23.74,47.17 23.74,46.06 23.89,45.91 28.09,45.91 29.08,46.91 v2(30.35,46.91)
  BOTTOM w0.081: v2(11.85,39.33) 11.68,39.17 11.05,39.17 10.81,38.92 UT4.D2
  BOTTOM w0.089: 30.67,47.13 30.46,46.91 v2(30.35,46.91) 30.29,46.85 29.88,46.85 29.57,46.53 29.57,45.5 UT1.U2
  BOTTOM w0.127: 30.67,47.13 30.74,47.19 RT36.2
TBT_I2C_DATA: length 30.2
  TOP w0.089: v2(29.2,46.27) 28.78,45.86 v3(28.5,45.86)
  IN2 w0.099: v2(29.2,46.27) 28.65,45.73 23.81,45.73 23.54,46 23.54,47.09 22.88,47.75 21.35,47.75 20.28,46.68 20.28,44.55 19.69,43.96 19.69,42.75 17.28,40.34 16.14,40.34 14.89,39.08 14.89,38.67 13.97,37.75 13.42,37.75 12.85,38.31 12.85,38.9 v2(12.43,39.32)
  BOTTOM w0.081: UT4.D1 11.37,38.98 12,38.98 12.33,39.32 v2(12.43,39.32)
  BOTTOM w0.089: v2(29.2,46.27) 29.33,46.14 UT1.U1
  BOTTOM w0.127: v2(29.2,46.27) 29.2,46.49 29.76,47.05 29.9,47.05 30.1,47.25 RT35.2
TBT_JTAG_TCK: length 25.9
  TOP w0.089: 33.66,46.1 33.52,46.24 32.98,46.24 32.8,46.42 32.48,46.42 31.85,45.79 29.87,45.79 v3(29.78,45.7) 29.07,44.99 29.07,44.66 v2(28.66,44.24)
  TOP w0.127: RT7.2 33.81,45.94 33.66,46.1
  TOP w0.14: T198.1 40.07,40.01 v2(40.22,39.86)
  IN4 w0.091: v2(40.22,39.86) 40.22,39.2 39.03,38.01 37.52,38.01 35.31,40.22 34.34,40.22 32.46,42.1 32.46,44 30.89,45.58 29.81,45.58 29.01,44.78 29.01,44.59 v2(28.66,44.24)
  BOTTOM w0.102: v2(28.66,44.24) UT1.T4
