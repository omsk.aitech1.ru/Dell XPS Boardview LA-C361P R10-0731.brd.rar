# Allegro board LA-C361P R10-0731.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+VBUS_DC_SS on BOTTOM (solid shape): 25.59,63.96 25.59,63.44 26.54,62.49 27.33,61.7 27.33,58.66 27.08,58.4 25.68,58.4 25.63,58.45 25.07,58.45 24.61,58.91 24.61,61.02 24.57,61.07 22.65,61.07 22.39,61.34 22.39,63.95 22.51,64.08 25.46,64.08
+VCC0V9_CIO on BOTTOM (solid shape): 28.31,42.7 28.36,42.72 28.41,42.72 28.54,42.63 28.7,42.62 28.72,42.62 28.75,42.59 28.77,42.52 28.8,42.48 28.83,42.44 28.89,42.41 28.89,42.19 28.82,42.13 28.7,42 28.7,41.5 28.54,41.35 28.54,40.7 28.4,40.55 28.05,40.55 27.91,40.69 27.91,40.71 27.87,40.8 27.81,40.86 27.81,41.13 27.91,41.32 27.81,41.51 27.81,41.62 28.25,42.07 28.26,42.08 28.34,42.29 28.26,42.5 28.25,42.52 28.25,42.64
+VCC0V9_CIO on IN6: 33.46,40.3 31.4,40.3 31.07,40.64 31.07,41.66 30.75,41.98 29.77,41.98 28.53,40.74 27.89,40.74 27.76,40.86 27.76,41.82 27.89,41.95 28.15,41.95 28.37,42.17 28.37,42.42 28.49,42.54 28.7,42.54 28.82,42.65 28.89,42.71 28.95,42.79 29.39,43.23 33.51,43.23 33.89,42.85 33.89,40.73
+VCC0V9_DP on TOP (solid shape): outline of 416 points within 26.32,37.85 32.64,46.26
+VCC0V9_DP on BOTTOM (solid shape): 26.57,43.26 26.84,43.26 26.99,43.4 27.06,43.4 27.24,43.23 27.41,43.23 27.52,43.11 27.58,43.05 27.58,42.86 27.22,42.51 26.28,42.51 26.24,42.55 26.24,43.32 26.34,43.41 26.42,43.41
+VCC0V9_DP on BOTTOM (solid shape): 29.66,41.49 29.68,41.46 29.71,41.43 29.74,41.4 29.78,41.37 29.78,41.27 29.63,40.99 29.78,40.72 29.78,40.63 29.63,40.46 29.63,40.23 29.64,40.2 29.7,40.12 29.78,40.06 29.74,39.94 29.68,39.88 29.55,39.88 29.36,40.08 29.23,40.08 29.19,40.11 29.19,40.12 29.14,40.18 29.08,40.22 29.08,40.23 28.76,40.55 28.76,41.37 28.89,41.49
+VCC0V9_PCIE on TOP (solid shape): outline of 145 points within 25.79,35.65 29.19,39.96
+VCC0V9_PCIE on BOTTOM (solid shape): 27.17,40.1 27.2,40.04 27.19,39.98 27.03,39.68 27.21,39.4 27.24,39.39 27.24,39.07 27.24,39.07 27.16,38.99 27.16,38.67 27.03,38.53 27.03,38.26 27.23,38.06 27.49,38.06 27.63,38.2 27.72,38.2 27.76,38.16 27.81,38.12 27.81,37.36 27.77,37.33 27.73,37.28 27.59,37.28 27.35,37.51 27.27,37.51 27.13,37.66 26.94,37.66 26.78,37.5 26.65,37.5 26.45,37.3 26.32,37.3 26.28,37.34 26.28,37.5 26.39,37.74 26.28,37.99 26.28,38.15 26.36,38.26 26.39,38.4 26.39,38.42 26.48,38.51 26.54,38.55 26.58,38.6 26.6,38.78 26.48,38.92 26.44,39 26.47,39.08 26.54,39.14 26.54,39.2 26.61,39.37 26.54,39.54 26.54,39.85 26.6,39.94 26.61,40.06 26.64,40.13 26.71,40.16 27.11,40.16
+VCC_CORE on BOTTOM (solid shape): outline of 127 points within 160.71,67.34 171.85,69.3
+VCC_CORE on BOTTOM (solid shape): outline of 1542 points within 149.51,79.59 170.44,116.01
+VCC_CORE on IN6 (solid shape): outline of 379 points within 149.56,95.28 167.31,116.01
+VCC_CORE on TOP: outline of 201 points within 145.66,68.1 171.84,110.82
+VCC_CORE on IN1: 167.5,67.26 167.49,67.27 160.71,67.27 160.39,67.52 160.06,67.27 159.75,67.27 159.53,67.56 159.18,67.48 159.11,67.44 159.04,67.47 157.7,68.81 157.7,78.39 159.7,80.4 159.7,88.11 160.06,88.46 170.27,88.46 170.45,88.29 170.45,84.05 170.2,83.81 170.2,78.41 170.39,78.22 170.39,73.43 171.99,71.83 172,71.82 172.07,71.69 172.2,71.62 172.21,71.61 172.28,71.54 172.23,71.48 172.22,71.47 171.98,71.2 172.14,70.87 172.34,70.82 172.52,70.9 172.63,70.92 172.69,70.82 172.69,69.06 172.63,68.97 172.52,68.99 171.95,68.75 172.52,68.52 172.63,68.54 172.69,68.45 172.69,67.42 172.53,67.26
+VCC_CORE on IN2: outline of 314 points within 148.16,67.2 173.59,111.58
+VCC_CORE on IN4: outline of 256 points within 145.66,67.41 172.77,110.75
+VCC_CORE on VCC: 154.67,56.52 154.18,57.01 154.18,67.17 152.4,68.95 152.4,78.39 153.54,79.53 153.54,85.22 151.26,87.5 149.92,87.5 148.75,88.67 146.14,88.67 144.3,90.51 144.3,92.67 138.3,98.67 138.3,105.76 138.6,106.05 144,106.05 145.16,107.22 145.16,110.39 145.78,111.01 151.79,111.01 157.25,105.55 166.39,105.55 166.69,105.25 166.69,96.04 168.55,94.18 172.04,94.18 172.98,93.25 172.98,86.52 175.01,84.49 175.01,58.92 172.62,56.52
+VCCGT on BOTTOM (solid shape): outline of 164 points within 143.8,67.49 156.81,69.23
+VCCGT on IN3 (solid shape): 121.82,83.93 121.82,82.18 122.35,81.64 122.95,81.64 123.31,81.29 123.31,79.92 121.73,78.34 121.73,70.81 121.25,70.33 121.25,70.13 119.91,68.79 116.89,68.79 116.36,69.33 116.36,69.53 116.89,70.06 116.89,70.72 115.9,71.71 115.9,81.47 116.26,81.82 117.76,81.82 118.03,82.1 118.03,82.76 117.12,83.68 117.12,84.16 117.48,84.51 121.24,84.51
+VCCGT on IN4 (solid shape): outline of 99 points within 115.9,68.79 123.81,84.51
+VCCGT on IN6 (solid shape): outline of 107 points within 115.9,68.79 124.13,84.51
+VCCGT on TOP: outline of 125 points within 116.47,67.59 158,89 ; 2 cut-outs
+VCCGT on BOTTOM: outline of 176 points within 115.6,68.78 158,93.35
+VCCGT on IN1: 145.28,67.64 144.74,68.17 143.74,69.17 143.11,69.8 143.11,74.85 142.67,75.29 142.19,75.29 141.09,76.39 138.86,76.39 138.25,77 138.25,85.79 139.13,86.67 139.13,88 139.39,88.26 150.12,88.26 150.42,88.07 150.71,88.26 156.09,88.26 157.99,86.36 157.99,80.2 157.28,79.49 157.28,73.3 157.27,73.29 157.27,68.59 157.26,68.54 157.26,68.48 156.41,67.64 153.43,67.64 153.35,67.68 153.33,67.77 153.02,68.2 152.71,67.77 152.69,67.68 152.61,67.64 152.51,67.64 152.43,67.68 152.42,67.77 152.1,68.2 151.79,67.77 151.77,67.68 151.69,67.64 150.69,67.64 150.6,67.68 150.59,67.77 150.27,68.2 149.96,67.77 149.95,67.68 149.86,67.64
+VCCGT on IN2: outline of 164 points within 116.51,66.72 159.43,89.04
+VCCGT on IN4: 153.81,67.64 153.19,68.25 149.75,68.25 149.05,68.25 148.48,67.69 145.55,67.69 144.98,68.25 144.27,68.25 144.25,68.27 143.89,68.27 143.88,68.28 143.45,68.28 143.21,68.51 143.19,68.6 143.24,68.68 143.41,69.02 143.14,69.3 143.1,69.3 143.1,79.21 143.28,79.51 143.1,79.8 143.1,79.89 142.49,80.49 142.49,81.04 142.54,81.13 142.64,81.13 142.98,81.15 143.13,81.46 142.93,81.79 142.56,81.71 142.51,81.75 142.49,81.81 142.49,84 142.34,84.16 142.33,84.17 142.21,84.35 142,84.41 141.91,84.4 141.82,84.35 141.42,84.35 141.23,84.42 141.03,84.35 140.78,84.35 140.69,84.4 140.69,84.5 140.4,84.98 140.11,84.5 140.1,84.4 140.02,84.35 138.79,84.35 138.66,84.49 138.66,88.25 139.11,88.71 150.03,88.71 150.12,88.66 150.12,88.56 150.42,88.07 150.71,88.56 150.71,88.66 150.8,88.71 154.65,88.71 158,85.35 158,78.96 157.73,78.69 157.73,70.15 157.7,70.07 157.69,70.01 157.7,69.92 157.73,69.83 157.73,69.82 157.73,68.42 157.33,68.01 156.23,68.01 155.86,67.64
+VCCGT on VCC: 143.79,90.3 145.93,88.16 148.54,88.16 149.71,86.99 151.05,86.99 153.04,85.01 153.04,79.74 151.89,78.6 151.89,68.74 153.67,66.96 153.67,57.01 153.18,56.52 131.68,56.52 124.44,63.76 120.25,63.76 115.95,68.06 115.95,85.63 119.76,89.44 119.76,97.63 121.45,99.32 137.18,99.32 137.8,98.71 137.8,98.46 143.79,92.46 ; 1 cut-out
+VCCGT on IN5: outline of 82 points within 116.56,69.83 158.73,88.02
+VCCIO on TOP (solid shape): outline of 922 points within 172.5,69.88 177.94,76.48
+VCCIO on BOTTOM (solid shape): outline of 781 points within 171.5,69.34 174.35,79.22
+VCCIO on IN3 (solid shape): outline of 423 points within 171.44,69.63 174.3,79.06
+VCCIO on IN4 (solid shape): outline of 230 points within 171.8,70.38 174.12,78.89
+VCCIO on BOTTOM: 117.45,65.99 117.45,68.16 117.7,68.41 119.38,68.41 119.77,68.03 119.77,66.84 120.05,66.55 121.39,66.55 121.62,66.33 121.62,62.78 121.15,62.32 117.6,62.32 117.6,62.85 118.14,62.85 118.14,63.6 118.1,63.64 117.65,63.64 117.58,63.7 117.58,64.04 118.14,64.04 118.14,64.83 117.58,64.83 117.58,65.87
+VCCIO on IN5: outline of 408 points within 116.9,63.32 174.55,73.68
+VCCSA on TOP (solid shape): 120.5,90.39 120.5,89.34 120.53,89.31 120.53,87.34 120.32,87.13 113.95,87.13 113.47,87.61 113.47,90.08 113.88,90.5 120.4,90.5
+VCCSA on TOP (solid shape): outline of 387 points within 169.9,81.89 179.44,86.62
+VCCSA on BOTTOM (solid shape): 120.56,90.48 120.56,87.49 120.21,87.14 119.07,87.14 119.06,87.13 117.6,87.13 117.22,87.51 115.19,87.51 114.97,87.29 114.97,86.85 114.94,86.81 114.94,86.32 114.64,86.02 112.87,86.02 112.38,86.51 112.38,90.55 112.59,90.75 114.87,90.75 115.63,91.51 119.53,91.51
+VCCSA on BOTTOM (solid shape): outline of 473 points within 165.86,79.57 177.64,93.87
+VCCSA on IN5: outline of 350 points within 115.29,73.86 179.31,101.35
+VCCST on TOP (solid shape): 181,80.26 181,79.27 181.13,79.13 181.13,78.52 181,78.38 180.33,78.38 180.16,78.55 180.16,80.27 180.23,80.34 180.91,80.34
+VCCST on TOP (solid shape): 173.78,81.31 174.29,81.31 174.44,81.47 174.54,81.46 174.6,81.47 175.04,81.47 175.11,81.45 175.17,81.44 175.19,81.44 175.25,81.38 175.25,80.75 175.02,80.52 174.59,80.52 174.58,80.52 174.48,80.54 174.38,80.52 174.37,80.52 173.96,80.52 173.94,80.52 173.66,80.43 173.56,80.15 173.56,80.13 173.38,79.94 173.38,78.29 173.28,78.19 172.78,78.19 172.72,78.25 172.72,78.83 172.53,79.03 172.37,79.03 172.14,79.25 172.14,80.03 172.34,80.22 172.73,80.22 172.9,80.39 172.9,80.9 172.72,81.07 172.72,81.75 172.8,81.82 173.27,81.82
+VCCST on IN2 (solid shape): outline of 1334 points within 173.71,63.15 182.48,81.5
+VCCSTG on BOTTOM (solid shape): 182.77,83.08 182.77,82.07 183.21,81.63 183.21,81.31 182.98,81.08 181.43,81.08 180.85,81.66 180.85,82.4 181.01,82.56 181.51,82.56 182.11,83.15 182.7,83.15
+VCCSTG on IN3 (solid shape): 178.71,83.61 178.89,83.61 179,83.64 179.1,83.7 180,83.7 181.28,82.42 183,82.42 183.25,82.17 183.25,81.37 183.03,81.15 180.78,81.15 179.2,82.73 178.78,82.73 178.74,82.74 178.69,82.73 177.45,82.73 177.37,82.81 177.32,82.81 177.31,82.83 177.07,82.92 176.84,82.83 176.82,82.81 176.7,82.81 176.45,82.92 176.19,82.81 175.75,82.81 174.97,82.03 174.94,82.01 174.86,81.93 174.82,81.97 174.41,82.1 174.22,81.71 174.2,81.63 174.12,81.59 173.27,81.59 173.16,81.7 173.16,82.35 173.26,82.45 173.46,82.45 173.51,82.45 173.68,82.45 173.84,82.6 173.84,82.6 174.02,82.78 174.03,82.78 174.07,82.83 174.24,82.83 174.4,82.98 174.53,82.98 174.79,83.24 174.79,83.37 175.09,83.67 175.26,83.67 175.53,83.94 178.32,83.94
DV12S on BOTTOM (solid shape): 331.11,34.03 331.11,33.54 330.48,32.91 330.48,32.57 330.36,32.46 330.36,31.86 330.04,31.54 329.57,31.54 329.27,31.24 327.04,31.24 326.68,31.59 326.68,32.51 326.84,32.67 327.43,32.67 328.13,31.96 329.02,31.96 329.41,32.36 329.41,32.95 329.63,33.17 329.63,33.4 330.41,34.18 330.95,34.18
GND on TOP (solid shape): 23.01,110.47 23.01,109 22.75,108.73 18.48,108.73 18.34,108.87 18.34,110.46 18.57,110.69 22.8,110.69
GND on TOP (solid shape): 26.27,45.39 26.27,44.74 26.15,44.62 25.22,44.62 24.93,44.91 24.93,45.6 24.98,45.64 26.02,45.64
GND on TOP (solid shape): 141.85,53.73 141.85,49.3 141.47,48.92 138.14,48.92 137.49,49.56 137.49,54.21 137.91,54.63 140.94,54.63
GND on TOP (solid shape): 155.56,52.6 155.56,49.78 154.81,49.03 152.4,49.03 152.25,49.18 152.25,52.62 152.46,52.84 155.32,52.84
GND on TOP (solid shape): 168.91,76.97 168.91,74.18 168.78,74.05 165.74,74.05 165.48,74.3 165.48,76.72 165.86,77.1 168.78,77.1
GND on TOP (solid shape): 209.09,109.39 209.09,106.98 208.9,106.79 207.99,106.79 207.9,106.88 207.9,109.37 208.04,109.51 208.97,109.51
GND on TOP (solid shape): 79.88,32.01 79.88,30.37 79.69,30.18 75.64,30.18 75.2,30.63 75.2,31.92 75.85,32.57 79.33,32.57
GND on TOP (solid shape): 277.3,29.64 277.3,27.47 276.98,27.15 274.12,27.15 273.88,27.4 273.88,29.66 274.13,29.92 277.02,29.92
GND on TOP (solid shape): 5.02,15.17 5.02,13.39 4.75,13.12 3.66,13.12 3.47,13.31 3.47,14.93 3.84,15.29 4.9,15.29
GND on TOP (solid shape): 5.77,20.52 5.77,19.03 4.97,18.23 4.09,18.23 3.84,18.49 3.84,20.52 3.96,20.65 5.64,20.65
GND on TOP (solid shape): 110.49,59.7 110.49,56.52 110.36,56.4 108.01,56.4 107.7,56.71 107.7,58.11 108.08,58.49 108.08,59.51 108.52,59.95 110.24,59.95
GND on TOP (solid shape): 133.96,10.02 133.96,7.63 133.77,7.44 128.91,7.44 128.4,7.95 128.4,9.91 128.65,10.17 133.8,10.17
GND on TOP (solid shape): 161.95,100.49 161.95,96.26 161.63,95.94 159.56,95.94 159.43,96.07 159.43,100.71 159.51,100.78 161.66,100.78
GND on TOP (solid shape): 172.73,50.44 172.73,44.45 172.31,44.03 169.52,44.03 169.29,44.26 169.29,50.81 169.67,51.19 171.98,51.19
GND on TOP (solid shape): 199.14,118.12 199.14,114.94 198.63,114.44 195.71,114.44 195.45,114.69 195.45,118.93 195.59,119.07 198.18,119.07
GND on TOP (solid shape): 243.33,46.68 245.45,46.68 245.64,46.49 245.64,44.74 245.24,44.33 240.86,44.33 240.54,44.65 240.54,46.81 240.73,47 243.02,47
GND on TOP (solid shape): 100.81,5.5 100.81,5.17 100.45,4.81 100.45,3.43 100.36,3.34 100.03,3.34 99.77,3.59 99.77,5.42 99.92,5.57 100.74,5.57
GND on TOP (solid shape): 124.7,69.16 124.7,68.4 124.59,68.28 123.32,68.28 121.79,66.76 120.04,66.76 119.91,66.89 119.91,68.29 120.91,69.29 124.58,69.29
GND on TOP (solid shape): 285.18,32.71 285.18,32.08 284.93,31.82 281.94,31.82 281.69,31.57 281.24,31.57 280.99,31.82 280.99,32.71 281.18,32.9 284.99,32.9
GND on TOP (solid shape): 329.5,22.11 329.5,19.76 329.06,19.31 321.69,19.31 321.57,19.44 321.57,20.2 322.04,20.68 324.45,20.68 326.2,22.42 329.19,22.42
GND on TOP (solid shape): 28.06,46.2 28.06,45.82 28.88,45.01 28.88,44.77 28.73,44.62 27.9,44.62 27.77,44.75 27.77,45.02 27.56,45.23 27.56,46.19 27.6,46.23 28.03,46.23
GND on TOP (solid shape): 242.4,9.58 242.4,8.27 242.36,8.23 240.2,8.23 240.14,8.28 240.14,8.94 240.19,8.99 240.56,8.99 240.78,9.22 240.78,9.6 240.89,9.7 242.28,9.7
GND on TOP (solid shape): 6.58,15.17 6.58,14.19 7.03,13.75 7.03,13.22 6.69,12.89 5.81,12.89 5.41,13.28 5.41,15.18 5.51,15.27 6.48,15.27
GND on TOP (solid shape): 31.45,44.36 31.45,43.87 31.52,43.8 31.85,43.8 31.93,43.72 31.93,42.78 31.78,42.63 31.27,42.63 30.99,42.91 30.99,44.36 31.04,44.41 31.4,44.41
GND on TOP (solid shape): 119.44,86.89 119.44,86.38 119.27,86.21 119.1,86.21 118.62,85.73 118.62,85.16 118.43,84.97 115.38,84.97 115.19,85.16 115.19,86.81 115.32,86.94 119.39,86.94
GND on TOP (solid shape): 220.85,71.51 220.85,70.94 221.68,70.11 221.68,69.6 221.43,69.35 220.16,69.35 219.52,69.99 219.52,70.24 219.65,70.37 219.97,70.37 220.09,70.49 220.09,71.45 220.22,71.57 220.79,71.57
GND on TOP (solid shape): 326.26,10.8 326.26,9.09 327.34,8.01 327.72,8.01 327.85,7.88 327.85,6.49 327.66,6.3 325.18,6.3 323.91,7.57 322.07,7.57 321.82,7.82 321.82,11.25 322.01,11.44 325.63,11.44
GND on TOP (solid shape): 118.87,59.64 118.87,56.52 118.56,56.21 114.45,56.21 114.27,56.39 114.27,59.64 114.64,60.02 118.49,60.02
GND on TOP (solid shape): 225.61,94.5 227.06,94.5 227.25,94.31 227.25,92.83 225.98,91.56 225.23,91.56 225.16,91.63 225.16,93.3 224.47,93.99 224.47,94.75 224.6,94.88 225.24,94.88
GND on TOP (solid shape): 231.19,53.79 231.19,53.43 231.24,53.37 231.74,53.37 231.83,53.28 231.83,52.78 231.7,52.65 230.52,52.65 230.37,52.8 230.37,53.79 230.47,53.89 231.09,53.89
GND on TOP (solid shape): 112.21,96.47 112.21,92.53 111.44,91.77 104.52,91.77 104.46,91.83 104.46,94.24 104.59,94.37 105.09,94.37 105.28,94.18 105.28,93.16 105.54,92.91 107.89,92.91 108.27,93.29 108.27,96.78 108.59,97.1 111.57,97.1
GND on TOP (solid shape): 252.99,29.49 252.99,26.23 252.41,25.66 251.11,25.66 250.92,25.85 250.92,27.01 251.2,27.29 251.2,27.79 251.45,28.04 251.45,28.74 251.93,29.22 251.93,29.74 252.06,29.87 252.6,29.87
GND on TOP (solid shape): 57.79,4.33 57.79,3.63 57.66,3.5 56.52,3.5 56.26,3.25 56.26,2.24 56.45,2.05 56.45,1.41 56.4,1.35 55.84,1.35 55.72,1.48 55.72,1.93 55.44,2.21 55.44,4.37 55.52,4.45 57.66,4.45
GND on TOP (solid shape): 84.94,35.31 85.14,35.31 86.06,34.4 86.06,33.38 85.78,33.11 82.58,33.11 82.22,33.46 82.22,34.07 82.53,34.38 82.88,34.38 83.11,34.6 83.11,35.19 83.24,35.31 83.44,35.31 83.85,35.72 84.53,35.72
GND on TOP (solid shape): 336.11,18.36 336.11,17.73 336.23,17.6 337.57,17.6 337.82,17.85 337.82,18.36 337.95,18.49 338.71,18.49 338.89,18.31 340.82,18.31 341.06,18.08 341.06,16.01 340.23,15.19 334.27,15.19 333.95,15.5 333.95,18.42 334.01,18.49 335.98,18.49
GND on TOP (solid shape): 294.51,6.88 294.51,6.24 294.43,6.16 294.43,5.44 294.62,5.25 294.62,4.77 294.5,4.66 293.87,4.66 293.82,4.71 293.82,5.39 293.8,5.41 293.8,5.42 293.79,5.42 293.74,5.47 293.22,5.47 293.04,5.65 293.04,6.84 293.18,6.98 294.42,6.98
GND on TOP (solid shape): 212.47,54.62 212.47,53.86 212.79,53.54 216.73,53.54 217.04,53.22 217.06,53.22 217.06,51.94 218.67,51.94 218.67,53.22 218.89,53.22 218.93,53.19 218.93,51.31 218.91,51.29 216.45,51.29 216.17,51.57 209.97,51.57 207.94,53.6 207.94,54.7 208.05,54.81 212.28,54.81
GND on TOP (solid shape): 28.81,61.21 28.81,60.4 29.43,58.08 29.43,57.67 29.53,57.57 29.53,57.16 29.88,56.8 29.88,56.21 29.83,56.16 29.3,56.16 29.27,56.18 29.27,56.19 29.06,56.4 27.62,58.56 27.62,59.51 27.23,59.91 27.23,60.32 27.21,60.33 27.21,61.29 27.35,61.43 28.59,61.43
GND on TOP (solid shape): 122.81,4.52 122.81,3.06 122.62,2.87 120.65,2.87 120.49,3.03 120.49,3.28 120.33,3.44 119.19,3.44 118.99,3.64 118.99,3.95 118.89,4.05 118.39,4.05 118.25,4.19 118.25,5.12 118.31,5.18 122.14,5.18
GND on TOP (solid shape): 208.25,70.11 208.89,70.11 209.14,69.86 209.14,66.56 208.44,65.86 208.44,64.78 208.03,64.36 208.03,63.45 207.9,63.32 207.17,63.32 206.86,63.64 206.86,64.4 207.3,64.84 207.3,64.84 207.56,65.1 207.56,66.18 207.72,66.34 207.72,68.57 207.24,69.06 207.24,70.49 207.3,70.56 207.81,70.56
GND on TOP (solid shape): 180.22,82.18 180.22,81.81 180.87,81.15 180.87,80.65 180.79,80.56 180.02,80.56 179.74,80.84 179.29,80.84 179.1,80.65 179.1,80.16 179.16,80.1 179.16,79.72 179.07,79.63 178.59,79.63 178.43,79.78 178.43,80.78 178.84,81.19 179.23,81.58 179.23,81.68 179.82,82.27 180.13,82.27
GND on TOP (solid shape): 245.16,51.98 245.16,49.89 245.14,49.87 243.83,49.87 243.7,49.74 243.7,48.75 243.64,48.69 243.52,48.69 243.47,48.74 243.47,49.75 243.36,49.87 241.73,49.87 240.65,48.79 235.21,48.79 234.96,49.03 234.96,49.78 235.15,49.97 235.15,51.34 235.18,51.37 235.95,51.37 236.39,50.94 240.27,50.94 240.75,51.41 240.75,51.7 241.06,52.02 245.12,52.02
GND on TOP (solid shape): 112.1,85.97 112.1,84.23 110.06,82.19 110.06,76.89 110.55,76.4 112.33,76.4 112.52,76.21 112.52,74.62 112.33,74.43 109.25,74.43 108.98,74.16 108.95,74.16 108.33,73.54 107.06,73.54 106.86,73.75 106.86,74.91 107.34,75.4 107.34,75.54 107.34,75.54 107.34,76.77 108.16,77.59 108.16,78.31 107.92,78.56 107.63,78.56 107.53,78.66 107.53,82.83 108.01,83.31 108.01,85.86 108.4,86.24 111.82,86.24
GND on TOP (solid shape): 147.29,120.31 150.77,120.31 151.29,119.79 151.29,117.99 149.89,116.59 147.82,116.59 145.1,113.86 145.1,107.68 144.6,107.18 144.6,106.51 144.02,105.93 143.51,105.93 143.38,106.05 143.38,106.94 143.15,107.18 141.17,107.18 140.99,107.37 140.99,108.24 141,108.25 141,110.46 140.4,111.06 140.4,113.92 141.05,114.57 141.05,116.85 140.82,117.08 140.5,117.08 140.47,117.12 140.47,120.1 140.69,120.32 147.28,120.32
GND on TOP (solid shape): 163.38,116.34 163.38,113.64 163.23,113.49 162.32,113.49 162.16,113.34 162,113.17 161.83,113.17 161.57,112.91 161.57,112.43 161.29,112.15 160.66,112.15 160.4,111.9 160.4,111.01 160.27,110.88 159.58,110.88 159.45,111.01 159.45,111.9 158.72,112.63 154.59,112.63 153.99,113.23 153.99,115.83 154.5,116.34 155.83,116.34 155.96,116.21 155.96,115.45 156.08,115.33 159.17,115.33 159.34,115.51 159.34,116.04 159.64,116.34 160.91,116.34 161.29,116.72 163,116.72
GND on TOP (solid shape): 32.51,21.46 32.51,17.98 32.45,17.92 30.93,17.92 30.56,17.55 30.56,17.53 30.51,17.48 30.51,16.49 30.74,16.26 30.74,16.07 30.61,15.95 28.89,15.95 28.45,15.5 27.75,15.5 27.69,15.57 27.69,16.14 28.09,16.54 28.09,18.83 28.58,19.31 29.15,19.31 29.31,19.15 29.31,18.16 29.45,18.02 30.37,18.02 30.99,18.64 30.99,19.06 31.15,19.22 31.15,21.08 30.94,21.29 30.94,21.87 31.1,22.03 31.94,22.03
GND on TOP (solid shape): 246.54,62.91 246.65,62.75 246.82,62.66 246.93,62.62 247.05,62.6 247.23,62.6 247.35,62.62 247.46,62.66 247.54,62.69 247.61,62.73 247.96,62.73 248.13,62.56 248.86,62.56 249.02,61.08 249.26,59.58 249.26,59.1 248.88,58.72 248.88,57.63 248.54,57.29 247.4,57.29 247.11,57.57 247.11,58.91 246.15,59.86 246.15,62.85 246.27,62.96 246.52,62.96
GND on TOP (solid shape): 332.28,69.3 332.28,69.17 331.32,68.21 331.32,66.2 331.24,66.13 329.82,66.13 328.96,66.99 328.96,67.03 329.04,67.17 329.19,67.16 329.74,67.46 329.19,67.76 329.04,67.75 328.96,67.88 328.96,68.31 330.33,69.68 331.9,69.68
GND on TOP (solid shape): 180.11,119.3 180.11,116.85 179.86,116.6 179.34,116.6 179.2,116.46 179.2,115.4 179.46,115.13 180.01,115.13 180.07,115.08 180.07,114.28 180.57,113.78 182.68,113.78 183.01,113.45 183.01,111.9 182.75,111.64 180.29,111.64 179.81,111.16 179.81,109.45 179.59,109.23 178.76,109.23 178.63,109.09 178.63,107.97 178.76,107.83 179.5,107.83 179.74,107.59 179.74,106.8 180.04,106.51 181.43,106.51 182.5,105.44 182.5,104.43 182.22,104.15 182.2,104.12 180.24,104.12 179.66,103.54 179.66,101.94 179.39,101.67 178.7,101.67 178.5,101.47 178.5,100.48 178.7,100.27 178.82,100.27 178.88,100.21 179.58,100.21 180.52,99.27 180.52,98.79 180.53,98.78 180.53,95.7 180.52,95.69 180.52,94.42 179.59,93.5 176.77,93.5 176.47,93.8 176.47,103.45 176.78,103.77 176.78,106.12 176.47,106.43 176.47,113.17 176.78,113.48 176.78,119.58 177.04,119.83 179.58,119.83
GND on TOP (solid shape): outline of 104 points within 174.9,22.84 177.83,29.31
GND on TOP (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on TOP (solid shape): outline of 1343 points within 0.25,0 352.45,109.22
GND on TOP (solid shape): outline of 2315 points within 1.15,33.64 351.55,122.8
GND on BOTTOM (solid shape): 119.3,54.15 116.76,54.15 116.76,54.95 119.3,54.95
GND on BOTTOM (solid shape): 102.85,64.42 102.25,64.42 102.25,81.92 102.85,81.92
GND on BOTTOM (solid shape): 45.59,20.96 45.59,19.76 45.47,19.63 42.42,19.63 42.23,19.82 42.23,21.03 42.48,21.28 45.28,21.28
GND on BOTTOM (solid shape): 102.85,54.95 109.24,54.95 109.24,54.15 102.25,54.15 102.25,56.9 102.85,56.9
GND on BOTTOM (solid shape): 109.03,36.86 109.03,32.14 108.79,31.9 105.25,31.9 105.14,32 105.14,36.56 105.97,37.39 108.5,37.39
GND on BOTTOM (solid shape): 153.49,99.23 153.49,96.62 153.26,96.39 150.35,96.39 150.03,96.71 150.03,99.19 150.35,99.51 153.2,99.51
GND on BOTTOM (solid shape): 199.96,118.82 199.96,115.49 197.83,113.36 196.09,113.36 195.83,113.61 195.83,119.13 196.03,119.33 199.45,119.33
GND on BOTTOM (solid shape): 168.99,108.9 168.99,106.4 168.98,106.39 166.47,106.39 166.44,106.41 166.44,108.89 166.47,108.91 168.98,108.91
GND on BOTTOM (solid shape): 5.73,32.5 5.73,29.59 5.61,29.47 4.36,29.47 4.29,29.54 4.29,30.46 4.72,30.89 4.72,32.52 4.78,32.57 5.66,32.57
GND on BOTTOM (solid shape): 116.65,93.73 117.35,93.73 117.41,93.67 117.41,93.29 117.22,93.1 115.89,93.1 115.38,93.61 115.38,93.73 115.46,93.82 116.57,93.82
GND on BOTTOM (solid shape): 28.73,81.99 28.73,76.52 28.01,76.52 27.86,76.67 27.86,79.33 27.67,79.52 26.61,79.52 26.38,79.75 26.38,81.73 26.73,82.08 28.63,82.08
GND on BOTTOM (solid shape): 136.3,118.96 136.3,116.31 135.76,115.77 133,115.77 132.81,115.96 132.81,118.94 132.94,119.07 136.19,119.07
GND on BOTTOM (solid shape): 324.97,91.32 324.97,84.54 324.92,84.49 324.88,84.49 324.62,84.23 323.39,84.23 323.25,84.36 323.25,91.32 323.38,91.45 324.84,91.45
GND on BOTTOM (solid shape): 21.72,25.31 21.72,22.87 21.66,22.81 21.07,22.81 21.03,22.84 21.03,23.07 20.45,23.66 20.45,24.84 20.93,25.32 20.93,25.32 20.99,25.37 21.66,25.37
GND on BOTTOM (solid shape): 117.41,86.94 118.37,86.94 118.68,86.62 118.68,85.29 118.43,85.04 115.51,85.04 115.32,85.23 115.32,87 115.57,87.26 117.1,87.26
GND on BOTTOM (solid shape): 329.38,33.97 329.38,33.36 329.15,33.13 329.15,32.33 328.91,32.09 328.26,32.09 327.53,32.81 326.94,32.81 326.39,33.36 326.39,34.04 326.52,34.17 329.17,34.17
GND on BOTTOM (solid shape): 105.28,93.99 105.28,93.23 105.45,93.07 106.06,93.07 106.18,92.95 106.18,92.18 106.01,92.02 104.33,92.02 104.14,92.21 104.14,93.86 104.4,94.12 105.16,94.12
GND on BOTTOM (solid shape): 131.56,118.98 131.56,116.07 131.26,115.77 128.59,115.77 128.59,115.77 128.54,115.77 128.34,115.97 128.34,118.89 128.53,119.07 131.47,119.07
GND on BOTTOM (solid shape): 170.69,99.64 171.7,98.62 171.7,96.34 171.51,96.15 168.09,96.15 167.89,96.34 167.89,99.45 168.09,99.64 170.63,99.64
GND on BOTTOM (solid shape): 211.5,54.73 211.5,53.52 210.63,52.65 208.63,52.65 208.18,53.1 208.18,54.7 208.36,54.87 211.36,54.87
GND on BOTTOM (solid shape): 55.4,20.66 55.49,20.66 55.64,20.51 55.64,19.5 55.55,19.41 54.2,19.41 53.56,18.77 53.37,18.77 52.77,19.36 52.77,19.6 53.83,20.67 55.39,20.67
GND on BOTTOM (solid shape): 122.75,4.58 122.75,2.93 122.62,2.8 118.19,2.8 118,2.99 118,5 118.22,5.22 122.11,5.22
GND on BOTTOM (solid shape): 202.02,80.6 202.02,79.52 201.96,79.46 201.57,79.46 201.38,79.64 201.38,80.54 200.81,81.11 200.05,81.11 199.99,81.17 199.99,81.4 200.08,81.49 200.3,81.49 200.31,81.49 201.13,81.49
GND on BOTTOM (solid shape): 287.97,28.6 287.97,27.12 287.34,26.49 287.02,26.49 286.96,26.55 286.96,26.81 287.75,27.6 287.75,28.59 287.82,28.66 287.91,28.66
GND on BOTTOM (solid shape): 100.82,5.5 100.82,5.24 100.55,4.97 99.77,4.97 99.59,4.8 99.28,4.8 98.92,4.44 98.75,4.44 98.68,4.52 98.68,5.19 99.11,5.63 99.11,6.01 99.22,6.12 100.21,6.12
GND on BOTTOM (solid shape): 118.89,59.75 118.89,56.66 118.11,55.89 114.3,55.89 114.17,56.02 114.17,56.52 114.36,56.71 114.8,56.71 114.91,56.83 114.91,56.96 114.9,56.97 114.9,59.85 115.06,60.02 118.62,60.02
GND on BOTTOM (solid shape): 339.41,120.28 339.41,120.28 341.61,118.09 341.61,114.74 340.65,113.79 334.84,113.79 334.09,114.54 334.09,119.25 335.37,120.53 339.16,120.53
GND on BOTTOM (solid shape): 78.06,26.04 78.25,25.85 78.25,25.46 78.4,25.31 78.4,25.18 78.3,25.08 78.24,25.09 78.01,25.09 77.86,25.24 77.25,25.24 76.57,25.92 76.57,26.23 76.8,26.46 77.63,26.46
GND on BOTTOM (solid shape): 161.94,81.57 161.94,81.38 161.56,81 161.56,80.37 161.43,80.24 161.21,80.24 161.12,80.34 161.12,81.21 161.29,81.39 161.29,81.42 161.59,81.72 161.8,81.72
GND on BOTTOM (solid shape): 277.07,29.62 277.07,28.54 276.61,28.08 276.61,27.57 276.29,27.25 274.34,27.25 273.87,26.77 273.33,26.77 273.24,26.86 273.24,29.54 273.62,29.92 276.77,29.92
GND on BOTTOM (solid shape): 112.33,96.15 112.37,96.11 112.37,93.78 111.32,92.72 110.55,92.72 110.21,92.37 109.77,92.37 109.63,92.51 109.63,94.22 109.28,94.56 108.52,94.56 108.33,94.75 108.33,96.21 108.55,96.43 112.05,96.43
GND on BOTTOM (solid shape): 154.82,81.61 154.82,81.42 154.45,81.05 154.45,80.3 154.38,80.24 154.13,80.24 154,80.37 154,81 153.62,81.38 153.62,81.57 153.75,81.7 153.94,81.7 154.09,81.56 154.35,81.56 154.52,81.72 154.71,81.72
GND on BOTTOM (solid shape): 151.76,81.53 151.95,81.53 152.16,81.73 152.32,81.73 152.48,81.57 152.48,81.38 152.1,81 152.1,80.37 151.97,80.24 151.72,80.24 151.65,80.3 151.65,81.01 151.27,81.4 151.27,81.59 151.41,81.73 151.56,81.73
GND on BOTTOM (solid shape): 157.17,81.59 157.17,81.4 156.8,81.02 156.8,80.3 156.73,80.24 156.48,80.24 156.35,80.37 156.35,81 155.97,81.38 155.97,81.57 156.1,81.7 156.29,81.7 156.44,81.56 156.69,81.56 156.87,81.73 157.03,81.73
GND on BOTTOM (solid shape): 78.86,4.71 78.86,4.52 78.74,4.4 78.36,4.4 78.26,4.3 78.26,2.64 78.11,2.49 77.85,2.49 77.71,2.63 77.71,3.72 77.53,3.9 77.53,4.58 77.63,4.67 77.81,4.67 77.9,4.77 78.79,4.77
GND on BOTTOM (solid shape): 244.11,13.07 244.11,10.95 243.52,10.36 242.66,10.36 242.45,10.16 242.45,9.31 242.27,9.13 240.91,9.13 240.76,9.28 240.76,9.64 240.81,9.69 241.07,9.69 241.26,9.87 241.26,11.01 240.7,11.56 240.7,13.37 240.9,13.57 243.61,13.57
GND on BOTTOM (solid shape): 247.78,64.14 247.78,62.96 248.16,62.58 248.85,62.58 249,61.24 249.2,59.91 249.2,59.72 249.09,59.61 247.98,59.61 247.83,59.76 247.17,59.76 246.14,60.79 246.14,64.17 246.33,64.36 247.56,64.36
GND on BOTTOM (solid shape): 257.81,35.37 258.45,35.37 258.65,35.16 260.88,35.16 261.14,34.91 261.14,33.9 260.91,33.67 260.52,33.67 260.25,33.39 256.82,33.39 256.79,33.43 255.85,33.43 255.83,33.41 255.65,33.41 254.92,34.15 254.92,36.46 255.55,37.09 256.08,37.09
GND on BOTTOM (solid shape): 163.49,81.63 163.58,81.55 163.77,81.55 163.79,81.57 163.85,81.57 163.97,81.7 164.16,81.7 164.29,81.57 164.29,81.38 163.91,81 163.91,80.37 163.78,80.24 163.53,80.24 163.47,80.3 163.47,80.98 163.07,81.37 163.07,81.59 163.21,81.73 163.4,81.73
GND on BOTTOM (solid shape): 32.21,21.41 32.21,20.49 32.44,20.26 35.38,20.26 35.56,20.07 35.56,17.05 35.42,16.91 32.4,16.91 32.07,16.58 32.07,16.01 31.81,15.76 29.19,15.76 28.93,16.01 28.93,17.2 29.27,17.55 30.48,17.55 31.05,18.12 31.05,21.51 31.12,21.57 32.04,21.57
GND on BOTTOM (solid shape): 134.18,10.93 134.18,9.79 133.99,9.6 133.99,8.14 133.86,8.01 133.41,8.01 132.93,7.52 132.93,5.05 131,5.05 131,5.3 132.28,5.3 132.28,6.93 130.85,6.93 130.55,7.22 130.55,7.94 130.77,8.15 131,8.15 131.19,8.34 131.19,9.28 130.94,9.53 128.76,9.53 128.54,9.76 128.54,11.07 128.84,11.38 133.73,11.38
GND on BOTTOM (solid shape): 144.66,81.54 144.88,81.54 145.05,81.71 145.29,81.71 145.41,81.58 145.41,81.37 145.34,81.31 145.29,81.24 145.29,81.23 145.2,81.14 145.2,80.45 144.98,80.23 144.45,80.23 144.29,80.39 144.29,81.23 144.13,81.4 144.13,81.57 144.27,81.71 144.49,81.71
GND on BOTTOM (solid shape): 64.14,16.05 64.14,15.62 64.81,14.94 64.81,12.68 62.95,10.83 60.3,10.83 60.15,10.68 60.15,10.22 60.07,10.14 59.45,10.14 59.45,10.82 59.08,11.18 59.08,12.3 58.81,12.57 58.81,14.86 58.86,14.92 58.9,14.99 59.04,15.13 59.04,16.09 59.48,16.53 63.65,16.53
GND on BOTTOM (solid shape): 21.63,46.77 21.66,46.74 21.7,46.71 22.17,46.24 22.17,46.24 22.56,45.84 22.56,45.2 22.51,45.14 22.37,45.14 22.29,45.22 22.29,45.41 22.18,45.52 22.17,45.52 21.71,45.52 21.67,45.48 21.44,45.48 20.85,46.07 20.74,46.07 20.58,46.24 19.08,46.24 18.82,45.97 18.28,45.97 18.19,46.07 18.19,46.54 18.8,47.16 21.25,47.16
GND on BOTTOM (solid shape): 109.86,62.05 109.79,61.98 108.65,61.98 108.65,60.27 109.98,60.27 110.36,59.89 110.36,59.32 110.11,59.06 109.35,59.06 109.22,58.94 109.22,58.17 109.41,57.98 110.36,57.98 110.55,57.79 110.55,56.71 110.36,56.52 107.82,56.52 107.7,56.65 107.7,58.11 108.01,58.43 108.01,62.05 108.14,62.18 109.86,62.18
GND on BOTTOM (solid shape): 166.67,81.6 166.67,81.41 166.26,81 166.26,80.3 166.2,80.24 165.94,80.24 165.81,80.37 165.81,81 165.43,81.38 165.43,81.57 165.56,81.7 165.75,81.7 165.88,81.57 165.94,81.57 165.95,81.57 166.03,81.56 166.11,81.57 166.12,81.57 166.17,81.57 166.33,81.73 166.54,81.73
GND on BOTTOM (solid shape): 168.16,81.7 168.21,81.63 168.31,81.57 168.39,81.56 168.47,81.57 168.48,81.57 168.55,81.57 168.67,81.7 168.86,81.7 168.99,81.57 168.99,81.38 168.61,81 168.61,80.37 168.48,80.24 168.23,80.24 168.16,80.3 168.16,80.99 167.8,81.36 167.8,81.63 167.92,81.75 168.11,81.75
GND on BOTTOM (solid shape): 28.61,75.99 28.61,75.84 28.45,75.68 28.44,75.68 27.56,75.03 27.23,74 27.23,72.54 26.95,72.54 26.84,72.65 26.84,76.07 26.93,76.16 26.98,76.21 28.39,76.21
GND on BOTTOM (solid shape): 18.42,52.56 18.42,51.33 18.42,50.52 18.23,50.34 17.65,50.34 17.25,49.94 17.25,49.1 17.54,48.81 17.55,48.82 17.93,48.82 18.12,49 18.12,49.44 18.98,50.31 18.98,51.02 19.28,51.32 19.79,51.32 20.07,51.05 20.07,49.41 18.89,48.24 17.98,48.24 17.73,47.98 17.73,47.72 17.1,47.09 16.83,47.09 16.67,47.26 16.67,49.97 17.48,50.78 17.48,51.53 17.17,51.84 17.17,52.61 17.28,52.72 18.26,52.72
GND on BOTTOM (solid shape): 170.73,95.45 171.67,95.45 171.89,95.23 172.14,95.23 172.33,95.04 172.33,94.53 172.48,94.38 172.89,94.38 174.98,94.38 174.99,94.38 175.04,94.38 175.15,94.27 175.15,93.11 175.01,92.98 174.94,92.98 174.94,92.97 172.2,92.97 172.07,93.1 172.07,93.7 171.88,93.89 167.2,93.89 167.1,93.98 166.07,93.98 165.94,94.12 165.94,94.7 167.06,95.82 170.36,95.82
GND on BOTTOM (solid shape): 12.28,18.16 12.32,18.16 12.5,18.12 12.67,18.17 14.5,18.17 14.59,18.16 14.69,18.17 15.26,18.17 15.41,18.03 15.81,18.03 15.95,18.17 18.29,18.17 18.35,18.11 18.35,10.46 18,10.11 18,8.68 17.35,8.04 12.03,8.04 11.68,8.39 11.68,10.8 11.36,11.12 11.36,18.1 11.43,18.17 12.23,18.17
GND on BOTTOM (solid shape): 147.74,81.61 147.74,81.34 147.69,81.29 147.65,81.23 147.41,80.98 147.41,80.37 147.25,80.22 146.85,80.22 146.67,80.4 146.67,81.15 146.62,81.19 146.62,81.21 146.57,81.3 146.49,81.36 146.47,81.38 146.47,81.57 146.61,81.71 146.87,81.71 146.97,81.61 146.99,81.6 147.19,81.57 147.35,81.69 147.36,81.7 147.39,81.73 147.61,81.73
GND on BOTTOM (solid shape): 149.26,81.71 149.27,81.7 149.43,81.57 149.63,81.6 149.65,81.61 149.78,81.73 149.97,81.73 150.1,81.61 150.1,81.42 149.72,81.03 149.72,80.4 149.59,80.27 149.18,80.27 149.07,80.39 149.07,81.14 148.97,81.24 148.97,81.24 148.91,81.32 148.83,81.38 148.83,81.59 148.89,81.63 148.93,81.7 148.97,81.73 149.23,81.73
GND on BOTTOM (solid shape): 159.56,81.6 159.56,81.35 159.5,81.29 159.45,81.21 159.45,81.2 159.23,80.98 159.23,80.37 159.08,80.22 158.67,80.22 158.49,80.39 158.49,81.14 158.43,81.2 158.43,81.21 158.37,81.31 158.29,81.37 158.29,81.56 158.43,81.7 158.7,81.7 158.74,81.66 158.76,81.63 158.81,81.59 159,81.57 159.16,81.68 159.2,81.73 159.43,81.73
GND on BOTTOM (solid shape): 180.09,119.2 180.09,114.25 180.53,113.8 182.69,113.8 182.94,113.55 182.94,111.96 182.63,111.64 180.28,111.64 179.83,111.2 179.83,106.82 180.12,106.53 181.33,106.53 181.95,105.91 181.95,105.49 182.12,105.32 182.12,104.43 181.84,104.15 180.4,104.15 179.83,103.58 179.83,99.51 180.56,98.79 180.56,94.08 179.9,93.42 178.28,93.42 177.86,93.84 177.86,93.85 177.66,94.05 176.07,94.05 175.41,94.71 173.6,94.71 173.17,95.14 173.17,95.27 173.23,95.34 173.43,95.34 173.5,95.27 176.24,95.27 176.47,95.5 176.47,98.94 176.09,99.32 176.09,103.83 176.72,104.47 176.72,106.12 176.28,106.56 176.28,119.07 176.53,119.33 179.96,119.33
GND on BOTTOM (solid shape): 163.37,116.35 163.37,113.54 162.94,113.1 161.86,113.1 161.61,112.85 161.61,112.47 161.42,112.28 159.32,112.28 158.94,112.66 158.94,113.03 158.54,113.43 155.84,113.43 155.84,112.96 155.82,112.94 155.23,112.94 154.94,113.23 154.94,113.55 153.92,114.56 153.92,114.66 155.18,114.66 155.18,114.61 155.19,114.57 155.2,114.53 155.23,114.49 155.26,114.45 155.29,114.43 155.33,114.4 155.37,114.39 155.41,114.38 155.44,114.38 155.74,114.38 155.76,114.38 155.81,114.39 155.85,114.4 155.89,114.43 155.92,114.45 155.95,114.49 155.97,114.53 155.99,114.57 155.99,114.61 155.99,114.66 155.99,114.7 155.97,114.74 155.95,114.78 155.92,114.81 155.89,114.84 155.85,114.87 155.81,114.88 155.76,114.89 155.74,114.89 155.44,114.89 155.41,114.89 155.37,114.88 155.33,114.87 155.29,114.84 155.26,114.81 155.23,114.78 155.2,114.74 155.19,114.7 155.18,114.66 153.92,114.66 153.92,115.16 154.06,115.3 159.06,115.3 159.21,115.45 159.21,115.53 159.68,116 160.69,116 161.43,116.73 162.99,116.73
GND on BOTTOM (solid shape): 14.62,58.71 15.51,58.34 15.88,57.45 15.88,46.3 15.51,45.41 14.62,45.04 6.78,45.04 6.78,45.55 14.62,45.55 15.15,45.77 15.37,46.3 15.37,57.45 15.15,57.98 14.62,58.2 3.91,58.2 3.91,58.71
GND on BOTTOM (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on BOTTOM (solid shape): outline of 135 points within 106.73,70.37 115.79,86.1
GND on BOTTOM (solid shape): outline of 158 points within 140.53,104.91 152.4,119.39
GND on BOTTOM (solid shape): 79.24,25.87 79.29,25.84 79.31,25.78 79.31,25.71 79.33,25.63 79.5,25.5 79.71,25.54 79.74,25.56 79.78,25.6 79.8,25.61 79.84,25.61 79.88,25.59 79.93,25.54 79.98,25.52 80.02,25.51 80.05,25.5 80.09,25.51 80.17,25.53 80.21,25.53 80.38,25.36 80.36,25.3 80.36,25.26 80.36,25.21 80.37,25.16 80.39,25.11 80.4,25.07 80.39,25.03 80.16,24.67 80.47,24.38 80.5,24.33 80.49,24.26 80.48,24.23 80.49,24.09 80.57,23.99 80.57,23.86 80.48,23.86 80.47,23.89 80.4,24 80.28,24.08 80.18,24.1 80.07,24.09 80,24.09 79.96,24.13 79.91,24.19 79.84,24.24 79.66,24.23 79.53,24.09 79.53,24.08 79.48,24.03 79.45,24.04 79.37,24.05 79.29,24.04 79.22,24.06 79.18,24.12 79.14,24.2 79.08,24.26 79.05,24.31 79.06,24.36 79.1,24.43 79.12,24.5 79.11,24.72 78.97,24.91 78.95,24.93 78.91,24.98 78.93,25.04 79.09,25.2 79.09,25.57 79.07,25.58 78.95,25.7 78.95,25.81 79.01,25.87
GND on BOTTOM (solid shape): outline of 138 points within 199.99,71.07 204.94,79.03
GND on BOTTOM (solid shape): outline of 185 points within 102.25,33.64 351.55,122.8
GND on BOTTOM (solid shape): outline of 1282 points within 0.25,0 352.45,109.22
GND on BOTTOM (solid shape): outline of 1467 points within 1.15,33.64 101.66,112.75
GND on BOTTOM (solid shape): outline of 10480 points within 77.91,5.91 99.07,25.48
GND on IN1 (solid shape): 179.99,119.03 179.99,114.26 180.54,113.7 181.97,113.7 181.97,113.71 182.15,113.71 182.75,113.1 182.75,112.02 182.42,111.69 180.32,111.69 179.83,111.21 179.83,106.82 180.13,106.52 181.41,106.52 182.37,105.56 182.37,104.3 182.25,104.17 180.42,104.17 179.81,103.56 179.81,99.53 180.54,98.79 180.54,96.29 180.34,96.08 179.77,96.08 179.48,96.37 176.56,96.37 176.45,96.48 176.45,98.94 176.1,99.3 176.1,103.87 176.76,104.53 176.76,106.1 176.28,106.58 176.28,119.2 176.47,119.39 179.63,119.39
GND on IN1 (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on IN1 (solid shape): outline of 275 points within 0.25,0 352.45,109.22
GND on IN1 (solid shape): outline of 376 points within 1.15,33.64 351.55,122.55
GND on IN2 (solid shape): 180.06,118.96 180.06,118.8 180.01,118.75 180.01,114.28 180.56,113.73 182.13,113.73 182.75,113.1 182.75,111.95 182.58,111.77 180.39,111.77 179.81,111.18 179.81,106.79 180.09,106.51 180.49,106.51 180.5,106.52 181.41,106.52 182.32,105.61 182.32,104.5 182.02,104.2 180.44,104.2 179.81,103.56 179.81,99.55 180.52,98.84 180.52,96.21 180.39,96.08 177.17,96.08 176.77,96.48 176.77,99.74 176.72,99.79 176.72,99.79 176.07,100.44 176.07,103.79 176.73,104.45 176.73,106.1 176.28,106.56 176.28,119.2 176.47,119.39 179.63,119.39
GND on IN2 (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on IN2 (solid shape): outline of 275 points within 0.25,0 352.45,109.22
GND on IN2 (solid shape): outline of 377 points within 1.15,33.64 351.55,122.55
GND on IN3 (solid shape): 180.06,119.21 180.06,114.23 180.52,113.78 181.76,113.78 181.78,113.79 182.06,113.79 182.75,113.1 182.75,112.12 182.35,111.72 180.32,111.72 179.83,111.24 179.83,106.82 180.14,106.51 181.36,106.51 182.35,105.52 182.35,104.4 182.14,104.2 180.42,104.2 179.81,103.59 179.81,99.55 180.57,98.79 180.57,96.19 180.47,96.08 180.04,96.08 179.36,96.76 176.75,96.76 176.34,97.18 176.34,99.91 176.1,100.15 176.1,104.07 176.79,104.76 176.79,106.1 176.25,106.64 176.25,119.17 176.47,119.39 179.88,119.39
GND on IN3 (solid shape): 112.35,85.91 112.35,84.57 112.09,84.31 111.15,84.31 110.72,83.88 110.72,83.14 110.34,82.76 109.53,82.76 109.37,82.61 109.37,80.17 109.73,79.82 110.49,79.82 110.95,79.36 115.16,79.36 115.42,79.1 115.42,75.14 115.01,74.74 110.57,74.74 110.03,75.27 108.81,75.27 108.59,75.04 108.59,72.12 108.69,72.02 109.65,72.02 109.93,71.74 109.93,70.6 109.68,70.34 107.42,70.34 107.11,70.65 107.11,70.77 107.14,70.8 107.14,71.54 106.73,71.94 106.73,72.26 106.74,72.29 106.74,72.35 106.73,72.36 106.73,75.27 107.42,75.95 107.42,76.84 108.15,77.58 108.15,78.29 107.87,78.57 107.77,78.57 107.57,78.77 107.57,79.84 107.49,79.92 107.49,83.04 107.9,83.45 107.9,85.81 108.18,86.09 112.17,86.09
GND on IN3 (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on IN3 (solid shape): outline of 275 points within 0.25,0 352.45,109.22
GND on IN3 (solid shape): outline of 378 points within 1.15,33.64 351.55,122.55
GND on IN4 (solid shape): 180.05,119.15 180.05,114.27 180.54,113.78 180.62,113.78 180.65,113.8 182.06,113.8 182.75,113.1 182.75,111.79 182.6,111.64 180.24,111.64 179.83,111.24 179.83,106.82 180.11,106.54 181.33,106.54 182.37,105.5 182.37,104.35 182.2,104.17 180.37,104.17 179.83,103.64 179.83,99.55 180.57,98.81 180.57,94.32 180.06,93.81 178.9,93.81 178.02,94.69 177.01,94.69 176.5,95.2 176.5,99.28 176.1,99.68 176.1,103.82 176.73,104.45 176.73,106.13 176.23,106.63 176.23,119.15 176.47,119.39 179.81,119.39
GND on IN4 (solid shape): 112.35,85.91 112.35,84.57 112.09,84.31 111.15,84.31 110.72,83.88 110.72,83.14 110.34,82.76 109.53,82.76 109.37,82.61 109.37,80.17 109.73,79.82 110.49,79.82 110.95,79.36 115.16,79.36 115.42,79.1 115.42,75.14 115.01,74.74 110.57,74.74 110.03,75.27 108.81,75.27 108.59,75.04 108.59,72.12 108.69,72.02 109.65,72.02 109.93,71.74 109.93,70.6 109.68,70.34 107.42,70.34 107.11,70.65 107.11,70.77 107.14,70.8 107.14,71.54 106.73,71.94 106.73,75.27 107.42,75.95 107.42,76.84 108.15,77.58 108.15,78.29 107.87,78.57 107.77,78.57 107.57,78.77 107.57,79.84 107.49,79.92 107.49,83.04 107.9,83.45 107.9,85.81 108.18,86.09 112.17,86.09
GND on IN4 (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on IN4 (solid shape): outline of 901 points within 322.22,80.25 352.05,122.54
GND on IN4 (solid shape): outline of 276 points within 0.25,0 352.45,109.22
GND on IN4 (solid shape): outline of 377 points within 1.15,33.64 351.55,122.55
GND on IN5 (solid shape): 180.06,119.11 180.09,119.11 180.09,114.21 180.49,113.8 182.06,113.8 182.75,113.1 182.75,111.84 182.58,111.67 180.29,111.67 179.86,111.24 179.86,106.79 180.17,106.48 181.45,106.48 182.37,105.56 182.37,104.33 182.22,104.17 180.42,104.17 179.83,103.59 179.83,99.55 180.57,98.81 180.57,96.29 180.37,96.08 176.85,96.08 176.4,96.53 176.4,98.97 176.1,99.27 176.1,103.79 176.73,104.43 176.73,106.15 176.25,106.64 176.25,119.17 176.47,119.39 179.78,119.39
GND on IN5 (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on IN5 (solid shape): 350.32,109.22 350.09,108.39 350.8,107.89 352.24,107.89 352.45,107.68 352.45,106.29 352.24,106.09 350.8,106.09 350.05,105.34 350.8,104.59 352.24,104.59 352.43,104.4 352.44,104.38 352.45,104.36 352.45,102.69 352.24,102.49 350.8,102.49 350.05,101.74 350.8,100.99 352.24,100.99 352.45,100.78 352.45,99.1 352.24,98.89 350.8,98.89 350.05,98.14 350.8,97.39 352.24,97.39 352.45,97.18 352.45,95.5 352.24,95.29 350.8,95.29 350.05,94.54 350.8,93.79 352.24,93.79 352.45,93.58 352.45,91.9 352.24,91.69 350.8,91.69 350.05,91.02 350.63,90.2 350.65,90.2 350.85,89.99 350.85,86.56 350.34,86.56 350.34,89.77 349.56,91.17 350.8,92.2 351.94,92.2 351.94,93.28 350.8,93.28 349.54,94.54 350.8,95.8 351.94,95.8 351.94,96.88 350.8,96.88 349.54,98.14 350.8,99.4 351.94,99.4 351.94,100.48 350.8,100.48 349.54,101.74 350.8,103 351.94,103 351.94,104.08 350.8,104.08 349.54,105.34 350.8,106.6 351.94,106.6 351.94,107.38 350.8,107.38 349.72,107.99 349.68,109.22
GND on IN5 (solid shape): outline of 125 points within 1.15,56.46 30.93,112.75
GND on IN5 (solid shape): outline of 212 points within 0.25,0 352.45,91.76
GND on IN5 (solid shape): outline of 257 points within 29.57,33.64 351.55,122.55
GND on IN6 (solid shape): 163.32,116.29 163.32,113.55 162.94,113.17 161.88,113.17 161.62,112.91 161.62,112.48 161.42,112.28 159.41,112.28 159.01,112.68 159.01,113.01 158.57,113.45 155.04,113.45 153.9,114.59 153.9,115.05 154.13,115.27 158.98,115.27 159.69,115.99 160.76,115.99 161.44,116.67 162.94,116.67
GND on IN6 (solid shape): 151.44,119.21 151.44,118.37 150.85,117.79 148.67,117.79 148.49,117.97 148.49,118.12 148.24,118.37 144.37,118.37 144.17,118.17 144.17,117.31 143.84,116.98 143.16,116.98 142.9,116.72 142.9,114.08 142.98,114 144.48,114 144.63,113.85 144.63,110.73 144.35,110.45 142.9,110.45 142.83,110.37 142.83,107.68 142.88,107.63 143.69,107.63 144.45,106.87 144.45,105.19 144.25,104.99 143.59,104.99 143.41,105.16 143.41,106.56 143.13,106.84 141.45,106.84 141.25,107.04 140.79,107.04 140.64,107.2 140.64,107.45 141.02,107.83 141.02,111.01 140.82,111.21 140.82,112.81 141.07,113.06 141.07,117.51 140.62,117.97 140.62,119.26 140.77,119.41 151.23,119.41
GND on IN6 (solid shape): 112.35,85.91 112.35,84.57 112.09,84.31 111.15,84.31 110.72,83.88 110.72,83.14 110.34,82.76 109.53,82.76 109.37,82.61 109.37,80.17 109.73,79.82 110.49,79.82 110.95,79.36 115.16,79.36 115.42,79.1 115.42,75.14 115.01,74.74 110.57,74.74 110.03,75.27 108.81,75.27 108.59,75.04 108.59,72.12 108.69,72.02 109.65,72.02 109.93,71.74 109.93,70.6 109.68,70.34 107.42,70.34 107.11,70.65 107.11,70.77 107.14,70.8 107.14,71.54 106.73,71.94 106.73,75.27 107.42,75.95 107.42,76.84 108.15,77.58 108.15,78.29 107.87,78.57 107.77,78.57 107.57,78.77 107.57,79.84 107.49,79.92 107.49,83.04 107.9,83.45 107.9,85.81 108.18,86.09 112.17,86.09
GND on IN6 (solid shape): 10.31,77.58 10.67,77.22 12.4,77.22 12.52,77.1 12.52,76.56 12.17,76.21 11.02,76.21 10.81,75.99 9.91,74.87 8.54,75.32 5.61,75.32 4.93,74.63 3.15,74.63 2.46,75.32 1.9,75.32 1.73,75.25 1.66,75.08 1.66,72.91 1.15,72.91 1.15,75.08 1.37,75.61 1.9,75.83 8.84,75.83 10.08,75.55 9.8,76.79 9.8,78.44 10.31,78.44
GND on IN6 (solid shape): outline of 277 points within 0.25,0 352.45,109.22
GND on IN6 (solid shape): outline of 377 points within 1.15,33.64 351.55,122.55
GND on TOP: 8.15,62 7.91,62 7.84,62.08 7.84,62.45 7.39,62.9 6.95,62.9 6.71,62.66 6.39,62.66 6.21,62.84 6.21,63.24 6.32,63.35 8.29,63.35 8.49,63.15 8.49,62.34
GND on TOP: 21.89,44.53 21.89,41.51 21.69,41.31 21.69,37.99 21.83,37.84 22.55,37.84 22.72,38.01 24.27,38.01 24.41,37.87 24.41,36.35 24.22,36.16 22.35,36.16 21.8,36.71 21.8,37.06 21,37.86 21,41.23 21.06,41.28 21.25,41.28 21.46,41.49 21.46,42.42 21.31,42.56 20.98,42.56 20.85,42.69 20.85,42.87 21.46,43.48 21.46,44.52 21.51,44.57 21.84,44.57
GND on TOP: 56.64,30.23 56.64,31.82 56.83,32.01 58.8,32.01 59.18,31.63 59.18,29.98 59.5,29.66 60.71,29.66 60.95,29.91 60.95,30.28 61.1,30.43 62.42,30.43 62.55,30.3 62.55,29.47 62.2,29.12 57.75,29.12
GND on TOP: 15.09,13.38 15.82,14.11 15.82,17.8 16.31,18.29 18.3,18.25 18.3,13.85 17.36,12.92 17.36,8.38 16.99,8 15.57,8 15.26,8.31 15.21,8.31 15.01,8.45 14.77,8.49 14.26,8.49 14.16,8.49 14.06,8.46 13.74,8.79 13.74,11.56 13.31,11.98 12.64,11.98 12.31,12.32 12.31,13.05 12.64,13.38
GND on TOP: 8.97,68.77 6.93,68.77 6.71,68.99 6.38,68.99 6.18,68.79 6.18,68.44 6.36,68.26 7.09,68.26 7.16,68.32 8.95,68.32 9.08,68.45 9.08,68.66
GND on TOP: 168.15,99.77 171.13,99.77 171.71,99.2 171.71,96.59 171.45,96.34 168.85,96.34 167.9,97.29 167.9,99.51
GND on TOP: 29.36,32.27 28.5,32.27 28.37,32.14 28.37,31.89 28.53,31.73 29.19,31.73 29.36,31.56 29.36,31.05 29.47,30.95 30.07,30.95 30.1,30.97 30.1,31.58 30.05,31.63 29.74,31.63 29.52,31.86 29.52,32.11
GND on TOP: 23.87,49.78 21.14,49.78 20.86,49.5 20.86,46.01 21.07,45.8 21.11,45.8 21.82,45.1 22.6,45.1 22.66,45.15 22.66,45.92 22.49,46.09 22.24,46.09 21.4,46.93 21.4,48.2 21.55,48.35 22.51,48.35 22.69,48.17 22.69,47.92 22.84,47.76 23.8,47.76 23.95,47.91 23.95,49.71
GND on TOP: 42.48,21.28 45.28,21.28 45.59,20.96 45.59,19.76 45.47,19.63 42.42,19.63 42.23,19.82 42.23,21.03
GND on TOP: 47.25,28.74 48.02,27.98 48.02,26.99 47.51,26.48 46.47,26.48 46.34,26.61 46.34,28.58 46.51,28.74
GND on TOP: 52.49,4.43 52.13,4.07 52.13,1.6 52.01,1.47 49.81,1.47 49.67,1.61 49.67,1.91 49.85,2.09 49.85,2.74 49.72,2.87 48.77,2.87 48.52,3.12 48.52,5.79 48.64,5.91 53.62,5.91 53.91,5.63 53.91,4.57 53.77,4.43
GND on BOTTOM: 177.31,36.88 172.76,36.88 172.58,36.7 172.58,32.11 172.84,31.85 175.23,31.85 176.23,30.86 176.23,29.16 175.74,28.68 175.74,27.35 176.06,27.03 177.23,27.03 177.45,27.25 177.45,36.74
GND on BOTTOM: 261.46,17.34 261.8,17 261.8,16.65 261.37,16.22 259.76,16.22 259.68,16.13 259.68,15.94 259.77,15.85 261.33,15.85 261.53,15.65 263.13,15.65 263.26,15.78 263.26,17.46 262.95,17.76 259.82,17.76 259.72,17.66 259.72,17.44 259.83,17.33 260.31,17.33 260.32,17.34
GND on BOTTOM: 239.23,11.11 240.91,11.11 241.01,11.01 241.01,9.94 240.88,9.81 240.7,9.81 240.63,9.74 240.63,9.22 240.49,9.08 239.42,9.08 239.21,9.29 239.21,11.08
GND on BOTTOM: outline of 621 points within 21.81,35.94 31.75,45.91
GND on BOTTOM: 2.92,39.28 3.58,39.28 3.68,39.38 3.68,43.9 3.61,43.98 2.41,43.98 2.21,43.77 2.21,40.45 2.31,40.34 2.67,40.34 2.85,40.17 2.85,39.35
GND on BOTTOM: 96.68,25.18 96.66,25.13 96.64,25.08 96.64,25.03 96.65,25.02 96.77,24.85 96.78,24.63 96.79,24.61 96.81,24.59 96.88,24.55 96.93,24.49 96.99,24.45 97.05,24.47 97.2,24.56 97.37,24.57 97.39,24.58 97.41,24.6 97.63,24.77 97.86,24.63 98.03,24.46 98.49,24.46 98.62,24.33 98.62,24.08 98.74,23.95 98.93,23.95 99.19,24.2 99.44,24.2 99.57,24.33 99.57,25.26 99.57,25.26 99.94,25.63 99.94,25.96 99.78,26.12 99.47,26.12 99.25,25.91 97.88,25.91 97.73,25.76 97.73,25.69 97.57,25.51 97.34,25.53 97.31,25.56 97.28,25.59 97.22,25.62 97.16,25.59 97.09,25.53 97.01,25.51
GND on BOTTOM: 121.35,69.73 124.02,69.73 124.21,69.54 124.21,67.13 123.83,66.75 120.09,66.75 119.9,66.94 119.9,68.29
GND on BOTTOM: 28.46,56.32 27.69,57.1 27.69,57.37 27.59,57.48 27.59,61.08 27.92,61.41 28.46,61.41 28.46,61.41 28.72,61.41 28.83,61.3 29.24,58.93 29.83,56.6 29.83,56.4 29.75,56.32
