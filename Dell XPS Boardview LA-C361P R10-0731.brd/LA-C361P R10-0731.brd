# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CLKB1#: length 35.6
  TOP w0.17: RV387.1 246.75,89.67 246.36,89.67 245.9,89.21 244.69,89.21 244.27,89.63 244.27,89.72 v2(243.91,90.08)
  IN6 w0.097: v2(243.91,90.08) 243.68,89.84 243.58,89.84 243.28,89.54 242.04,89.54 240.81,88.31 240.81,83.64 238.18,81.01 235.92,81.01 235.82,80.92 233.34,80.92 230.28,77.85 225.13,77.85 223.9,79.08 223.9,79.38 223.65,79.64 223.01,79.64 222.9,79.75 222.9,79.93 223.03,80.06 v2(223.14,80.06)
  BOTTOM w0.089: UV1.F20 223.07,79.65 223.25,79.84 223.25,79.96 223.14,80.08 v2(223.14,80.06)
  BOTTOM w0.114: UV10.J11 243.53,90.47 v2(243.91,90.08)
CLKDET#: length 4.2
  TOP w0.089: v1(92.22,3.34) 92.08,3.34 RH558.1 91.19,4.32 90.32,5.18 v2(89.6,5.18)
  BOTTOM w0.089: v2(89.6,5.18) 89.53,5.26 89.27,5.26 UH2.BB22
CLKREQ_PCIE#0: length 25.9
  IN3 w0.089: v2(88.8,1.71) 89.07,1.97 89.07,2.7 88.06,3.71 86.82,3.71 86.51,4.02 86.05,4.02 85.74,3.71 82.85,3.71 81.05,1.91 75.62,1.91 75.08,2.45 75.06,2.45
  IN3 w0.091: 75.06,2.45 72.57,2.45 72.34,2.22 71.32,2.22 v2(70.85,1.75)
  BOTTOM w0.089: v2(88.8,1.71) 88.8,1.7 88.34,2.16 88.34,2.75 88.33,2.76 88.33,2.76 88.06,3.03 88.06,3.6 87.89,3.78 87.89,4.7 88.04,4.85 UH2.BC24
  BOTTOM w0.14: v2(70.85,1.75) 70.85,2.15 RH548.2
CLKRUN#: length 266.2
  TOP w0.14: UE3.A32 304.73,19.13 304.79,19.19 304.79,19.44 v2(304.41,19.82) ; RH85.1 106.11,7.78 v2(105.56,8.33) ; v1(315.85,6.99) 315.6,6.99 315.22,6.61 314.2,6.61 313.86,6.95 v2(313.86,7.89)
  IN2 w0.089: v2(89.73,6.97) 90.26,6.44 90.26,5.75 90.54,5.47 91.99,5.47 92.15,5.31 95.12,5.31 95.81,6 96.13,6 96.54,6.42 97.7,6.42 98.06,6.78 99.08,6.78 99.63,7.33 100.12,7.33 100.97,8.17 101.98,8.17
  IN2 w0.099: 101.98,8.17 102.23,8.17 102.84,8.79 104.04,8.79 104.5,8.33 v2(105.56,8.33) 106.18,8.95 116.89,8.95 118.61,10.67 146.53,10.67 146.85,10.36 149.43,10.36 151.58,8.21 151.58,7.25 152.46,6.36 159.25,6.36 159.78,5.83 163.37,5.83 163.69,5.51 172.07,5.51 172.59,6.04 175.18,6.04 176.02,6.89 179.74,6.89 180.48,7.63 200.49,7.63 201.08,8.23 209.64,8.23 214.89,2.98 238.91,2.98 239.78,3.84 244.73,3.84 246.38,5.5 250.88,5.5 251.06,5.32 267.75,5.32 269.64,3.43 288.79,3.43 289.51,4.15 296.2,4.15 296.36,4.31 300.89,4.31 301.75,5.17 303.07,5.17 303.99,4.25 309.63,4.25 310.21,4.83 310.85,4.83 313.86,7.85 v2(313.86,7.89)
  IN3 w0.091: v2(313.86,7.89) 313.59,8.16 313.59,19.08 311.93,20.75 305.33,20.75 v2(304.41,19.82)
  BOTTOM w0.089: v2(89.73,6.97) 89.52,6.76 UH2.AW22
CPU_24MHZ_N: length 139.8
  IN6 w0.107: v2(100.76,24.2) 100.59,24.02 100.43,24.02 100.29,24.16 100.29,28.46 102.63,30.8 104.83,30.8 117.55,43.53 117.55,51.58 119.25,53.28 119.25,59.67 122.3,62.72 123.5,62.72 127.18,66.4 127.18,69.16 128.39,70.37 128.39,75.49 131.89,78.99 131.89,81.56 132.92,82.58 132.92,84.27 133.61,84.96 133.61,88.42 135.94,90.75 156.19,90.75 157.21,89.73 170.06,89.73 170.47,89.32 175.16,89.32 179.19,85.29 179.19,81.61 178.72,81.15 175.74,81.15 175.57,81.32 175.57,81.53 v2(175.82,81.77)
  BOTTOM w0.076: v2(175.82,81.77) 175.82,81.85 UH1.D31
  BOTTOM w0.102: v2(100.76,24.2) 100.56,24 100.12,24 99.65,23.53 99.47,23.53 UH2.F1
CPU_24MHZ_P: length 141.7
  IN6 w0.107: v2(175.17,81.77) 175.37,81.57 175.37,81.23 175.66,80.95 178.81,80.95 179.39,81.53 179.39,85.37 175.24,89.52 170.56,89.52 170.14,89.94 157.29,89.94 156.27,90.95 135.85,90.95 133.4,88.5 133.4,85.04 132.72,84.35 132.72,82.67 131.69,81.64 131.69,79.08 128.18,75.58 128.18,70.46 126.98,69.25 126.98,66.49 123.42,62.93 122.22,62.93 119.05,59.76 119.05,53.36 117.35,51.66 117.35,43.61 104.74,31 102.55,31 100.09,28.54 100.09,24.08 100.34,23.82 100.56,23.82 v2(100.76,23.62)
  BOTTOM w0.076: v2(175.17,81.77) 175.17,81.85 UH1.E31
  BOTTOM w0.102: v2(100.76,23.62) 100.61,23.77 100.19,23.77 99.33,22.91 UH2.G1
CPU_TRIGGER: length 162.7
  TOP w0.14: RH192.1 v1(180.74,73.8) 181.55,73 v2(183.26,73)
  IN5 w0.099: v2(177.03,21.12) 177.03,19.65 175.24,17.86 110.86,17.86 110.8,17.8 107.2,17.8 106.88,18.13 106.29,18.13 105.31,19.11 105.31,20.76 v2(104.8,21.27)
  IN6 w0.099: v2(177.03,21.12) 178.66,22.75 178.66,24.96 180.67,26.97 180.67,31.58 193.31,44.22 193.31,60.05 191.06,62.3 191.06,64.21 189.18,66.09 186.44,66.09 183.26,69.26 v2(183.26,73)
  BOTTOM w0.089: 101.59,12.54 101.59,12.29 100.76,11.46 99.48,11.46 UH2.AK1
  BOTTOM w0.127: 101.59,12.54 101.8,12.76 104.01,12.76 104.29,13.04 105.14,13.04 105.22,13.12 105.22,15.4 105.16,15.46 105.16,17.12 104.24,18.04 104.24,20.17 104.56,20.49 104.56,21.03 v2(104.8,21.27)
CPU_TRIGGER_R: length 6.4
  TOP w0.089: v3(178.09,76.95) 177.72,76.58 RH192.2 176.17,75.9 176.12,75.85 174.23,75.85 v2(173.84,76.24)
  BOTTOM w0.076: UH1.J23 173.21,76.24 v2(173.84,76.24)
CPU_XDP_TCK: length 39.4
  TOP w0.14: RH498.2 RH491.2 131.12,103.01 v1(130.82,102.71) 130.82,101.93 131.27,101.48 v2(131.27,100.1) 131.17,100.01 130.64,100.01 130.28,99.65 129.64,99.65 129.5,99.51 JXDP.57
  IN2 w0.089: 134.62,78.99 135,78.99 v2(135.41,79.39)
  IN2 w0.099: 128.98,86.21 130.17,85.02 130.17,82.18 132.09,80.26 132.09,79.83 132.94,78.99 134.62,78.99
  IN2 w0.102: v2(131.27,100.1) 130.76,99.6 130.76,97.21 131.62,96.35 131.62,95.92 132.8,94.74 132.8,93.13 128.98,89.31 128.98,86.21
  BOTTOM w0.076: UH1.BR28 137.81,79.28 137.47,79.28 137.06,78.87 135.93,78.87 v2(135.41,79.39)
CPU_XDP_TDI: length 25.9
  TOP w0.14: v2(139.04,94.8) 139.04,94.66 v1(139.41,94.29)
  IN2 w0.102: v2(139.04,94.8) 139.04,92.41 135.4,88.77 135.4,83.42 135.69,83.12 137.29,83.12 138.47,81.95 141.04,81.95 v2(141.23,82.13)
  BOTTOM w0.076: v2(141.23,82.13) 140.9,82.46 UH1.BL32
  BOTTOM w0.14: v2(139.04,94.8) 137.01,96.83 RH541.2 RH495.2
CPU_XDP_TDO: length 27.2
  TOP w0.14: v2(133.14,96.15) 134.11,96.15 v1(134.18,96.21)
  IN2 w0.099: v2(133.14,96.15) 133.21,96.07 133.21,92.96 129.39,89.14 129.39,86.38
  IN2 w0.102: v2(136.04,79.39) 135.43,80 133.88,80 133.32,80.57 132.36,80.57 130.59,82.34 130.59,85.18 129.39,86.38
  BOTTOM w0.076: UH1.BT28 136.92,79.04 136.5,79.04 136.14,79.39 v2(136.04,79.39)
  BOTTOM w0.14: v2(133.14,96.15) 133.67,96.68 RH496.2 RH540.2
CPU_XDP_TMS: length 35.1
  TOP w0.14: v1(134.48,80.4) 134.14,80.06 v2(134.14,79.39)
  IN2 w0.099: v2(131.29,98.73) 131.29,97.23 131.64,96.88 132.37,96.88 132.7,96.55
  IN2 w0.102: v2(134.14,79.39) 133.17,80.37 132.27,80.37 130.37,82.26 130.37,85.11 129.19,86.29 129.19,89.22 133.01,93.04 133.01,94.83 132.7,95.13 132.7,96.55
  BOTTOM w0.076: 134.62,79.79 137.26,79.79 137.37,79.91 138.42,79.91 UH1.BP28
  BOTTOM w0.127: 134.45,79.71 v2(134.14,79.39)
  BOTTOM w0.14: 134.45,79.71 134.53,79.79 134.62,79.79 ; v2(131.29,98.73) 131.18,98.62 131.18,97.35 RH494.2 131.7,96.02 131.18,95.5 RH542.2
CPU_XDP_TRST#: length 124.1
  TOP w0.089: v2(97.23,6.91) 97.35,6.78 98.65,6.78 99.33,7.47 99.33,7.9 99.91,8.48 100.5,8.48 101.41,9.39 101.41,9.67 101.65,9.91 101.98,9.91
  TOP w0.127: v2(115.25,46.17) v1(115.25,45.07) 115.25,40.05 105.9,30.7 101.95,30.7 98.7,27.45 98.7,25.5 99.68,24.51 99.68,23.02 102.17,20.53 102.54,20.53 105.54,17.53
  TOP w0.14: 105.54,17.53 105.66,17.41 106.94,17.41 108.14,16.2 110.04,16.2 110.05,16.21 111.99,16.21 112.72,15.48 112.72,12.7 111.33,11.31 106.38,11.31 104.98,9.91 101.98,9.91
  IN4 w0.091: v2(115.25,46.17) 117.36,48.28 117.36,52.14 118.46,53.25 118.46,55.09 118.11,55.44 118.11,63.21 119.77,64.87 119.9,64.87 122.02,66.99 122.02,68.28 125.16,71.42 125.16,79.29 v2(127.98,82.11)
  BOTTOM w0.076: UH1.BP30 138.53,81.15 138.24,81.44 137.9,81.44 137.71,81.63 135.2,81.63 134.89,81.31 134.62,81.31
  BOTTOM w0.089: v2(97.23,6.91) 97.28,6.85 UH2.AY5
  BOTTOM w0.14: v2(127.98,82.11) 128.18,82.11 RH543.2 130.54,81.4 RH497.2 131.67,81.31 134.62,81.31
CR_CLK_REQ#: length 318.4
  TOP w0.127: 68.82,4.83 68.81,4.83 68.73,4.76 68.51,4.76 68.25,4.49 67.48,4.49 v2(67.31,4.32)
  TOP w0.14: v1(324.35,34.27) 324.65,34.58 v2(325.16,34.58) ; RP2.6 68.73,5.58 68.96,5.34 68.96,4.97 68.82,4.83
  IN3 w0.091: v2(325.16,34.58) 325.62,34.12 326.84,34.12 327.44,33.52 334.99,33.52 v2(335.46,33.04)
  IN5 w0.089: 75.06,4.47 75.26,4.27 75.6,3.93 86.27,3.93 86.78,3.42 87.07,3.42 87.62,2.87 87.62,2.45 87.97,2.09 89.11,2.09 v2(89.47,1.74)
  IN5 w0.099: 75.06,4.47 74.71,4.82 67.81,4.82 v2(67.31,4.32)
  IN6 w0.089: v2(89.47,1.74) 89.68,1.52 97.97,1.52 100.29,3.84 101.98,3.84
  IN6 w0.099: v2(325.16,34.58) 325.4,34.33 325.4,31.31 324.76,30.66 324.76,26.93 320.08,22.26 320.08,10.14 316.22,6.28 307.9,6.28 305.93,4.31 303.54,4.31 302.88,4.97 301.75,4.97 301.1,4.31 295.15,4.31 294.98,4.48 270.76,4.48 269.98,3.69 268.94,3.69 267.01,5.62 263.34,5.62 263.12,5.41 258.97,5.41 258.27,4.71 254,4.71 253.05,5.66 246.53,5.66 245.46,4.6 243.5,4.6 242.62,3.72 238.11,3.72 237.38,2.98 215.95,2.98 210.6,8.33 179.02,8.33 177.59,6.91 176.09,6.91 175,5.82 172.06,5.82 171.24,5 169.75,5 167.82,3.07 157.28,3.07 156.16,4.19 150.16,4.19 149.6,4.74 147.93,4.74 144.9,7.78 142.22,7.78 141.08,6.63 140.03,6.63 139.67,7 135.17,7 134.98,6.81 134.15,6.81 134.14,6.81 133.51,6.81 133.08,6.38 129.66,6.38 129.45,6.6 118.83,6.6 116.42,4.18 110.18,4.18 108.6,2.6 106.37,2.6 105.12,3.84 101.98,3.84
  BOTTOM w0.089: v2(89.47,1.74) 89.07,2.14 89.07,2.82 88.76,3.13 88.64,3.13 88.43,3.34 88.43,3.45 88.42,3.46 88.42,3.86 88.42,3.86 88.28,3.99 88.28,4.24 88.39,4.35 88.38,4.35 88.38,4.66 88.28,4.76 88.28,5.24 UH2.BB24
  BOTTOM w0.14: v2(335.46,33.04) 334.88,33.62 UR1.2
CS_1.2V: length 3.9
  BOTTOM w0.14: v3(286.12,25.97) 286.34,26.18 287.77,26.18 PR601.2
  BOTTOM w0.203: PU600.13 288.27,27 288.08,26.81 PR601.2
CSSN_1: length 7.5
  TOP w0.254: v2(54.37,6.48) 54.48,6.59 54.48,7.18 v1(53.6,8.07) 51.88,9.79 51.88,10.91 PR302.1
  BOTTOM w0.254: v2(54.37,6.48) 55.02,7.13 PR300.2
CSSP_1: length 7
  TOP w0.254: v2(55.02,6.45) 54.87,6.61 54.87,7.49 v1(52.58,9.77) 52.39,9.96 52.39,10.92 PR301.1
  BOTTOM w0.254: v2(55.02,6.45) 55.02,6.44 PR300.3
DAT_SMB: length 11
  TOP w0.254: v2(21.02,10.78) 21.02,11.25 20.83,11.44 v3(20.83,12.01) 20.83,12.96 21.21,13.34 PD101.3 21.21,14.55 19.91,15.85 19.6,15.85 PR108.1
  BOTTOM w0.254: v2(21.02,10.78) 21.02,10.91 20.85,11.08 BAT100.6
DAT_TP_SIO: length 123.5
  TOP w0.14: UE3.B40 300.52,19.41 v2(300.39,19.27) ; RE26.2 300.99,23.07 300.66,22.74 v2(300.48,22.74) ; v1(216.37,6.91) 217.73,8.27 v2(217.73,8.64) 217.73,9.31 CE78.1
  IN3 w0.091: v2(300.48,22.74) 300.04,23.19 291.29,23.19 290.25,22.15 282.05,22.15 279.51,19.61 278.65,19.61 277.63,18.59 272.39,18.59 270.32,16.52 268.57,16.52 266.54,14.49 260.69,14.49 260.57,14.36 256.7,14.36 256.48,14.14 253.84,14.14 252.12,12.43 233.52,12.43 232.75,11.66 231.16,11.66 230.35,10.84 219.93,10.84 v2(217.73,8.64)
  IN4 w0.091: v2(300.39,19.27) 300.39,20.77 299.95,21.21 299.95,22.34 300.36,22.74 v2(300.48,22.74)
  BOTTOM w0.14: v2(217.73,8.64) 218.4,7.98 221.51,7.98 222.38,8.84 222.38,9.19 224.69,11.5 225.39,11.5 225.63,11.74 225.63,11.93 226.42,12.71 229.24,12.71 DE4.3 229.67,13.62 228.12,15.17 227.31,15.17 226.44,14.31 226.44,14.04 224.35,11.95 222.83,11.95 222.4,12.37 JTP.2
DAUL_IN: length 125.5
  TOP w0.254: PR243.1 v2(13.79,3.72)
  IN3 w0.254: v2(25.49,70.64) 25.53,70.6 26.44,70.6 26.75,70.9 26.75,78.11 25.9,78.96 25.9,81.68 26.44,82.23 26.44,84.21 v2(25.49,85.16) ; v2(26.09,66.05) 25.66,66.48 25.66,69.2 v2(25.49,69.37) ; v2(32.98,21.37) 32.98,19.49 32.21,18.72 29.22,18.72 28.6,18.09 28.6,9.01 28.21,8.62 28.21,7.57 27.21,6.57 27.21,5.63 24.75,3.17 14.34,3.17 v2(13.79,3.72)
  IN5 w0.254: v2(23.03,93.29) 23.06,93.26 23.06,92.88 23.52,92.43 23.52,91.97 24.65,90.84 24.65,86 v2(25.49,85.16) ; v2(26.09,66.05) 26.48,65.66 26.48,61.29 26.23,61.03 26.23,58.49 27,57.72 27,55.52 29.12,53.4 29.12,52.57 31.31,50.38 31.31,48.08 31.04,47.81 31.04,44.77 32.75,43.06 33.04,43.06 34.16,41.94 34.16,40.44 36.84,37.76 36.84,33.99 36.25,33.4 36.25,27.79 32.98,24.53 v2(32.98,21.37)
  BOTTOM w0.254: PR202.1 19.64,97.44 19.64,95.64 20.12,95.16 20.8,95.16 21.41,95.77 21.41,96.07 21.64,96.3 PQ204.3 23.03,95.7 v2(23.03,93.29)
  vias: v1(24.41,69.66) v2(24.91,70.64) v2(24.91,70) v2(24.91,69.37) v2(25.49,70)
DCIN_ACOK: length 443.9
  TOP w0.14: v2(309.35,7.46) 309.82,7.46 310.21,7.85 310.21,8.82 309.75,9.28 DE11.1 ; v2(25.83,29.92) 25.73,30.02 25.01,30.02 24.35,29.36 PQ229.2 ; v2(27.76,55.46) 27.76,55.48 28.04,55.48 v1(28.58,56.02)
  TOP w0.254: v2(11.01,21.95) 10.94,21.88 PR259.2
  IN2 w0.089: 33.66,43.04 32.81,43.04 32.44,43.41 32.44,43.87 31.36,44.95 31.36,47.13 ; 101.98,14.98 101.62,14.98 100.81,15.79 99,15.79 98.61,15.4 94.57,15.4 91.34,18.63 91.34,19.93 91.06,20.2 88.29,20.2 86.83,18.74 86.09,18.74 85.17,17.82 85.17,16.41 84.07,15.31 80.84,15.31 77.79,12.25 75.48,12.25 75.06,12.68
  IN2 w0.099: v2(34.75,37.33) 34.75,42.24 33.95,43.04 33.66,43.04 ; 75.06,12.68 73.4,14.34 73.4,22.34 71.1,24.63 60.2,24.63 55.94,28.9 47.97,28.9 45.73,31.14 40.6,31.14 38.93,32.81 35.95,32.81 34.89,31.75 33.84,31.75 33.05,30.96 31.29,30.96 30.87,30.53 26.45,30.53 v2(25.83,29.92) 25.03,29.92 24.43,29.31 20.95,29.31 17.35,25.71 17.35,25.26 16.77,24.67 16.77,23.55 16.03,22.82 11.88,22.82 v2(11.01,21.95) 10.47,21.41 8.79,21.41 v2(8.38,21) ; v2(214.01,8.47) 213.66,8.47 210.9,11.24 175.34,11.24 174.82,11.76 155.31,11.76 152.59,14.48 122.15,14.48 121.64,14.98 101.98,14.98 ; 31.36,47.13 31.36,47.52 30.96,47.91 28.29,47.91 27.93,48.27 27.93,50.88 27.79,51.02 27.79,55.44 v2(27.76,55.46)
  IN3 w0.254: v2(27.76,55.46) 28.12,55.46 28.32,55.66 28.32,56.83 27.52,57.63 27.52,58.64 27.1,59.06 27.1,78.27 26.25,79.12 26.25,81.52 26.82,82.09 26.82,85.84 26.14,86.52 26.14,88.86 24.99,90 24.99,93.66 23.93,94.73 23.93,96.45 v2(23.85,96.53)
  IN5 w0.089: 32.8,34.3 32.47,34.62 31.8,34.62 31.59,34.83 31.59,35.83 33.1,37.33 33.66,37.33
  IN5 w0.099: v2(25.83,29.92) 26.25,30.34 26.71,30.34 27.34,30.97 32.36,30.97 33.75,32.36 33.75,33.34 32.8,34.3 ; v2(214.01,8.47) 215.01,9.48 231.03,9.48 231.51,9 231.73,9 232.21,8.52 252.16,8.52 252.93,9.29 262.05,9.29 263.18,8.16 274.07,8.16 275.98,6.25 284.66,6.25 285.84,5.07 300.98,5.07 302.41,6.5 306.62,6.5 307.18,7.06 308.95,7.06 v2(309.35,7.46) ; 33.66,37.33 v2(34.75,37.33)
  BOTTOM w0.254: v2(27.76,55.46) 27.64,55.59 27.54,55.59 27.38,55.75 PR231.1 ; PU202.7 11.43,20.95 10.88,20.41 PC216.1 10.31,20.75 PR251.1 8.9,21.6 8.38,21.08 v2(8.38,21) 8.33,20.95 PQ230.2 ; PR209.1 22.78,101.86 23.27,101.38 25.19,101.38 25.68,100.88 25.68,99.9 25.01,99.23 25.01,97.61 PR228.1 24.36,97.24 23.85,96.73 v2(23.85,96.53)
DCIN_ACOK#: length 117.4
  TOP w0.14: PU204.2 7.88,11.76 7.96,11.67 7.96,10.58 PR283.1 8.5,9.86 v2(8.95,9.41) ; v1(27.57,100.78) 27.78,100.58 v2(27.78,99.51)
  TOP w0.254: v2(8.36,21.82) 8.48,21.94 PR252.1
  IN3 w0.091: v2(8.95,9.41) 8.95,12.85 8.13,13.68 8.13,15.99 8.75,16.6 8.75,17.38 8.55,17.59 8.55,18.32 8.71,18.49 8.71,19.87 7.62,20.96 7.62,21.47 7.97,21.82 v2(8.36,21.82)
  IN5 w0.099: v2(8.36,21.82) 9.66,21.82 9.93,21.55 12.49,21.55 16.29,25.34 16.29,25.66 17.68,27.05 17.68,31.23 19.04,32.58 19.04,38.13 15.71,41.45 15.71,43.42 17.26,44.97 17.26,63.4 18.96,65.1 18.96,76.43 19.34,76.81 19.34,78.85 19.94,79.45 19.94,93.43 21.95,95.44 23.7,95.44 v2(27.78,99.51)
  BOTTOM w0.254: v2(27.78,99.51) 28.26,100 PR235.1 28.27,100.12 PR268.1 ; PQ228.2 8.69,23.48 8.84,23.33 8.84,22.3 v2(8.36,21.82) 7.98,21.82 7.68,21.52 PQ230.1
DDC_CLK_HDMI: length 15.1
  IN3 w0.091: v2(18.54,92.67) 18.02,92.67 17.59,93.1 15.88,93.1 15.38,92.61 15.38,91.28 14.06,89.96 14.06,89.25 13.63,88.82 12.61,88.82 12.36,89.07 11.52,89.07 11.21,88.76 11.21,88.44 11.32,88.05 11.32,87.71 11.23,87.55 11.23,87.33 11.34,87.09 11.38,87.01 11.38,86.8 11.75,86.43 JHDMI1.15
  BOTTOM w0.127: v2(18.54,92.67) RV124.1
  BOTTOM w0.14: RV124.1 18.07,91.56 QX1.6
DDC_DAT_HDMI: length 15.2
  IN3 w0.091: v2(14.07,92.03) 13.59,92.03 13.49,92.13 13.49,92.78 13.68,92.97 14.99,92.97 15.16,92.8 15.16,91.37 13.84,90.05 13.84,89.35 13.53,89.04 12.7,89.04 12.45,89.29 11.43,89.29 10.99,88.85 10.99,88.41 11.1,88.02 11.1,87.77 11.01,87.6 11.01,87.28 11.14,87 11.16,86.96 11.16,86.75 11.07,86.66 10.84,86.66 JHDMI1.16
  BOTTOM w0.127: v2(14.07,92.03) RV125.1
  BOTTOM w0.14: QX1.3 15.56,92.86 RV125.1
DDI1_CPU_AUXN: length 193.1
  TOP w0.17: v2(36,44.56) 35.9,44.46 35.56,44.46 35.18,44.08 35.18,41.51 34.95,41.28 34.02,41.28 CT26.2
  IN3 w0.089: 141.11,78.88 141.11,78.89 141.09,78.9 141.09,79.98 142,80.88 144.16,80.88 144.33,80.71 147.88,80.71 148,80.83 172.53,80.83 173.09,80.27 173.09,80.09 174.22,78.96 174.76,78.96 v2(175.13,78.59)
  IN3 w0.112: 141.11,78.88 141.11,77.15 140.4,76.44 138.24,76.44 137.98,76.19 137.98,71.76 135.14,68.92 135.14,65.99 134.66,65.51 134.66,57.11 106.5,28.94 96.13,28.94 95.63,29.44 88.04,29.44 86.68,28.08 80.33,28.08 79.31,27.05 74.88,27.05 73.46,25.63 58.04,25.63 57.15,26.52 56.38,26.52 55.97,26.93 55.65,26.93 55.64,26.94 49.75,26.94 48.45,28.23 46.72,28.23 42.45,32.5 40.47,32.5 37.12,35.86 37.12,37.28 35.26,39.14 35.26,44.15 35.55,44.45 35.88,44.45 v2(36,44.56)
  BOTTOM w0.076: UH1.E27 175.48,78.94 v2(175.13,78.59)
DDI1_CPU_AUXN_C: length 4.4
  TOP w0.089: CT26.1 33.35,41.33 32.15,41.33 31.55,41.93 30.94,41.93 30.79,42.08 30.4,42.08 v2(29.96,41.64)
  BOTTOM w0.102: UT1.W11 30.07,41.53 v2(29.96,41.64)
DDI1_CPU_AUXP: length 193.1
  TOP w0.17: CT25.2 34.02,40.85 35.13,40.85 35.61,41.33 35.61,43.9 35.74,44.03 35.95,44.03 v2(36,43.98)
  IN3 w0.089: 140.86,78.88 140.86,78.89 140.87,78.9 140.87,80.07 141.91,81.11 144.25,81.11 144.42,80.93 147.79,80.93 147.91,81.06 172.62,81.06 173.31,80.37 173.31,80.18 174.31,79.19 174.85,79.19 175.08,78.95 175.36,78.95 175.72,78.59 v2(175.78,78.59)
  IN3 w0.112: v2(36,43.98) 36,44 35.79,44.2 35.65,44.2 35.5,44.05 35.5,39.24 37.36,37.38 37.36,35.96 40.57,32.75 42.56,32.75 46.82,28.48 48.55,28.48 49.85,27.19 55.54,27.19 56.06,27.19 56.49,26.77 57.26,26.77 58.14,25.88 73.35,25.88 74.78,27.3 79.2,27.3 80.23,28.33 86.58,28.33 87.94,29.69 95.73,29.69 96.23,29.19 106.4,29.19 134.42,57.21 134.42,65.62 134.89,66.09 134.89,69.02 137.74,71.86 137.74,76.29 138.13,76.69 140.29,76.69 140.86,77.25 140.86,78.88
  BOTTOM w0.076: UH1.D27 176.01,79.01 175.78,78.79 v2(175.78,78.59)
DDI1_CPU_AUXP_C: length 4.3
  TOP w0.089: CT25.1 33.16,40.98 v4(32.49,40.98) 32.07,40.98 31.87,41.18 31.68,41.18 31.59,41.27 31.59,41.46 31.47,41.58 31.29,41.58 31.23,41.51 31.23,41.29 31.13,41.19 31,41.19 30.9,41.29 30.9,41.58 30.83,41.64 v2(30.61,41.64)
  BOTTOM w0.102: v2(30.61,41.64) UT1.Y11
DDI1_DDPB_CTRLCLK: length 102.9
  TOP w0.089: RP1.3 100.42,7 99.34,5.91 99.34,5.04 v3(99.29,4.99) 99.23,4.93 97.47,4.93 v2(96.9,5.5)
  IN3 w0.089: v2(96.9,5.5) 96.67,5.72 95.78,5.72 95.34,5.28 92.73,5.28 92.16,4.71 91.64,4.71 91.47,4.88 90.89,4.88 90,5.77 89.43,5.77 88.95,5.3 88.12,5.3 87.89,5.53 86.73,5.53 86.56,5.35 85.82,5.35 85.61,5.56 84.52,5.56 84.11,5.15 83.52,5.15 83.02,5.65 82.49,5.65 81.79,4.95 79.48,4.95 79.18,4.66 78.27,4.66 77.65,5.28 77.65,5.83 77.09,6.38 76.04,6.38 75.31,5.66 75.06,5.66
  IN3 w0.112: 75.06,5.66 72,5.66 71.72,5.38 71.37,5.38 69.72,5.38 68.07,7.03 68.07,8.8 66.65,10.22 64.72,10.22 63.7,11.24 63.7,15.05 63.69,15.06 63.69,15.06 62.53,16.22 62.53,17.7 61.75,18.48 61.75,19.06 59.44,21.37 59.44,21.85 58.58,22.7 57,22.7 56.11,23.6 54.48,23.6 54.18,23.3 53.36,23.3 53.16,23.5 51.08,23.5 50.32,24.26 47.87,24.26 47.27,24.86 46.18,24.86 45.55,24.23 44.29,24.23 43.84,24.67 43.84,26.04 42.88,27.01 42.88,27.74 42.38,28.24 41.2,28.24 39.7,29.74 39.33,29.74 37.65,31.42 37.65,32.1 32.98,36.77 32.98,40.7 32.27,41.41 32.27,43.08 31.12,44.23 v2(30.6,44.23)
  BOTTOM w0.089: UH2.BA5 97.24,5.84 v2(96.9,5.5)
  BOTTOM w0.102: v2(30.6,44.23) 30.6,44.21 30.89,43.92 UT1.Y5
DDI1_DDPB_CTRLDAT: length 114.8
  TOP w0.089: RP1.4 100.37,6.5 99.61,5.74 99.61,4.85 99.01,4.25 v3(98.2,4.25) 98.08,4.25 v2(97.77,4.57)
  IN3 w0.089: 27.71,34.3 27.71,35.26 26.93,36.04 23.34,36.04 22.32,37.06 22.32,41.05 23.82,42.54 25.6,42.54 27.3,44.24 v2(28.01,44.24) ; 75.06,3.43 75.52,3.43 76.04,3.95 79.48,3.95 79.77,4.24 85.52,4.24 85.83,4.56 86.73,4.56 87.04,4.24 88.22,4.24 88.41,4.43 89.96,4.43 90.1,4.43 90.36,4.17 91.17,4.17 91.34,4 92.46,4 92.72,4.26 92.87,4.26 97.46,4.26 v2(97.77,4.57)
  IN3 w0.112: 75.06,3.43 73.46,3.43 73.32,3.56 70.67,3.56 70.1,2.98 69.22,2.98 68.74,3.46 66.68,3.46 65.35,4.79 64.49,4.79 61.27,8.01 61.27,14.38 58.85,16.8 58.01,16.8 57.12,17.69 57.12,17.89 54.17,20.84 53.28,20.84 52.28,21.84 50.39,21.84 50.06,22.16 47.29,22.16 46.94,22.51 43.61,22.51 42.18,23.95 42.18,25.29 40.9,26.57 40.51,26.57 39.01,28.08 37.39,28.08 37.11,28.36 37.11,29 36.21,29.89 36.06,29.89 34.78,31.17 30.33,31.17 30.1,31.41 27.93,31.41 27.42,31.92 27.42,32.84 27.71,33.13 27.71,34.3
  BOTTOM w0.089: UH2.BC4 97.81,4.61 v2(97.77,4.57)
  BOTTOM w0.102: UT1.R4 v2(28.01,44.24)
DDI1_HTX_TBRX_N0: length 195.4
  IN3 w0.112: v2(36.87,42.74) 37.14,43 37.33,43 37.83,42.51 37.83,38.63 38.44,38.02 38.44,36.52 39.41,35.56 40.04,35.56 41.25,34.35 42.48,34.35 47.27,29.56 49.02,29.56 50.23,28.35 56.47,28.35 56.78,28.05 56.92,27.91 60.16,27.91 60.48,27.58 66.05,27.58 66.52,28.05 69.44,28.05 70.21,27.28 73.15,27.28 74.25,28.38 78.72,28.38 78.82,28.49 79.9,29.56 86.2,29.56 87.53,30.9 96.84,30.9 97.37,30.36 105.25,30.36 132.56,57.67 132.56,65.36 131.57,66.35 131.57,68.35 130.68,69.24 130.68,79.87 132.11,81.29 132.11,82.15 135.69,85.74 135.69,88.18 137.24,89.73 163.7,89.73 164.45,88.97 169.18,88.97 169.94,88.21 170.43,88.21 171.11,87.52 171.72,87.52 v2(171.88,87.37)
  BOTTOM w0.076: UH1.K37 172.33,85.4 172.39,85.34 172.55,85.34 172.65,85.43 172.65,86.69 172.29,87.05 172.29,87.49 172.13,87.64 172.07,87.64 172.04,87.6 171.96,87.6 171.88,87.52 v2(171.88,87.37)
  BOTTOM w0.17: CT18.2 35.35,42.36 35.42,42.44 36.39,42.44 36.69,42.74 v2(36.87,42.74)
DDI1_HTX_TBRX_N0_C: length 3.4
  BOTTOM w0.089: UT1.AC7 32.01,42.97 31.95,42.91 31.95,42.85 32.07,42.73 32.31,42.73 32.44,42.86 33.14,42.86 33.5,42.49 33.66,42.49
  BOTTOM w0.17: 33.66,42.49 v3(33.85,42.49) 34.51,42.49 CT18.1
DDI1_HTX_TBRX_N1: length 194.7
  IN3 w0.112: v2(172.73,83.45) 172.36,83.82 172.36,83.94 172.36,83.94 172.36,84.25 172.36,84.25 172.49,84.38 172.49,84.5 172.4,84.58 171.86,84.58 170.72,85.72 170.72,86.6 169.1,88.23 163.95,88.23 163.18,88.99 137.52,88.99 136.39,87.86 136.39,84.46 135.08,83.14 135.08,80.96 133.05,78.93 133.05,78.24 131.49,76.69 131.49,69.62 133.5,67.61 133.5,57.67 105.53,29.7 96.96,29.7 96.46,30.2 87.77,30.2 86.47,28.9 80.17,28.9 79.13,27.86 78.99,27.72 74.6,27.72 73.5,26.62 69.93,26.62 69.16,27.39 66.79,27.39 66.33,26.92 60.1,26.92 59.84,27.18 56.66,27.18 56.15,27.69 49.96,27.69 48.75,28.9 47,28.9 42.21,33.69 40.97,33.69 39.79,34.87 39.16,34.87 37.78,36.25 37.78,37.57 36.29,39.06 36.29,41.05 36.73,41.49 37.16,41.49 v2(37.3,41.63)
  BOTTOM w0.076: v2(172.73,83.45) 173.05,83.76 UH1.J34
  BOTTOM w0.17: CT20.2 36.69,41.63 v2(37.3,41.63)
DDI1_HTX_TBRX_N1_C: length 4.6
  BOTTOM w0.089: UT1.AC9 32.01,42.05 31.94,42.12 31.94,42.21 32.02,42.28 32.33,42.28 32.97,41.64 33.66,41.64
  BOTTOM w0.17: CT20.1 35.79,41.64 33.66,41.64
DDI1_HTX_TBRX_N2: length 189.4
  IN3 w0.112: v2(38.97,41.31) 39.2,41.07 39.41,41.07 39.69,40.79 39.69,39.75 40.04,39.39 40.04,37.83 41.96,35.92 43.15,35.92 47.88,31.19 49.63,31.19 50.82,30 50.89,29.93 69.79,29.93 70.45,29.26 72.91,29.26 73.6,29.95 74.96,29.95 78.05,29.95 79.3,31.2 85.55,31.2 86.89,32.55 97.12,32.55 104.87,40.29 104.87,41.15 115.38,51.66 116.69,51.66 121.98,56.96 121.98,61.54 122.77,62.33 123.48,62.33 128.2,67.05 128.2,80.3 130.25,82.35 130.25,82.7 134.18,86.64 134.18,88.99 136.63,91.44 155.06,91.44 155.54,91.92 164.08,91.92 164.93,91.07 170.37,91.07 171.87,89.57 173.32,89.57 173.66,89.23 173.66,88.94 v2(173.8,88.81)
  BOTTOM w0.076: v2(173.8,88.81) 173.75,88.77 173.75,88.45 173.99,88.21 173.99,86.07 174.22,85.84 174.22,85.38 UH1.H36
  BOTTOM w0.17: v2(38.97,41.31) 38.89,41.23 38.23,41.23 37.53,40.54 36.57,40.54 36.43,40.68 35.44,40.68 CT22.2
DDI1_HTX_TBRX_N2_C: length 3.5
  BOTTOM w0.089: 32.42,41.26 32.32,41.36 32.02,41.36 31.94,41.29 31.94,41.2 32.01,41.13 UT1.AC11
  BOTTOM w0.102: 33.66,40.64 33.64,40.64 33.61,40.6 33.4,40.6 33.06,40.94 32.74,40.94 32.42,41.26
  BOTTOM w0.17: 33.66,40.64 v3(33.91,40.64) 34.62,40.64 CT22.1
DDI1_HTX_TBRX_N3: length 190.9
  IN3 w0.112: v2(172.41,88.95) 172.19,88.72 171.75,88.72 171.32,89.15 170.18,89.15 169.4,89.92 165.01,89.92 163.69,91.25 155.87,91.25 155.4,90.78 136.96,90.78 134.81,88.62 134.81,86.21 131.07,82.48 131.07,81.61 129.15,79.69 129.15,66.24 131.53,63.86 131.53,58.12 104.72,31.32 98.36,31.32 97.84,31.84 87.18,31.84 85.88,30.54 79.59,30.54 78.34,29.29 73.87,29.29 72.77,28.19 70.59,28.19 69.81,28.96 66.14,28.96 65.68,28.5 64.22,28.5 63.46,29.26 50.61,29.26 50.54,29.33 49.35,30.52 47.61,30.52 42.87,35.26 41.64,35.26 40.4,36.5 39.75,36.5 39.35,36.9 39.35,39.12 39.04,39.43 38.82,39.43 v2(38.63,39.62)
  BOTTOM w0.076: UH1.J38 173.28,86.46 173.28,86.98 173.41,87.12 173.41,87.97 172.96,88.43 172.87,88.43 172.72,88.58 172.72,88.64 v2(172.41,88.95)
  BOTTOM w0.17: CT24.2 36.84,39.55 38.56,39.55 v2(38.63,39.62)
DDI1_HTX_TBRX_N3_C: length 5
  BOTTOM w0.102: UT1.AC13 32.01,40.21 31.94,40.28 31.94,40.37 32.02,40.44 32.37,40.44 32.48,40.34 32.73,40.34 33.57,39.49 33.66,39.49
  BOTTOM w0.17: 33.66,39.49 36.03,39.49 CT24.1
DDI1_HTX_TBRX_P0: length 195.4
  IN3 w0.112: v2(171.88,87.95) 171.7,87.77 171.21,87.77 170.53,88.46 170.05,88.46 169.28,89.22 164.55,89.22 163.8,89.98 137.13,89.98 135.44,88.28 135.44,85.84 131.86,82.26 131.86,81.39 130.44,79.97 130.44,69.14 131.33,68.25 131.33,66.25 132.32,65.26 132.32,57.78 105.15,30.61 97.47,30.61 96.94,31.14 87.43,31.14 86.1,29.81 79.79,29.81 78.61,28.63 74.15,28.63 73.05,27.53 70.31,27.53 69.54,28.3 66.42,28.3 65.95,27.83 60.58,27.83 60.26,28.15 57.02,28.15 56.58,28.6 50.33,28.6 49.13,29.81 47.37,29.81 42.58,34.6 41.35,34.6 40.15,35.8 39.51,35.8 38.69,36.62 38.69,38.12 38.08,38.74 38.08,42.61 37.43,43.25 36.94,43.25 v2(36.87,43.32)
  BOTTOM w0.076: UH1.K36 172.41,85.15 172.62,85.15 172.83,85.36 172.83,86.84 172.5,87.17 172.5,87.56 172.11,87.95 v2(171.88,87.95)
  BOTTOM w0.17: v2(36.87,43.32) 36.72,43.17 36.51,43.17 36.21,42.87 CT17.2
DDI1_HTX_TBRX_P0_C: length 3.4
  BOTTOM w0.089: UT1.AB7 31.86,43.2 32.41,43.2 32.57,43.04 33.21,43.04 33.38,42.87 33.66,42.87
  BOTTOM w0.17: 33.66,42.87 CT17.1
DDI1_HTX_TBRX_P1: length 194.7
  IN3 w0.112: v2(172.73,84.1) 173.02,83.81 173.2,83.81 173.29,83.9 173.29,84.21 172.91,84.59 172.74,84.59 172.5,84.83 171.96,84.83 170.97,85.82 170.97,86.71 169.2,88.48 164.05,88.48 163.29,89.24 137.42,89.24 136.15,87.96 136.15,84.56 134.83,83.25 134.83,81.06 132.8,79.03 132.8,78.34 131.24,76.79 131.24,69.52 133.25,67.51 133.25,57.78 105.43,29.95 97.06,29.95 96.57,30.44 87.67,30.44 86.37,29.14 80.07,29.14 78.89,27.96 74.5,27.96 73.4,26.86 70.04,26.86 69.26,27.63 66.69,27.63 66.22,27.17 60.21,27.17 59.95,27.43 56.76,27.43 56.25,27.94 50.06,27.94 48.85,29.14 47.1,29.14 42.31,33.93 41.07,33.93 39.9,35.11 39.26,35.11 38.03,36.35 38.03,37.67 36.53,39.16 36.53,40.95 36.83,41.24 37.11,41.24 v2(37.31,41.04)
  BOTTOM w0.076: UH1.J35 173.05,84.41 v2(172.73,84.1)
  BOTTOM w0.17: CT19.2 37.2,41.16 v2(37.31,41.04)
DDI1_HTX_TBRX_P1_C: length 4.7
  BOTTOM w0.102: 33.66,41.25 32.93,41.25 32.36,41.82 31.86,41.82 UT1.AB9
  BOTTOM w0.17: CT19.1 35.85,41.25 33.66,41.25
DDI1_HTX_TBRX_P2: length 189.4
  IN3 w0.112: v2(173.09,88.8) 173.16,88.72 173.29,88.72 173.42,88.85 173.42,89.13 173.22,89.32 171.77,89.32 170.26,90.83 164.82,90.83 163.98,91.67 155.64,91.67 155.16,91.19 136.73,91.19 134.43,88.89 134.43,86.53 130.49,82.6 130.49,82.24 128.45,80.2 128.45,66.94 123.59,62.08 122.87,62.08 122.23,61.44 122.23,56.85 116.79,51.42 115.48,51.42 105.11,41.04 105.11,40.19 97.23,32.3 86.99,32.3 85.79,31.1 85.65,30.96 79.4,30.96 78.15,29.71 74.86,29.71 73.7,29.71 73.01,29.02 70.35,29.02 69.69,29.68 50.79,29.68 50.64,29.82 50.64,29.82 49.52,30.94 47.78,30.94 43.04,35.68 41.85,35.68 39.8,37.73 39.8,39.29 39.44,39.65 39.44,40.69 39.31,40.83 39.07,40.83 v2(38.97,40.73)
  BOTTOM w0.076: UH1.H37 173.69,85.51 173.56,85.51 173.48,85.58 173.48,85.76 173.66,85.94 173.66,88.07 173.42,88.31 173.42,88.68 173.3,88.8 v2(173.09,88.8)
  BOTTOM w0.17: v2(38.97,40.73) 38.89,40.8 38.41,40.8 37.71,40.11 36.39,40.11 36.25,40.25 35.45,40.25 CT21.2
DDI1_HTX_TBRX_P2_C: length 3.5
  BOTTOM w0.102: 33.66,40.2 33.45,40.2 32.92,40.74 32.42,40.74 32.26,40.9 31.86,40.9 UT1.AB11
  BOTTOM w0.17: CT21.1 34.7,40.2 33.66,40.2
DDI1_HTX_TBRX_P3: length 190.9
  IN3 w0.112: v2(38.63,39.04) 38.78,39.19 38.94,39.19 39.11,39.02 39.11,36.8 39.65,36.26 40.3,36.26 41.54,35.01 42.77,35.01 47.5,30.28 49.25,30.28 50.36,29.16 50.51,29.02 63.36,29.02 64.12,28.25 65.78,28.25 66.24,28.71 69.71,28.71 70.48,27.94 72.88,27.94 73.98,29.04 78.44,29.04 78.55,29.15 79.69,30.3 85.98,30.3 87.28,31.59 97.73,31.59 98.26,31.07 104.83,31.07 131.78,58.02 131.78,63.97 129.4,66.34 129.4,79.59 131.32,81.5 131.32,82.37 135.05,86.11 135.05,88.52 137.06,90.53 155.5,90.53 155.97,91 163.59,91 164.91,89.68 169.3,89.68 170.08,88.9 171.22,88.9 171.65,88.48 172.3,88.48 v2(172.4,88.38)
  BOTTOM w0.076: v2(172.4,88.38) 172.64,88.38 172.77,88.25 172.88,88.25 173.23,87.91 173.23,87.21 173.08,87.06 173.08,86.24 173.12,86.2 UH1.J37
  BOTTOM w0.17: v2(38.63,39.04) 38.56,39.12 36.81,39.12 CT23.2
DDI1_HTX_TBRX_P3_C: length 5
  BOTTOM w0.102: UT1.AB13 31.86,39.98 32.57,39.98 33.42,39.13 33.46,39.13 33.49,39.1 33.61,39.1 33.64,39.06 33.66,39.06
  BOTTOM w0.17: CT23.1 v3(33.91,39.06) 33.66,39.06
DDI1_PCH_HPD: length 100.5
  IN3 w0.089: v2(97.74,7.15) 97.74,6.87 97.3,6.42 96.81,6.42 96.29,5.9 95.71,5.9 95.27,5.46 92.25,5.46 92.18,5.53 91.01,5.53 90.95,5.48 90.59,5.48 90.11,5.95 89.35,5.95 88.88,5.48 88.2,5.48 87.97,5.7 86.66,5.7 86.48,5.53 85.9,5.53 85.69,5.74 84.44,5.74 84.04,5.33 83.59,5.33 82.71,6.21 79.74,6.21 79.31,6.64 78.6,6.64 78.41,6.83 75.72,6.83 75.06,6.17
  IN3 w0.112: v2(38.24,31.43) 38.32,31.43 39.59,30.16 39.87,30.16 41.37,28.66 42.55,28.66 43.46,27.75 43.46,27.04 45.07,25.43 47.28,25.43 48.04,24.67 50.5,24.67 51.25,23.92 53.33,23.92 53.53,23.72 54.01,23.72 54.3,24.01 56.35,24.01 57.24,23.12 59.02,23.12 60.39,21.75 60.39,21.64 62.17,19.86 62.17,18.75 64.14,16.79 64.14,11.41 64.85,10.7 66.76,10.7 68.49,8.97 68.49,7.2 69.89,5.8 71.55,5.8 71.83,6.08 74.97,6.08 75.06,6.17
  IN5 w0.089: 33.66,43.7 33.24,44.12 32.31,44.12 32.03,44.4 32.03,45.68 32.41,46.06 v2(32.64,46.06)
  IN5 w0.119: 33.66,43.7 34.98,42.37 34.98,40.42 38.24,37.17 v2(38.24,31.43)
  BOTTOM w0.089: UH2.AW4 97.95,6.93 v2(97.74,7.15) ; UT1.AA2 31.41,45.51 31.41,45.89 31.54,46.02 32.6,46.02 v2(32.64,46.06) 32.82,46.24 33.57,46.24 33.66,46.33
  BOTTOM w0.17: RT41.2 33.66,46.33
DDI2_CPU_AUXN: length 186.5
  TOP w0.17: CT107.2 34.09,39.71 34.44,39.71 v4(34.89,39.26) 35.26,38.89 35.26,37.29 35.35,37.21 35.35,37.11 v2(35.19,36.95)
  IN3 w0.089: 141.77,78.96 141.77,78.97 141.75,78.98 141.75,79.79 142.42,80.46 143.73,80.46 144.61,79.57 169.85,79.57 170.48,80.21 172.2,80.21 172.76,79.65 172.76,79.45 174.23,77.99 174.23,77.8 174.51,77.51 174.98,77.51 175.06,77.43 175.29,77.43 175.71,77.85 v2(175.8,77.85)
  IN3 w0.112: v2(35.19,36.95) 35.29,37.05 35.56,37.05 35.8,36.82 35.8,36.23 40.2,31.83 42.19,31.83 46.49,27.53 48.18,27.53 49.44,26.28 51.82,26.28 52.32,25.78 56.95,25.78 57.76,24.97 78.85,24.97 79.35,25.47 83.03,25.47 83.42,25.85 84.69,25.85 86.09,27.26 86.8,27.26 88.28,28.74 95.25,28.74 95.71,28.28 106.77,28.28 135.15,56.66 135.46,56.66 137.7,58.89 137.7,65.05 137.35,65.39 137.35,68.8 138.5,69.95 139.32,69.95 141.77,72.39 141.77,78.96
  BOTTOM w0.076: UH1.E26 175.48,78.03 175.67,77.85 v2(175.8,77.85)
DDI2_CPU_AUXN_C: length 4.5
  TOP w0.089: CT107.1 33.22,39.71 v4(32.27,39.71) 31.9,39.71 31.71,39.9 31.16,39.9 30.83,40.23 30.56,40.23 29.96,40.84 v2(29.96,40.99)
  BOTTOM w0.102: v2(29.96,40.99) UT1.W12
DDI2_CPU_AUXP: length 186.5
  TOP w0.17: v2(35.73,37.44) 35.7,37.46 35.7,39.06 35.19,39.57 34.62,40.14 CT108.2
  IN3 w0.089: 141.52,78.96 141.52,78.97 141.53,78.98 141.53,79.88 142.33,80.68 143.82,80.68 144.7,79.8 169.75,79.8 170.39,80.43 172.29,80.43 172.99,79.74 172.99,79.54 174.45,78.08 174.45,77.89 174.6,77.74 174.73,77.74 174.79,77.8 174.79,78.13 174.89,78.23 175.4,78.23 175.47,78.16 175.47,77.98 175.31,77.82 v2(175.17,77.82)
  IN3 w0.112: v2(35.73,37.44) 35.73,37.24 36.04,36.92 36.04,36.33 40.3,32.08 42.29,32.08 46.59,27.78 48.29,27.78 49.54,26.52 51.92,26.52 52.42,26.03 57.06,26.03 57.87,25.22 78.75,25.22 79.24,25.71 82.93,25.71 83.31,26.09 84.58,26.09 85.99,27.5 86.7,27.5 88.18,28.99 95.35,28.99 95.81,28.53 106.67,28.53 135.05,56.9 135.36,56.9 137.45,58.99 137.45,64.94 137.11,65.29 137.11,68.9 138.4,70.19 139.22,70.19 141.52,72.5 141.52,78.96
  BOTTOM w0.076: v2(175.17,77.82) 174.83,78.16 UH1.F26
DDI2_CPU_AUXP_C: length 4.6
  TOP w0.089: v2(30.61,40.99) 30.49,40.88 30.49,40.79 30.7,40.59 30.79,40.59 v4(30.94,40.74) 31.09,40.89 31.19,40.89 31.29,40.79 31.29,40.66 31.15,40.52 31.15,40.4 31.31,40.25 31.86,40.25 32.05,40.06 33.28,40.06 CT108.1
  BOTTOM w0.102: v2(30.61,40.99) UT1.Y12
DDI2_DDPC_CTRLCLK: length 99.1
  TOP w0.089: RP1.1 100.36,8 100.23,7.87 100.23,7.78 v3(99.29,6.84) 98.64,6.19 v2(98.39,6.19)
  IN3 w0.089: v2(98.39,6.19) 98.39,5.4 98.07,5.08 97.54,5.08 96.91,4.44 92.94,4.44 92.94,4.44 92.65,4.44 92.38,4.17 91.42,4.17 91.25,4.35 90.44,4.35 90.3,4.48 90.18,4.61 89.88,4.61 88.27,4.61 88.08,4.42 87.12,4.42 86.8,4.73 85.76,4.73 85.45,4.42 79.7,4.42 79.4,4.12 76.03,4.12 75.74,4.41 75.06,4.41
  IN3 w0.112: v5(31.24,42.29) 31.24,41.59 32.39,40.44 32.39,33.3 33.16,32.54 34.01,32.54 36.17,30.37 36.92,30.37 38.8,28.49 39.18,28.49 40.68,26.99 41.07,26.99 42.59,25.47 42.59,24.12 43.78,22.93 47.12,22.93 47.47,22.58 50.23,22.58 50.56,22.25 52.64,22.25 52.84,22.05 54.12,22.05 54.68,21.5 54.78,21.5 57.53,18.74 57.53,17.87 58.18,17.21 59.21,17.21 61.68,14.74 61.68,8.53 65,5.21 68.13,5.21 69.2,4.13 70.86,4.13 72.1,4.13 72.22,4 72.94,4 73.35,4.41 75.06,4.41
  BOTTOM w0.089: v2(98.39,6.19) 98.68,5.9 UH2.BB3
  BOTTOM w0.102: UT1.Y8 30.93,42.62 31.24,42.31 v5(31.24,42.29)
DDI2_DDPC_CTRLDAT: length 102.9
  TOP w0.089: v2(97.69,5.51) 97.9,5.71 v3(98.22,5.71) 98.66,5.71 100.44,7.5 RP1.2
  IN3 w0.089: 75.06,4.83 75.67,4.83 76.2,4.3 79.33,4.3 79.62,4.6 85.37,4.6 85.69,4.91 86.88,4.91 87.19,4.6 87.94,4.6 88.13,4.78 89.81,4.78 90.29,4.78 90.55,4.52 91.32,4.52 91.49,4.35 92.31,4.35 92.58,4.62 93.02,4.62 93.02,4.62 96.84,4.62 97.69,5.47 v2(97.69,5.51)
  IN3 w0.112: 75.06,4.83 72.35,4.83 72.07,4.55 71.03,4.55 69.38,4.55 68.3,5.62 66.02,5.62 63.73,7.92 63.73,8.24 63.63,8.34 63.63,10.09 62.85,10.87 62.85,14.68 60.54,16.99 60.54,17.94 57.43,21.05 56.43,21.05 55.57,21.91 54.85,21.91 54.29,22.47 53.01,22.47 52.81,22.67 50.73,22.67 50.4,23 47.64,23 47.29,23.35 43.99,23.35 43.01,24.33 43.01,25.69 41.3,27.41 40.86,27.41 39.35,28.91 38.98,28.91 37.1,30.79 36.34,30.79 33.86,33.27 33.86,33.41 32.59,34.68 32.59,40.53 31.62,41.49 31.62,42.42 31.37,42.67 29.6,42.67 28.66,43.61 v2(27.36,43.61)
  BOTTOM w0.089: v2(97.69,5.51) 97.22,5.04 UH2.BD6
  BOTTOM w0.102: UT1.N4 27.36,44.24 27.36,43.61 v2(27.36,43.61)
DDI2_HTX_TBRX_N0: length 190.6
  IN3 w0.112: v2(40.84,38.5) 41.05,38.3 41.42,38.3 43.03,36.68 43.46,36.68 45.32,34.81 46.05,34.81 46.93,33.93 46.93,33.21 47.3,32.84 48.54,32.84 49.53,31.85 52.14,31.85 53.37,30.62 70.07,30.62 70.77,29.92 72.63,29.92 73.33,30.62 75.24,30.62 77.77,30.62 78.16,31 79.02,31.87 85.26,31.87 86.6,33.21 96.85,33.21 104.2,40.57 104.2,41.42 115.12,52.33 116.42,52.33 121.32,57.24 121.32,61.85 122.46,63 123.19,63 125.57,65.38 125.57,69.87 127.47,71.76 127.47,80.6 128.7,81.83 128.7,83.89 129.16,84.35 130.2,84.35 133.5,87.65 133.5,89.27 136.36,92.14 154.81,92.14 155.27,92.59 164.51,92.59 165.28,91.82 170.56,91.82 172.15,90.23 173.73,90.23 174.42,89.55 174.42,88.48 173.83,87.9 173.83,84.01 174.18,83.66 174.18,83.58 v2(174.35,83.42)
  BOTTOM w0.076: UH1.H33 174.04,83.11 v2(174.35,83.42)
  BOTTOM w0.17: CT30.2 35.45,38.45 40.79,38.45 v2(40.84,38.5)
DDI2_HTX_TBRX_N0_C: length 3.7
  BOTTOM w0.102: 33.57,38.48 33.37,38.48 32.49,39.36 32.49,39.41 32.37,39.52 32.02,39.52 31.94,39.45 31.94,39.36 32.01,39.29 UT1.AC15
  BOTTOM w0.17: CT30.1 34.63,38.43 34.36,38.43 34.3,38.48 33.57,38.48
DDI2_HTX_TBRX_N1: length 190.3
  IN3 w0.112: v2(176.88,88.82) 176.88,88.6 176.79,88.52 176.63,88.52 176.48,88.67 176.48,91.37 176.72,91.61 176.72,92.62 176.03,93.31 174.2,93.31 173.63,93.88 171.88,93.88 171.01,94.75 154.6,94.75 154.15,94.31 136.44,94.31 136,94.75 134.17,94.75 129.26,89.84 129.26,88.48 125.31,84.52 125.31,72.83 123.51,71.04 123.51,68.34 118.31,63.13 118.31,58.34 102.02,42.05 102.02,41.19 96.02,35.2 85.45,35.2 84.1,33.86 78.1,33.86 77.62,33.38 75.46,33.38 75.14,33.06 54.51,33.06 53.65,33.92 52.21,33.92 51.69,34.44 50.62,34.44 50.1,34.96 48.79,34.96 v2(48.59,35.16)
  BOTTOM w0.076: v2(176.88,88.82) 176.69,88.63 175.44,88.63 174.41,87.61 174.41,86.88 174.2,86.67 174.2,86.48 174.32,86.36 UH1.G38
  BOTTOM w0.17: CT32.2 36.86,36.56 37.7,36.56 38.04,36.22 43.8,36.22 45.24,34.78 47.67,34.78 47.98,35.09 48.52,35.09 v2(48.59,35.16)
DDI2_HTX_TBRX_N1_C: length 5.6
  BOTTOM w0.102: 33.66,37.58 33.22,37.58 32.49,38.31 32.49,38.49 32.37,38.6 32.02,38.6 31.94,38.53 31.94,38.44 32.01,38.37 UT1.AC17
  BOTTOM w0.17: 33.66,37.58 v3(33.88,37.58) 33.88,37.57 34.96,36.5 36.01,36.5 CT32.1
DDI2_HTX_TBRX_N2: length 187.5
  IN3 w0.112: v2(175.08,84.11) 174.93,84.26 174.93,84.82 174.55,85.2 174.55,87.58 175.11,88.14 175.11,89.87 174.08,90.89 172.59,90.89 171.39,92.1 171.39,92.43 170.46,93.35 155.08,93.35 154.58,92.85 136.05,92.85 132.81,89.6 132.81,89.19 129.14,85.53 128.19,85.53 126.77,84.11 126.77,83.08 127.17,82.68 127.17,81.26 126.75,80.83 126.75,72.05 124.9,70.2 124.9,66.43 123.49,65.02 123.06,65.02 120.66,62.61 120.66,58.81 103.47,41.62 103.47,40.77 96.57,33.87 86.17,33.87 84.82,32.53 78.75,32.53 77.5,31.28 76.08,31.28 76.08,31.28 75.85,31.28 75.85,31.28 75.51,31.28 75.51,31.28 74.24,31.28 73.8,31.71 73.6,31.71 71.81,31.71 71.38,31.28 70.35,31.28 70.35,31.28 69.59,31.28 69.59,31.28 53.67,31.28 52.36,32.59 49.72,32.59 48.73,33.59 48.11,33.59 47.98,33.71 47.65,33.71 v2(47.5,33.87)
  BOTTOM w0.076: UH1.F35 174.99,84.11 v2(175.08,84.11)
  BOTTOM w0.17: v2(47.5,33.87) 47.4,33.77 46.85,33.77 46.32,33.23 45.35,33.23 43.51,35.07 36.86,35.07 CT34.2
DDI2_HTX_TBRX_N2_C: length 5.7
  BOTTOM w0.102: 33.34,36.83 33.33,36.84 33.28,36.84 33.2,36.92 33.15,36.92 32.49,37.58 32.48,37.58 32.37,37.68 32.02,37.68 31.94,37.61 31.94,37.52 32.01,37.45 UT1.AC19
  BOTTOM w0.17: 33.34,36.83 33.72,36.45 33.75,36.42 33.96,36.2 34.08,36.09 34.38,35.79 34.65,35.52 35.21,34.96 v3(35.33,34.96) 35.93,34.96 CT34.1
DDI2_HTX_TBRX_N3: length 189.3
  IN3 w0.112: v2(49.77,33.9) 49.9,33.77 51.43,33.77 51.94,33.26 53.38,33.26 54.25,32.39 75.43,32.39 75.69,32.65 77.93,32.65 78.47,33.19 84.44,33.19 85.79,34.54 96.3,34.54 102.72,40.96 102.72,41.81 119.99,59.09 119.99,62.98 120.28,63.26 120.28,64.01 121.96,65.69 123.2,65.69 124.23,66.72 124.23,70.59 126,72.37 126,84.28 130.36,88.64 130.36,89.59 134.34,93.56 154.35,93.56 154.84,94.05 170.75,94.05 171.6,93.2 173.34,93.2 173.98,92.56 173.98,91.97 174.65,91.3 175.29,91.3 175.8,90.8 175.8,88.29 175.97,88.12 175.97,87.31 v2(175.63,86.97)
  BOTTOM w0.076: UH1.E36 175.77,85.36 175.77,85.94 175.67,86.04 175.67,86.92 v2(175.63,86.97)
  BOTTOM w0.17: CT36.2 37.28,33.84 37.59,34.16 43.12,34.16 45.07,32.21 47.29,32.21 48.92,33.84 49.71,33.84 v2(49.77,33.9)
DDI2_HTX_TBRX_N3_C: length 5.2
  BOTTOM w0.102: 33.41,34.3 33.41,34.31 33.38,34.35 33.38,34.61 v3(33.25,34.75) 32.79,35.2 32.79,36.3 32.49,36.6 32.49,36.65 32.37,36.76 32.02,36.76 31.94,36.69 31.94,36.6 32.01,36.53 UT1.AC21
  BOTTOM w0.17: 33.41,34.3 33.41,34.24 34.01,33.64 34.41,33.64 CT36.1
DDI2_HTX_TBRX_P0: length 190.6
  IN3 w0.112: v2(40.84,37.92) 40.98,38.05 41.32,38.05 42.93,36.44 43.35,36.44 45.22,34.57 45.94,34.57 46.68,33.83 46.68,33.11 47.19,32.59 48.44,32.59 49.43,31.6 52.04,31.6 53.13,30.52 53.27,30.37 69.97,30.37 70.67,29.68 72.74,29.68 73.43,30.37 75.13,30.37 75.14,30.37 77.87,30.37 79.13,31.62 85.36,31.62 86.7,32.97 96.95,32.97 104.45,40.47 104.45,41.32 115.22,52.09 116.52,52.09 121.57,57.14 121.57,61.75 122.57,62.75 123.29,62.75 125.82,65.28 125.82,69.77 127.71,71.66 127.71,80.5 128.95,81.73 128.95,83.79 129.27,84.11 130.3,84.11 133.74,87.55 133.74,89.17 136.47,91.89 154.92,91.89 155.37,92.35 164.4,92.35 165.17,91.58 170.46,91.58 172.05,89.99 173.63,89.99 174.17,89.44 174.17,88.58 173.59,88 173.59,83.9 173.94,83.56 173.94,83.37 173.86,83.29 173.65,83.29 v2(173.53,83.41)
  BOTTOM w0.076: UH1.H34 173.55,83.41 v2(173.53,83.41)
  BOTTOM w0.17: v2(40.84,37.92) 40.74,38.02 35.45,38.02 CT29.2
DDI2_HTX_TBRX_P0_C: length 3.7
  BOTTOM w0.102: 33.57,38.05 33.56,38.05 33.53,38.09 33.41,38.09 33.37,38.12 33.22,38.12 32.28,39.06 31.86,39.06 UT1.AB15
  BOTTOM w0.17: CT29.1 34.68,37.99 34.18,37.99 34.12,38.05 33.57,38.05
DDI2_HTX_TBRX_P1: length 190.3
  IN3 w0.112: v2(177.09,88.27) 176.87,88.27 176.87,88.27 176.53,88.27 176.23,88.56 176.23,91.47 176.48,91.72 176.48,92.52 175.93,93.06 174.1,93.06 173.53,93.63 171.78,93.63 170.9,94.5 154.7,94.5 154.26,94.06 136.34,94.06 135.9,94.5 134.27,94.5 129.51,89.73 129.51,88.38 125.55,84.42 125.55,72.73 123.76,70.94 123.76,68.24 118.56,63.03 118.56,58.24 102.26,41.94 102.26,41.09 96.13,34.95 85.55,34.95 84.2,33.61 78.2,33.61 77.72,33.14 75.57,33.14 75.24,32.81 54.41,32.81 53.55,33.67 52.11,33.67 51.59,34.2 50.52,34.2 50,34.72 48.76,34.72 48.6,34.57 v2(48.59,34.58)
  BOTTOM w0.076: v2(177.09,88.27) 177,88.37 176.9,88.37 176.83,88.29 175.57,88.29 174.75,87.47 174.75,86.19 174.69,86.13 UH1.F37
  BOTTOM w0.17: v2(48.59,34.58) 48.52,34.65 48.15,34.65 47.85,34.35 45.06,34.35 43.63,35.78 37.86,35.78 37.52,36.13 36.86,36.13 CT31.2
DDI2_HTX_TBRX_P1_C: length 5.5
  BOTTOM w0.089: 33.64,37.14 33.65,37.14
  BOTTOM w0.102: UT1.AB17 31.86,38.14 32.33,38.14 32.71,37.76 32.82,37.65 33.33,37.14 33.64,37.14
  BOTTOM w0.17: 33.65,37.14 33.7,37.14 34.71,36.14 34.71,36.14 v3(34.72,36.13) 34.79,36.06 36.13,36.06 CT31.1
DDI2_HTX_TBRX_P2: length 187.6
  IN3 w0.112: v2(174.3,84.08) 174.42,83.96 174.6,83.96 174.69,84.04 174.69,84.72 174.3,85.1 174.3,87.68 174.87,88.24 174.87,89.76 173.98,90.65 172.49,90.65 171.14,91.99 171.14,92.32 170.36,93.11 155.18,93.11 154.68,92.61 136.16,92.61 133.05,89.5 133.05,89.09 129.24,85.28 128.29,85.28 127.01,84.01 127.01,83.18 127.41,82.78 127.41,81.15 126.99,80.73 126.99,71.95 125.14,70.1 125.14,66.33 123.59,64.77 123.16,64.77 120.9,62.51 120.9,58.71 103.71,41.52 103.71,40.67 96.68,33.63 86.27,33.63 84.92,32.28 78.85,32.28 77.74,31.18 77.6,31.03 75.41,31.03 74.13,31.03 73.7,31.47 71.91,31.47 71.48,31.04 70.24,31.04 53.57,31.04 52.26,32.35 49.62,32.35 48.63,33.34 48.01,33.34 47.88,33.47 47.68,33.47 v2(47.5,33.28)
  BOTTOM w0.076: UH1.F34 174.37,84.08 v2(174.3,84.08)
  BOTTOM w0.17: v2(47.5,33.28) 47.45,33.33 47.03,33.33 46.5,32.8 45.17,32.8 43.33,34.64 36.83,34.64 CT33.2
DDI2_HTX_TBRX_P2_C: length 5.7
  BOTTOM w0.102: 33.03,36.52 32.34,37.22 31.97,37.22 31.96,37.22 31.86,37.22 UT1.AB19
  BOTTOM w0.17: 33.03,36.52 v3(33.44,36.11) 35.03,34.53 36.13,34.53 CT33.1
DDI2_HTX_TBRX_P3: length 189.2
  IN3 w0.112: v2(175.59,87.55) 175.44,87.4 175.22,87.4 175.08,87.54 175.08,87.77 175.28,87.97 175.44,87.97 175.55,88.08 175.55,90.7 175.19,91.06 174.54,91.06 173.73,91.87 173.73,92.46 173.24,92.95 171.5,92.95 170.64,93.81 154.94,93.81 154.45,93.32 134.44,93.32 130.61,89.49 130.61,88.54 126.25,84.18 126.25,72.27 124.48,70.49 124.48,66.62 123.3,65.44 122.06,65.44 120.53,63.91 120.53,63.16 120.24,62.87 120.24,58.98 102.96,41.71 102.96,40.86 96.4,34.29 85.89,34.29 84.55,32.95 78.58,32.95 78.03,32.4 75.8,32.4 75.53,32.14 54.15,32.14 53.28,33.01 51.84,33.01 51.32,33.52 49.98,33.52 v2(49.77,33.32)
  BOTTOM w0.076: UH1.E37 175.49,85.73 175.49,86.57 175.14,86.91 175.14,87.11 v2(175.59,87.55)
  BOTTOM w0.17: CT35.2 35.48,33.21 35.69,33.41 37.45,33.41 37.77,33.73 42.94,33.73 44.89,31.78 47.47,31.78 49.1,33.4 49.68,33.4 v2(49.77,33.32)
DDI2_HTX_TBRX_P3_C: length 5.3
  BOTTOM w0.102: 32.98,34.3 32.98,34.31 33.02,34.35 33.02,34.46 32.91,34.57 32.85,34.63 32.43,35.05 32.43,36.15 32.28,36.3 31.86,36.3 UT1.AB21
  BOTTOM w0.17: CT35.1 33.83,33.21 v3(33.58,33.46) 32.98,34.06 32.98,34.3
DDI2_PCH_HPD: length 106.7
  TOP w0.089: v2(98.35,7.15) 98.35,7.26 v3(97.83,7.78)
  IN3 w0.089: 75.06,5.25 75.77,5.25 75.87,5.34 76.24,5.34 77.1,4.48 79.25,4.48 79.55,4.78 85.3,4.78 85.61,5.09 86.95,5.09 87.26,4.78 87.77,4.78 87.96,4.96 88.87,4.96 89.5,5.6 89.92,5.6 90.82,4.7 91.39,4.7 91.57,4.53 92.23,4.53 92.5,4.8 93.09,4.8 96.76,4.8 97.33,5.36 97.33,6.12 v2(98.35,7.15)
  IN3 w0.112: 75.06,5.25 72.18,5.25 71.89,4.96 71.2,4.96 69.55,4.96 68.01,6.5 65.91,6.5 64.49,7.91 64.49,9.84 63.27,11.06 63.27,14.87 63.04,15.1 63.03,15.1 62.09,16.04 62.09,17.55 61.57,18.07 61.04,18.07 60.02,19.08 60.02,20.09 59.54,20.57 58.8,20.57 57.39,21.98 57.13,21.98 56.75,22.36 55.59,22.36 55.56,22.33 55.02,22.33 54.47,22.89 53.19,22.89 52.99,23.09 50.9,23.09 50.16,23.83 47.7,23.83 47.1,24.44 46.49,24.44 45.86,23.81 44.12,23.81 43.43,24.5 43.43,25.87 42.46,26.83 42.46,27.57 42.21,27.82 41.03,27.82 39.53,29.33 39.15,29.33 37.27,31.21 36.52,31.21 34.28,33.44 34.28,33.58 32.78,35.08 32.78,40.61 32.01,41.39 32.01,42.32 31.23,43.1 31.1,43.1 v2(30.61,43.59)
  IN6 w0.089: v2(30.61,43.59) 31.04,44.03 33.54,44.03 33.66,43.91
  IN6 w0.119: 33.66,43.91 34.05,43.52 36.27,43.52 v2(36.58,43.83)
  BOTTOM w0.089: v2(98.35,7.15) 98.35,6.95 UH2.AY2
  BOTTOM w0.102: UT1.Y6 v2(30.61,43.59)
  BOTTOM w0.17: v2(36.58,43.83) 36.5,43.83 RT42.2
DDR4_DRAMRST#: length 81.9
  TOP w0.14: RD31.1 134.24,17.09 v2(134.48,16.85)
  IN4 w0.091: v2(134.48,16.85) 135.28,17.66 154.21,17.66 155.26,18.72 176.8,18.72 178.18,17.33 210.42,17.33 210.89,16.86 v2(210.89,16.86)
  BOTTOM w0.102: JDIMM1.108 134.12,17.21 v2(134.48,16.85) ; v2(210.89,16.86) 210.89,16.86 210.43,17.32 JDIMM2.108
DDR_A_ACT#: length 50.4
  IN6 w0.089: v2(150.06,57.99) 150.22,57.83 150.22,54.24 149.86,53.89
  IN6 w0.117: 149.86,53.89 149.86,48.66 148.52,47.32 148.52,45.65 144.34,41.46 144.34,40.83 135.94,32.43 135.94,29.43 135.36,28.86 135.36,26.62 135.17,26.43 135.17,22.06 v2(135.78,21.45)
  BOTTOM w0.076: v2(150.06,57.99) 150.59,58.51 150.59,59.5 150.47,59.61 150.47,60.63 150.55,60.71 150.76,60.71 150.83,60.78 150.83,60.96 UH1.AU3
  BOTTOM w0.221: JDIMM1.114 135.62,19.34 135.26,19.71 135.26,20.93 v2(135.78,21.45)
DDR_A_ALERT#: length 51.6
  IN6 w0.117: v2(149.62,58.92) 149.65,58.88 149.65,57.78 149.91,57.52 149.91,54.46 149.43,53.98 149.43,48.82 148.1,47.49 148.1,45.82 143.91,41.64 143.91,41 135.52,32.61 135.52,29.61 134.94,29.03 134.94,26.79 134.75,26.6 134.75,21.03 v2(135.77,20.01)
  BOTTOM w0.076: v2(149.62,58.92) 149.62,59.1 150.14,59.62 150.14,61.73 UH1.AU5
  BOTTOM w0.221: v2(135.77,20.01) 135.77,19.94 136.12,19.58 JDIMM1.116
DDR_A_BG0: length 54.5
  IN6 w0.117: v2(133.93,20.48) 132.24,22.18 132.24,31.64 132.29,31.7 132.29,32.7 141.37,41.78 141.37,42.43 145.72,46.78 145.72,49.64 146.52,50.44 146.52,53.13 146.98,53.58 v2(146.98,54.02)
  BOTTOM w0.076: v2(146.98,54.02) 146.98,54.69 149.11,56.82 149.39,56.82 150.75,58.18 150.75,59.17 150.75,59.17 UH1.AU1
  BOTTOM w0.221: JDIMM1.115 135.88,25.07 135.27,24.46 135.27,22.1 134.44,21.26 134.44,20.99 v2(133.93,20.48)
DDR_A_BG1: length 52.1
  IN6 w0.117: v2(133.93,21.78) 133.09,22.62 132.66,23.05 132.66,31.41 132.71,31.47 132.71,32.53 141.99,41.8 141.99,42.45 146.15,46.61 146.15,49.47 146.94,50.26 146.94,52.91 147.74,53.7 147.74,54.9 v2(147.73,54.91)
  BOTTOM w0.076: UH1.AU2 150.75,60.13 151.03,59.85 151.03,58.22 148.56,55.75 148.56,55.74 v2(147.73,54.91)
  BOTTOM w0.221: v2(133.93,21.78) 134.06,21.78 134.75,22.46 134.75,24.79 135.37,25.42 JDIMM1.113
DDR_A_BS0: length 53.6
  IN6 w0.089: v2(157.41,58.62) 158.49,58.62 158.61,58.49 158.61,51 159.17,50.44 159.17,50
  IN6 w0.117: 159.17,50 159.17,45.55 157.91,44.3 157.91,42.26 149.37,33.72 149.37,31.81 147.4,29.83 147.4,25.25 145.7,23.55 145.7,22.11 145.82,21.98 v2(146.47,21.98)
  BOTTOM w0.076: UH1.AH5 158,62.34 157.8,62.14 157.8,59.01 v2(157.41,58.62)
  BOTTOM w0.221: v2(146.47,21.98) 147.35,21.98 147.47,21.85 147.47,21.31 146.96,20.79 146.96,20.07 146.64,19.75 JDIMM1.150
DDR_A_BS1: length 51.2
  IN6 w0.089: 158.32,50 158.32,50.33 158.15,50.5 158.15,56.22 157.73,56.65 v2(157.41,56.65)
  IN6 w0.117: 158.32,50 158.32,45.9 157.07,44.65 157.07,42.61 148.44,33.98 148.44,33.12 148.36,33.04 148.17,33.04 147.89,33.31 147.77,33.31 147.55,33.09 147.55,32.94 148.32,32.17 148.32,32.02 148.07,31.77 147.9,31.77 147.42,32.25 147.24,32.25 147.01,32.02 147.01,31.84 147.49,31.36 147.49,31.19 147.24,30.94 147.08,30.94 146.93,31.1 146.76,31.1 145.78,30.11 145.78,29.15 146.13,28.79 146.13,27.18 146.25,27.06 146.43,27.06 146.55,26.95 146.55,26.71 146.43,26.6 146.25,26.6 146.13,26.48 146.13,26.25 146.25,26.13 146.43,26.13 146.55,26.01 146.55,25.78 146.43,25.66 146.25,25.66 146.13,25.55 146.13,25.18 144.8,23.85 v2(144.8,23.25)
  BOTTOM w0.076: UH1.AH1 158.3,57.54 v2(157.41,56.65)
  BOTTOM w0.221: JDIMM1.145 145.37,25.51 144.8,24.94 v2(144.8,23.25)
DDR_A_CAS#: length 51.3
  IN6 w0.117: v2(150.74,21.95) 151.29,21.95 151.99,22.65 151.99,24.25 153.04,25.3 153.04,26.88 152.59,27.33 152.59,28.7 155.13,31.24 155.13,33.44 162.18,40.49 162.18,41.3 164.17,43.28 164.17,49.71 160.58,53.3 v2(160.58,53.8)
  BOTTOM w0.076: v2(160.58,53.8) 160.58,54.23 161.7,55.35 161.7,59.58 UH1.AD1
  BOTTOM w0.221: v2(150.74,21.95) 150.59,21.95 150.03,21.39 150.03,20.71 149.38,20.06 148.9,20.06 148.14,19.31 148.14,19.24 JDIMM1.156
DDR_A_D0: length 61.9
  IN6 w0.079: v2(107.65,21.34) 107.65,23.57 107.75,23.67 107.75,24 108.2,24.44 108.2,26.83 107.63,27.4 107.63,29.85 120.09,42.31 120.09,46.94 131.94,58.8 131.94,61.19 132.77,62.02 135.42,62.02 v2(135.54,61.9)
  BOTTOM w0.076: UH1.BR6 138.02,63.03 137.19,63.03 137.14,62.97 136.79,62.97 136.71,63.05 136.05,63.05 135.54,62.54 v2(135.54,61.9)
  BOTTOM w0.14: JDIMM1.8 109.13,20.22 108.01,21.34 v2(107.65,21.34)
DDR_A_D1: length 61.8
  IN6 w0.079: v2(136.93,63.33) 136.27,63.33 135.54,62.61 132.56,62.61 131.38,61.42 131.38,59.03 128.45,56.1 128.32,56.1 128.06,56.37 127.97,56.37 127.77,56.17 127.77,56.06 128.02,55.8 128.02,55.69 127.91,55.58 127.8,55.58 127.55,55.84 127.44,55.84 127.27,55.67 127.27,55.56 127.47,55.36 127.47,55.23 127.38,55.14 127.25,55.14 127.05,55.34 126.94,55.34 126.83,55.23 126.83,55.12 127.05,54.9 127.05,54.77 126.95,54.67 126.82,54.67 126.6,54.89 126.49,54.89 126.38,54.78 126.38,54.67 126.64,54.41 126.64,54.3 126.53,54.19 126.42,54.19 126.16,54.45 126.05,54.45 119.53,47.93 119.53,42.54 106.94,29.96 106.94,24.22 v2(107.34,23.82)
  BOTTOM w0.076: UH1.BT6 v2(136.93,63.33)
  BOTTOM w0.14: JDIMM1.7 108.88,25.5 107.81,24.43 107.81,24.3 v2(107.34,23.82)
