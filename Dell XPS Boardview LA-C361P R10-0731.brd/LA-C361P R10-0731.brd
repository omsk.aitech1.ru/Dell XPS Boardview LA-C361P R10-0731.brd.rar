# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_CMD30: length 27
  TOP w0.17: v2(206.58,95.91) 205.33,95.91 205.16,95.74 205.16,95.14 204.99,94.97 v3(204.98,94.97) 204.65,94.97 204.48,95.14 204.48,95.74 204.31,95.91 203.97,95.91 203.8,95.74 203.8,95.14 203.63,94.97 203.29,94.97 203.12,95.14 203.12,95.69 RV338.1 200.05,98.75 200.05,99.36 199.8,99.62 199.8,101.31 v2(200.24,101.75)
  BOTTOM w0.089: UV1.Y33 210.87,90.45 210.48,90.84 210.09,90.84 209.49,91.44 209.49,92.12 209.42,92.18
  BOTTOM w0.14: v2(200.24,101.75) 200.24,101.75 200.21,101.78 200.21,101.77 199.86,102.13 UV6.J3
  BOTTOM w0.17: v2(206.58,95.91) 207.37,95.91 207.75,95.53 208.83,95.53 208.95,95.4 208.95,94.97 208.83,94.84 207.02,94.84 206.9,94.71 206.9,94.33 207.02,94.2 208.87,94.2 209,94.08 209,93.14 209.3,92.84 209.3,92.31 209.42,92.18 209.42,92.18
FBA_CMD31: length 32.8
  BOTTOM w0.089: 211.32,92 211.68,91.65 211.68,90.97 211.5,90.79 211.5,89.51 211.84,89.17 212.38,89.17 UV1.V31
  BOTTOM w0.17: 211.32,92 211.32,92.97 211.2,93.1 211.2,93.77 211.05,93.92 211.05,96.52 208.81,98.77 v3(208.81,100.4) 208.81,104.76 207.14,106.43 200.93,106.43 199.68,105.19 198.78,105.19 198.41,104.82 198.41,104.43 197.87,103.89 197.87,102.55 UV6.L3
FBA_D0: length 20.5
  IN6 w0.097: v2(223.89,102.56) 223.48,102.15 223.48,100 222.69,99.21 222.69,95.93 223.06,95.56 223.06,91.37 222.33,90.64 222.33,90.1 220.65,88.42 219.17,88.42 218.65,87.9 218.65,87.34 218.11,86.8 v2(218.11,86.73)
  BOTTOM w0.089: v2(218.11,86.73) 218.49,86.35 UV1.L28
  BOTTOM w0.102: v2(223.89,102.56) UV5.A4
FBA_D1: length 20.7
  IN6 w0.097: v2(223.89,100.96) 224.28,100.57 224.28,99.24 223.54,98.51 223.54,96.33 223.99,95.88 223.99,93.09 223.47,92.57 223.47,90.94 220.66,88.13 219.77,88.13 219.43,87.79 219.43,87.44 219.13,87.14 218.78,87.14 218.54,86.9 218.54,86.53 218.38,86.37 217.65,86.37 v2(217.27,86.75)
  BOTTOM w0.089: v2(217.27,86.75) 217.7,87.18 UV1.M29
  BOTTOM w0.102: v2(223.89,100.96) UV5.A2
FBA_D2: length 22.9
  IN6 w0.089: v2(223.09,102.56) 223.5,102.97 224.02,102.97 224.24,102.74
  IN6 w0.097: 224.24,102.74 224.32,102.66 224.32,101.57 224.68,101.21 224.68,99.08 223.95,98.34 223.95,96.49 224.51,95.93 224.51,92.31 223.83,91.63 223.83,90.68 221.89,88.74 221.89,87.57 221.53,87.21 219.55,87.21 219.11,86.78 v2(218.93,86.78)
  BOTTOM w0.089: UV1.L29 218.93,86.77 v2(218.93,86.78)
  BOTTOM w0.102: UV5.B4 v2(223.09,102.56)
FBA_D3: length 20.8
  IN6 w0.097: v2(223.09,100.96) 222.7,100.56 222.7,100.01 222.27,99.59 222.27,95.76 222.66,95.37 222.66,91.7 221.84,90.89 221.84,89.89 220.67,88.71 219.17,88.71 218.46,87.99 218.46,87.42 218.25,87.21 217.21,87.21 216.83,86.82 216.83,86.34 v2(217.23,85.93)
  BOTTOM w0.089: v2(217.23,85.93) 217.65,86.35 UV1.M28
  BOTTOM w0.102: v2(223.09,100.96) UV5.B2
FBA_D4: length 19.2
  IN6 w0.097: v2(217.27,88.46) 217.4,88.46 217.93,88.99 217.93,90.24 219.24,91.54 219.24,92.51 220.07,93.34 220.07,96.14 220.15,96.22 220.15,99 219.46,99.69 219.46,101.08 219.73,101.35 220.85,101.35 221.08,101.58 221.08,102.99 v2(220.68,103.39)
  BOTTOM w0.089: UV1.N31 216.89,88.85 v2(217.27,88.46)
  BOTTOM w0.102: UV5.E4 221.09,102.98 v2(220.68,103.39)
FBA_D5: length 17.6
  IN6 w0.097: v2(216.45,86.75) 216.45,87.03 216.83,87.41 216.83,87.8 217.11,88.08 217.5,88.08 218.18,88.77 218.18,89.86 219.71,91.39 219.71,92.36 220.47,93.13 220.47,95.97 220.55,96.05 220.55,99.72 220.28,99.99 220.28,100.55 v2(220.69,100.96)
  BOTTOM w0.089: v2(216.45,86.75) 216,87.19 UV1.P29
  BOTTOM w0.102: v2(220.69,100.96) UV5.E2
FBA_D6: length 20.6
  IN6 w0.097: v2(220.65,102.56) 220.65,102.36 220.47,102.18 219.33,102.18 218.69,101.55 218.69,100.82 218.34,100.47 218.34,99.48 219.32,98.5 219.32,96.63 219.25,96.55 219.25,93.69 218.36,92.8 218.36,91.96 216.83,90.43 216.83,89.11 216.59,88.86 216.28,88.86 216.01,88.6 216.01,87.52 215.56,87.06 v2(215.56,86.81)
  BOTTOM w0.089: UV1.R29 215.56,86.84 v2(215.56,86.81)
  BOTTOM w0.102: UV5.F4 220.29,102.93 v2(220.65,102.56)
FBA_D7: length 20
  IN6 w0.097: v2(219.86,101.77) 219.48,101.77 219.08,101.37 219.08,100.69 218.67,100.29 218.67,99.75 219.75,98.67 219.75,96.44 219.66,96.35 219.66,93.5 218.83,92.67 218.83,91.72 217.66,90.54 217.66,89.1 217.45,88.88 217.14,88.88 216.84,88.58 216.84,88.26 216.36,87.78 216.36,87.42 215.96,87.03 215.96,86.31 v2(215.61,85.96)
  BOTTOM w0.089: UV1.P28 216,86.33 215.63,85.96 v2(215.61,85.96)
  BOTTOM w0.102: UV5.F2 220.27,101.36 v2(219.86,101.77)
FBA_D8: length 27.7
  IN1 w0.089: 222.06,89.67 221.58,89.19 221.49,89.19 220.91,88.61 220.91,87.45 220.64,87.18 220.26,87.18 v2(219.8,86.72) ; 223.56,92.18 223.56,91.88 223.27,91.59 223.27,91.58 222.81,91.12 222.81,91.12 222.06,90.38
  IN1 w0.097: 223.56,92.18 223.56,95.03 222.39,96.21 222.39,97.09 222.48,97.18 222.76,97.18 222.86,97.28 222.86,97.47 222.76,97.57 222.48,97.57 222.39,97.66 222.39,97.86 222.48,97.95 222.76,97.95 222.86,98.05 222.86,98.24 222.76,98.34 222.48,98.34 222.39,98.44 222.39,99.47 222.7,99.78 222.7,103.57 223.48,104.35 223.48,107.77 v2(223.12,108.13) ; 222.06,90.38 222.06,89.67
  BOTTOM w0.089: UV1.J28 219.83,86.72 v2(219.8,86.72) ; UV5.A11 224.28,108.56 223.88,108.16 223.15,108.16 v2(223.12,108.13)
FBA_D9: length 28
  IN1 w0.089: 221.63,89.58 220.55,88.5 v2(220.55,87.6) ; 223.09,92.18 223.09,91.7 221.86,90.47
  IN1 w0.097: 221.63,89.58 221.83,89.79 221.83,90.44 221.86,90.47 ; v2(223.92,109.76) 223.46,109.3 223.46,108.72 223.28,108.54 222.97,108.54 222.71,108.28 222.71,107.86 222.43,107.57 222.43,104.14 221.88,103.59 221.88,99.83 221.43,99.37 221.43,98.66 221.55,98.54 221.79,98.54 221.92,98.41 221.92,98.19 221.79,98.07 221.48,98.07 221.36,97.94 221.36,97.72 221.48,97.6 221.78,97.6 221.91,97.47 221.91,97.27 221.78,97.14 221.53,97.14 221.4,97.01 221.4,96.81 221.53,96.68 221.88,96.68 221.98,96.58 221.98,96.04 223.09,94.93 223.09,92.18
  BOTTOM w0.089: UV5.A13 224.29,110.13 v2(223.92,109.76) ; UV1.H29 220.95,87.2 220.55,87.6 v2(220.55,87.6)
FBA_D10: length 28.7
  IN1 w0.089: v2(219.86,87.62) 219.86,88.07 221.01,89.21 221.01,90.2 221.3,90.5 221.49,90.5
  IN1 w0.097: 221.49,90.5 221.63,90.5 222.67,91.54 222.67,94.79 220.98,96.48 220.98,97.23 220.85,97.35 220.18,97.35 220.05,97.48 220.05,97.66 220.18,97.79 220.83,97.79 220.96,97.91 220.96,98.1 220.83,98.23 220.18,98.23 220.05,98.36 220.05,98.59 220.18,98.71 220.84,98.71 220.95,98.82 220.95,99.61 221.09,99.75 221.09,103.56 221.93,104.4 221.93,108.32 222.17,108.56 222.48,108.56 222.86,108.94 v2(223.06,108.94)
  BOTTOM w0.089: UV1.J29 220.2,87.28 v2(219.86,87.62) ; UV5.B11 223.44,108.56 v2(223.06,108.94)
FBA_D11: length 28.5
  IN1 w0.089: 221.48,88.91 221.1,88.53 221.1,87.12 v2(221.41,86.81)
  IN1 w0.097: 221.48,88.91 221.68,88.91 222.31,89.54 222.31,90.37 224.03,92.09 224.03,95.84 223.3,96.57 223.3,99.61 223.47,99.78 223.47,102.69 223.75,102.97 224.05,102.97 224.28,103.2 224.28,103.54 223.88,103.95 223.88,108.4 224.27,108.8 224.27,109.39 224.37,109.5 224.37,109.85 224.08,110.15 223.69,110.15 223.3,109.76 v2(223.12,109.76)
  BOTTOM w0.089: UV1.H28 221,86.4 v2(221.41,86.81) ; v2(223.12,109.76) 223.49,110.13 UV5.B13
FBA_D12: length 38
  IN1 w0.089: 226.11,91.72 225.58,91.2 225.58,91.1 224.29,89.8 224.29,89.09 224.03,88.83 222.97,88.83 222.71,88.57 222.71,88.06 v2(222.28,87.63)
  IN1 w0.097: 226.11,91.72 226.11,99.37 226.53,99.8 226.53,104.21 225.83,104.91 225.83,107.27 226.26,107.69 226.26,107.95 226.5,108.19 226.5,108.54 226.75,108.79 226.75,111.12 225.57,112.29 222.1,112.29 221.27,111.47 221.27,111.28 220.94,110.95 220.56,110.95 220.31,110.7 220.31,108.63 v2(220.73,108.21)
  BOTTOM w0.089: v2(222.28,87.63) 222.27,87.63 221.85,87.2 UV1.G29 ; UV5.E11 221.07,108.56 v2(220.73,108.21)
FBA_D13: length 30.9
  IN1 w0.089: 225.71,91.68 225.24,91.21 225.24,91 223.95,89.72 223.95,89.34 v2(223.91,89.3)
  IN1 w0.097: 225.71,91.68 225.71,99.54 226.04,99.87 226.04,103.99 225.3,104.73 225.3,107.3 225.83,107.84 225.83,108.12 226.09,108.38 226.09,108.73 226.34,108.98 226.34,110.79 225.24,111.89 222.27,111.89 220.94,110.56 v2(220.7,110.56)
  BOTTOM w0.089: UV1.E31 223.5,88.89 v2(223.91,89.3) ; v2(220.7,110.56) 221.09,110.17 UV5.E13
FBA_D14: length 32
  IN1 w0.097: v2(223.11,89.28) 223.2,89.28 224.91,90.98 224.91,91.36 225.31,91.76 225.31,96.88 224.51,97.67 224.51,98.91 225.59,99.99 225.59,103.87 224.9,104.56 224.9,107.47 225.39,107.96 225.39,108.24 225.69,108.54 225.69,109.06 225.82,109.2 225.82,110.54 224.88,111.49 222.99,111.49 222.44,110.94 222.16,110.94 221.91,110.69 221.91,109.62 221.65,109.36 221.11,109.36 v2(220.7,108.95)
  BOTTOM w0.089: v2(223.11,89.28) 223.49,89.65 UV1.E32 ; v2(220.7,108.95) 220.31,108.56 UV5.F11
FBA_D15: length 36.3
  IN1 w0.089: v2(223.1,88.45) 223.47,88.08 224.15,88.08 224.47,88.4 224.47,89.73 226.41,91.67
  IN1 w0.097: 226.41,91.67 226.41,92.05 226.51,92.16 226.51,99.21 226.93,99.63 226.93,104.38 226.33,104.98 226.33,107.19 226.67,107.54 226.67,107.8 226.9,108.02 226.9,108.37 227.15,108.62 227.15,111.29 225.74,112.7 221.45,112.7 220.28,111.53 220.28,111.16 219.89,110.77 v2(219.89,110.56)
  BOTTOM w0.089: UV1.F30 223.1,88.45 v2(223.1,88.45) ; v2(219.89,110.56) 220.29,110.16 UV5.F13
FBA_D16: length 28.6
  IN1 w0.097: v2(211.89,108.16) 212.28,107.77 212.28,104.34 213.11,103.51 213.11,102.73 213.1,102.72 213.1,102.4 213.11,102.39 213.11,101.13 213.1,101.12 213.1,100.8 213.11,100.79 213.11,100.33 213.07,100.3 213.07,99.92 214.67,98.33 214.8,98.33 215.25,98.78 215.39,98.78 215.52,98.64 215.52,98.51 215.07,98.06 215.07,97.92 215.21,97.79 215.35,97.79 215.8,98.24 215.93,98.24 216.07,98.1 216.07,97.96 215.62,97.51 215.62,97.38 215.78,97.21 215.89,97.21 216.3,97.63 216.54,97.63 217.17,97 218.77,97 221.32,94.45 222.06,94.45 v2(222.23,94.28)
  BOTTOM w0.102: UV5.U11 v2(211.89,108.16)
  BOTTOM w0.17: v2(222.23,94.28) 222.66,94.28 v3(223.56,93.38) 225.2,91.74 UV1.C34
FBA_D17: length 29
  IN1 w0.097: v2(221.97,93.11) 221.4,93.11 218.36,96.15 215.3,96.15 211.18,100.26 211.18,108.49 211.48,108.78 211.48,109.33 v2(211.07,109.74)
  BOTTOM w0.089: UV5.U13 211.07,109.75 v2(211.07,109.74)
  BOTTOM w0.17: v2(221.97,93.11) 222.36,93.11 223.08,92.4 223.08,91.13 223.32,90.89 223.63,90.89 223.97,90.55 223.97,90.03 UV1.D32
FBA_D18: length 27.9
  IN1 w0.097: v2(221.94,94.88) 221.45,94.88 218.91,97.42 217.32,97.42 216.91,97.83 216.91,97.97 217.22,98.28 217.22,98.42 217.09,98.56 216.95,98.56 216.64,98.24 216.5,98.24 216.36,98.38 216.36,98.51 216.68,98.83 216.68,98.97 216.54,99.1 216.4,99.1 216.09,98.79 215.95,98.79 215.44,99.3 215.01,99.3 214.7,99.61 214.7,102.38 214.7,102.38 214.7,104.26 213.08,105.88 213.08,107.73 v2(212.66,108.15)
  BOTTOM w0.102: UV5.T11 212.66,108.19 v2(212.66,108.15)
  BOTTOM w0.17: v2(221.94,94.88) v3(222.52,94.88) 222.88,94.88 225.58,92.18 225.59,92.17 225.59,90.86 UV1.B33
FBA_D19: length 28.6
  IN1 w0.097: v2(211.89,109.76) 212.29,109.36 212.29,108.81 212.03,108.56 211.73,108.56 211.46,108.28 211.46,104.3 212.29,103.46 212.29,102.33 212.27,102.31 212.27,99.97 215.67,96.57 218.52,96.57 221.49,93.61 221.95,93.61 222.03,93.7 v2(222.23,93.7)
  BOTTOM w0.089: v2(211.89,109.76) UV5.T13
  BOTTOM w0.17: UV1.C33 224.8,90.85 224.8,91.35 222.45,93.7 v2(222.23,93.7)
FBA_D20: length 37.1
  IN1 w0.097: v2(221.57,91.19) 217.4,91.19 216.64,91.95 216.4,91.95 214.13,94.22 213.13,94.22 209.82,97.53 209.82,110.33 210.51,111.01 210.96,111.01 211.01,110.96 213.64,110.96 213.9,110.7 213.9,108.7 214.44,108.16 v2(215.09,108.16)
  BOTTOM w0.089: UV1.F33 221.96,91.19 v2(221.57,91.19)
  BOTTOM w0.102: UV5.N11 214.69,108.56 v2(215.09,108.16)
FBA_D21: length 38.5
  IN1 w0.097: v2(215.09,109.76) 215.09,110.36 214.48,110.97 214.1,110.97 213.24,111.82 210.72,111.82 209.4,110.5 209.4,96.79 212.48,93.71 213.98,93.71 215.34,92.35 215.34,91.89 216.07,91.16 216.6,91.16 216.94,90.83 v2(220.6,90.83)
  BOTTOM w0.089: UV1.F32 222.26,90.09 222.26,90.51 221.95,90.83 v2(220.6,90.83)
  BOTTOM w0.102: v2(215.09,109.76) UV5.N13
FBA_D22: length 39.2
  IN1 w0.097: v2(215.1,108.97) 215.49,109.36 215.49,110.47 214.69,111.26 214.69,111.51 213.95,112.25 210.54,112.25 208.97,110.68 208.97,96.65 214.32,91.3 215.02,91.3 215.91,90.41 219.83,90.41 220.18,90.05 v2(220.57,90.05)
  BOTTOM w0.089: UV1.H33 220.97,90.45 v2(220.57,90.05) ; UV5.M11 215.1,108.95 v2(215.1,108.97)
FBA_D23: length 39.4
  IN1 w0.097: v2(220.57,89.29) 219.77,89.29 219.42,89.65 216.04,89.65 214.85,90.83 214.18,90.83 208.55,96.47 208.55,110.85 210.36,112.67 214.13,112.67 215.14,111.66 v2(215.14,111.39)
  BOTTOM w0.089: UV1.H32 220.93,89.65 v2(220.57,89.29)
  BOTTOM w0.102: UV5.M13 215.14,110.51 v2(215.14,111.39)
FBA_D24: length 14.4
  IN6 w0.097: v2(216.48,91.57) 215.89,92.16 215.89,96.55 213.09,99.35 213.09,101.89 212.87,102.11 212.33,102.11 v2(211.85,102.6)
  BOTTOM w0.089: v2(216.48,91.57) 216.16,91.25 UV1.P34 ; v2(211.85,102.6) 211.85,102.64 211.53,102.96 UV5.U4
FBA_D25: length 14.3
  IN6 w0.097: v2(216.45,90.02) 215.2,91.26 215.2,91.96 215.04,92.12 215.04,96.2 211.46,99.79 211.46,100.55 v2(211.85,100.95)
  BOTTOM w0.089: UV5.U2 211.49,101.31 v2(211.85,100.95) ; v2(216.45,90.02) 216.08,89.65 UV1.P32
FBA_D26: length 18.1
  IN6 w0.097: v2(211.84,103.36) 210.88,102.41 210.88,99.76 214.62,96.03 214.62,92.17 214.94,91.85 214.94,90.79 v2(216.46,89.26)
  BOTTOM w0.089: UV1.P31 216.05,88.85 v2(216.46,89.26) ; v2(211.84,103.36) 211.87,103.36 211.87,103.36 212.28,102.96 UV5.T4
FBA_D27: length 13.2
  IN6 w0.097: v2(212.68,100.97) 212.26,100.55 212.26,99.59 215.47,96.38 215.47,91.76 v2(216.45,90.78)
  BOTTOM w0.089: UV1.P33 216.11,90.45 v2(216.45,90.78) ; v2(212.68,100.97) UV5.T2
FBA_D28: length 16.4
  IN6 w0.097: v2(215.09,102.54) 215.1,102.54 216.29,101.35 216.97,101.35 217.2,101.13 217.2,99.1 218.1,98.2 218.1,95.51 v2(218.1,95.51)
  BOTTOM w0.089: v2(215.09,102.54) 214.69,102.94 UV5.N4
  BOTTOM w0.17: UV1.L31 218.12,89.23 218.12,91.75 217.91,91.97 217.91,93.13 217.73,93.3 217.73,95.14 v2(218.1,95.51)
FBA_D29: length 11.8
  IN6 w0.097: v2(218.19,93.54) 217.92,93.54 217.26,94.2 217.26,97.44 215.53,99.17 215.53,99.98 215.52,99.99 215.52,100.52 v2(215.09,100.96)
  BOTTOM w0.089: v2(215.09,100.96) UV5.N2
  BOTTOM w0.17: v2(218.19,93.54) 218.39,93.34 218.39,92.11 218.5,92 UV1.L34
FBA_D30: length 18.5
  IN6 w0.097: v2(218.77,94.83) 218.63,94.97 218.63,98.3 217.71,99.22 217.71,100.93 217.84,101.06 217.84,103.15 217.87,103.18 217.87,103.49 217.59,103.77 215.52,103.77 v2(215.13,103.38)
  BOTTOM w0.089: UV5.M4 215.49,103.01 v2(215.13,103.38)
  BOTTOM w0.17: v2(218.77,94.83) 219.37,94.23 v3(219.37,93.62) 219.37,91.74 219.2,91.58 219.2,90.94 218.95,90.69 218.95,90.1 UV1.L32
FBA_D31: length 14
  IN6 w0.097: v2(215.11,101.76) 215.13,101.76 216.29,100.6 216.29,99.15 217.68,97.75 217.68,94.42 217.96,94.14 v2(218.75,94.14)
  BOTTOM w0.089: UV5.M2 215.49,101.38 v2(215.11,101.76)
  BOTTOM w0.17: UV1.L33 218.5,90.62 218.86,90.98 218.86,94.02 v2(218.75,94.14)
FBA_D32: length 26.9
  IN6 w0.097: v2(205.87,103.32) 206.35,103.32 208.65,101.03 208.65,98.62 211.78,95.49 211.78,92.13 211.19,91.54 211.19,90.74 210.25,89.8 210.25,89.17 209.94,88.86 209.32,88.86 209.21,88.75 208.81,88.75 208.6,88.53 208.6,88.52 208.59,88.51 208.59,88.09 208.55,88.05 208.55,86.54 207.57,85.56 206.12,85.56 205.51,86.17 v2(205.51,86.8)
  BOTTOM w0.089: UV1.AG28 205.2,86.49 v2(205.51,86.8) ; v2(205.87,103.32) 206.23,102.96 UV6.A4
FBA_D33: length 18.6
  IN6 w0.097: v2(205.57,87.6) 206.04,88.06 206.04,88.6 206.24,88.81 206.69,88.81 207.02,89.14 207.02,90.11 207.96,91.06 207.96,91.64 208.33,92.01 208.33,93.51 204.62,97.21 v2(204.62,97.8)
  BOTTOM w0.089: UV1.AF29 205.97,87.2 v2(205.57,87.6)
  BOTTOM w0.17: v2(204.62,97.8) 204.8,97.8 205.26,98.26 205.26,98.97 205.93,99.64 206.31,99.64 206.63,99.96 206.63,100.99 UV6.A2
FBA_D34: length 21
  IN6 w0.097: v2(204.56,98.43) 204.19,98.07 204.19,97.08 207.93,93.34 207.93,91.93 207.71,91.71 207.71,91.07 206.83,90.19 206.83,89.25 206.57,89 206.01,89 205.86,88.85 205.45,88.85 205.16,88.55 205.16,87.16 v2(204.81,86.81)
  BOTTOM w0.089: UV1.AG29 v2(204.81,86.81)
  BOTTOM w0.17: v2(204.56,98.43) 204.56,98.97 205.61,100.02 205.61,100.18 205.87,100.43 205.87,102.55 UV6.B4
FBA_D35: length 19.4
  IN6 w0.097: v2(206.65,87.35) 206.65,87.85 207.39,88.59 207.39,89.96 208.64,91.22 209.19,91.22 209.38,91.41 209.38,91.97 209.24,92.11 209.24,94.54 207.07,96.71 206.4,96.71 205.55,97.56 205.55,98.74 204.67,99.62 204.67,100.58 v2(205.06,100.96)
  BOTTOM w0.089: v2(206.65,87.35) 206.65,87 UV1.AF28 ; v2(205.06,100.96) UV6.B2
FBA_D36: length 23.8
  IN6 w0.097: v2(208.17,87.61) 208.17,88.08 208.28,88.19 208.28,88.48 208.74,88.93 209.13,88.93 209.38,89.18 209.38,89.37 210.88,90.88 210.88,91.7 211.34,92.15 211.34,95.33 208.22,98.45 208.22,100.28 206.93,101.57 206.7,101.57 205.84,102.43 205.84,102.72 205.17,103.39 202.69,103.39 202.67,103.37 v2(202.66,103.37)
  BOTTOM w0.089: v2(208.17,87.61) 208.17,87.64 207.75,88.05 UV1.AD30
  BOTTOM w0.102: v2(202.66,103.37) 202.67,103.37 202.67,103.33 203.04,102.96 UV6.E4
FBA_D37: length 21.6
  IN6 w0.097: v2(207.29,86.78) 207.29,87.19 207,87.48 207,87.78 207.57,88.35 207.57,89.85 208.2,90.48 209.05,90.48 209.66,91.1 209.66,94.68 207.23,97.11 206.57,97.11 205.97,97.71 205.97,98.92 205.46,99.43 205.46,101.05 205.45,101.06 205.45,101.13 205.23,101.35 203.9,101.35 v2(203.49,100.95)
  BOTTOM w0.089: v2(207.29,86.78) 207.7,87.19 UV1.AD29 ; v2(203.49,100.95) 203.06,101.38 203.06,101.38 UV6.E2
FBA_D38: length 24.3
  IN6 w0.097: v2(208.09,86.8) 207.8,87.09 207.8,87.98 208.03,88.2 208.03,88.63 208.51,89.11 208.51,89.58 208.66,89.73 209.36,89.73 210.61,90.99 210.61,91.77 210.94,92.1 210.94,95.15 207.8,98.28 207.8,100.11 205.59,102.32 205.59,102.59 205.13,103.04 203.14,103.04 v2(202.66,102.56)
  BOTTOM w0.089: UV1.AC29 208.49,87.2 v2(208.09,86.8)
  BOTTOM w0.102: UV6.F4 v2(202.66,102.56)
FBA_D39: length 21.2
  IN6 w0.097: v2(202.66,100.96) 202.7,100.96 203.06,100.59 203.06,99.67 203.27,99.46 204.23,99.46 205.12,98.57 205.12,97.42 206.23,96.31 206.9,96.31 208.8,94.41 208.8,92.22 208.5,91.92 208.5,91.78 208.33,91.61 208.33,91.16 207.2,90.04 207.2,88.72 206.22,87.74 206.22,87.07 207.29,86 v2(207.29,85.96)
  BOTTOM w0.089: v2(202.66,100.96) UV6.F2 ; UV1.AD28 207.68,86.35 v2(207.29,85.96)
FBA_D40: length 24.1
  IN1 w0.097: v2(203.86,87.58) 203.99,87.71 203.99,89.62 204.8,90.43 205.06,90.43 205.29,90.66 205.29,90.66 206.25,91.62 206.25,92.61 205.77,93.08 205.77,96.93 205.51,97.19 205.51,99.39 205.75,99.63 205.75,100.58 205.98,100.8 205.98,102.5 206.65,103.17 206.65,107.36 v2(205.86,108.16)
  BOTTOM w0.089: UV1.AJ29 203.45,87.38 203.65,87.58 v2(203.86,87.58) ; UV6.A11 v2(205.86,108.16)
FBA_D41: length 26.7
  IN1 w0.097: v2(205.86,110.56) 205.47,110.17 205.47,105.31 206.33,104.45 206.33,103.23 205.66,102.57 205.66,100.87 205.45,100.65 205.45,99.92 205.11,99.59 205.11,97.02 205.37,96.76 205.37,92.81 205.47,92.71 205.47,91.54 205.21,91.28 204.63,91.28 204.34,90.99 204.34,90.27 203.61,89.54 203.61,88.16 v2(203.03,87.58)
  BOTTOM w0.089: 202.63,87.18 v2(203.03,87.58) ; UV6.A13 v2(205.86,110.56)
  BOTTOM w0.102: UV1.AK29 202.63,87.18
FBA_D42: length 22.3
  IN1 w0.097: v2(205.06,108.17) 204.66,107.76 204.66,100 203.92,99.26 203.92,96.96 204.71,96.17 204.71,93.11 203.59,91.98 203.59,89.81 203.08,89.31 v2(203.08,88.47)
  BOTTOM w0.089: UV6.B11 v2(205.06,108.17) ; UV1.AJ30 v2(203.08,88.47)
FBA_D43: length 29.5
  IN1 w0.076: 207.26,92.18 207.26,91 206.78,90.52
  IN1 w0.097: v2(205.87,109.76) 207.21,108.41 207.21,100.47 205.94,99.19 205.94,97.48 206.17,97.24 206.17,93.45 207.26,92.37 207.26,92.18 ; 206.78,90.52 205.44,90.52 205.37,90.45 205.37,90.45 205.08,90.16 204.3,89.39 204.3,87.5 203.99,87.18 202.65,87.18 v2(202.22,86.75)
  BOTTOM w0.089: UV6.B13 205.47,110.16 v2(205.87,109.76) ; UV1.AK28 202.6,86.37 v2(202.22,86.75)
FBA_D44: length 24.8
  IN1 w0.097: v2(202.68,108.15) 202.68,107.96 203.11,107.53 203.11,105.85 202.24,104.97 202.24,103.73 202.27,103.7 202.27,96.85 203.51,95.61 203.51,93.61 202.29,92.39 202.29,89.97 201.52,89.2 201.52,88.23 201.06,87.76 201.06,87.22 v2(200.6,86.76)
  BOTTOM w0.089: v2(202.68,108.15) 203.06,108.52 UV6.E11 ; UV1.AM29 200.99,87.15 v2(200.6,86.76)
FBA_D45: length 25.7
  IN1 w0.097: v2(200.6,88.42) 200.6,91.22 200.72,91.35 200.72,99.35 199.85,100.22 199.85,106.62 199.86,106.63 199.86,107.18 200.66,107.98 200.66,109.93 200.91,110.17 201.23,110.17 201.24,110.16 202.27,110.16 v2(202.67,110.56)
  BOTTOM w0.089: UV1.AM31 200.97,88.8 v2(200.6,88.42) ; UV6.E13 203.06,110.17 v2(202.67,110.56)
FBA_D46: length 26.5
  TOP w0.089: v2(199.8,87.52) 199.8,87.59 200.2,87.99 v1(200.2,89.62)
  IN1 w0.097: v2(201.84,108.97) 201.42,108.55 201.42,106.56 201.04,106.18 201.04,103.89 200.66,103.51 200.66,100.31 201.15,99.83 201.15,92.72 201.35,92.52 201.35,91.38 201,91.04 201,88.3 200.75,88.04 200.32,88.04 v2(199.8,87.52)
  BOTTOM w0.089: v2(201.84,108.97) UV6.F11 ; v2(199.8,87.52) 200.17,87.15 UV1.AN29
FBA_D47: length 25.5
  IN1 w0.097: v2(200.58,87.58) 200.59,87.58 201.26,88.25 201.26,89.3 201.87,89.91 201.87,92.54 203.11,93.78 203.11,95.44 201.84,96.71 201.84,99.62 201.47,100 201.47,106.16 202.27,106.96 202.27,109.32 v2(201.84,109.75)
  BOTTOM w0.089: v2(200.58,87.58) 200.95,87.95 UV1.AM30 ; v2(201.84,109.75) 202.26,110.16 UV6.F13
FBA_D48: length 25.1
  IN1 w0.097: v2(193.85,108.16) 193.85,108.16 193,108.16 192.96,108.12 192.7,108.12 192.53,107.95 192.53,103.08 192.62,102.99 192.62,96.16 197.73,91.05 197.73,90.17 198.69,89.2 v2(198.69,89.02)
  BOTTOM w0.089: UV1.AN31 199.44,88.8 199.21,89.02 v2(198.69,89.02)
  BOTTOM w0.102: UV6.U11 v2(193.85,108.16)
FBA_D49: length 25.6
  IN1 w0.097: v2(193.85,110.56) 194.25,110.16 194.8,110.16 195.06,109.9 195.06,108.03 194.77,107.74 194.48,107.74 194.25,107.51 194.25,95.69 198.49,91.45 198.97,91.45 199.77,90.65 v2(199.77,90.05)
  BOTTOM w0.089: UV1.AN32 200.17,89.65 v2(199.77,90.05)
  BOTTOM w0.102: v2(193.85,110.56) UV6.U13
FBA_D50: length 26.1
  IN1 w0.097: v2(198.12,88.86) 197.3,89.68 197.3,90.89 192.2,95.98 192.2,102.82 192.11,102.91 192.11,108.14 192.51,108.54 193.44,108.54 v2(193.85,108.96)
  BOTTOM w0.102: UV6.T11 v2(193.85,108.96)
  BOTTOM w0.14: UV1.AP30 198.75,88.6 198.57,88.6
  BOTTOM w0.17: v2(198.12,88.86) 198.38,88.6 198.57,88.6
FBA_D51: length 24.5
  IN1 w0.097: v2(198.23,90.34) 198.23,91.13 193.08,96.28 193.08,107.25 193.59,107.76 193.99,107.76 194.26,108.02 194.26,109.35 v2(193.85,109.76)
  BOTTOM w0.102: v2(193.85,109.76) UV6.T13
  BOTTOM w0.17: UV1.AP32 198.71,90.34 v2(198.23,90.34)
FBA_D52: length 21.2
  IN1 w0.097: v2(199.47,92.52) 199.29,92.52 198.15,93.66 198.15,94.38 196.76,95.77 196.76,101.5 196.67,101.6 196.67,103.77 197.49,104.59 197.49,105.94 196.65,106.77 196.65,107.52 197.05,107.92 v2(197.05,108.16)
  BOTTOM w0.102: UV6.N11 v2(197.05,108.16)
  BOTTOM w0.14: 200.14,92.18 200.6,91.72 200.6,91.01 201,90.61 UV1.AM33
  BOTTOM w0.17: v2(199.47,92.52) 199.81,92.52 200.14,92.18
FBA_D53: length 26.3
  IN1 w0.097: v2(197.05,110.56) 197.44,110.18 198.78,110.18 199.03,109.92 199.03,105.27 199.3,105 199.3,97.31 200.1,96.52 200.1,92.13 200.19,92.04 200.19,89.63 v2(199.8,89.24)
  BOTTOM w0.102: v2(197.05,110.56) UV6.N13
  BOTTOM w0.14: UV1.AL31 201.41,89.24 v2(199.8,89.24)
FBA_D54: length 22.3
  IN1 w0.097: v2(197.05,108.96) 197.48,108.54 197.48,107.01 197.82,106.67 197.82,103.12 197.48,102.78 197.48,100.27 197.44,100.23 197.44,99.91 197.44,99.9 197.44,95.69 198.63,94.5 v2(198.63,94.09)
  BOTTOM w0.102: UV6.M11 v2(197.05,108.96)
  BOTTOM w0.14: 202.16,91.3 202.7,90.76 UV1.AK33
  BOTTOM w0.17: v2(198.63,94.09) 199.61,94.09 202.16,91.54 202.16,91.3
FBA_D55: length 24.2
  IN1 w0.097: v2(199.29,93.1) 199.6,93.41 199.6,94.13 198.25,95.49 198.25,100.79 198.25,100.8 198.25,109.11 197.99,109.38 197.44,109.38 v2(197.05,109.76)
  BOTTOM w0.102: v2(197.05,109.76) UV6.M13
  BOTTOM w0.14: 200.85,92.18 201.18,92.18 201.91,91.45 201.91,91.04 202.27,90.68 202.27,90.08 UV1.AK32
  BOTTOM w0.17: 200.85,92.18 200.8,92.24 200.77,92.24 199.91,93.1 v2(199.29,93.1)
FBA_D56: length 23.9
  IN6 w0.097: v2(206.9,91.98) 206.9,91.98 v2(206.9,91.98) ; v2(206.9,91.98) 206.9,92.95 200.65,99.2 200.65,103.48 199.2,104.92 198.13,104.92 197.7,104.49 196.6,104.49 196.1,103.99 194.35,103.99 193.85,103.5 v2(193.85,103.35)
  BOTTOM w0.089: v2(193.85,103.35) 193.46,102.96 UV6.U4
  BOTTOM w0.132: UV1.AD34 207.09,91.86 207.02,91.86 v2(206.9,91.98)
FBA_D57: length 30.8
  IN6 w0.097: v2(206.41,90.92) 206.52,90.82 207.06,90.82 207.32,91.08 207.32,93.09 201.43,98.98 201.43,103.49 199.64,105.28 194.97,105.28 193.47,103.78 193.47,101.37 v2(193.84,101)
  BOTTOM w0.089: UV6.U2 193.48,101.36 193.84,101 v2(193.84,101) ; v2(206.41,90.92) 206.56,90.77 206.98,90.77 207.28,90.48 207.28,90.07 UV1.AD32
FBA_D58: length 25.6
  IN6 w0.097: v2(194.65,103.32) 195.69,103.32 195.84,103.47 195.85,103.47 195.87,103.49 196.36,103.49 196.84,103.98 197.5,103.98 197.73,103.74 198.9,103.74 199.07,103.57 199.07,102.28 199.47,101.88 199.47,99.24 205.96,92.75 205.96,92.24 206.29,91.92 206.29,91.51 206,91.23 206,89.8 206.42,89.39 206.42,89.37 v2(206.42,89.36)
  BOTTOM w0.089: v2(194.65,103.32) 194.29,102.96 UV6.T4 ; UV1.AC30 208.22,88.05 207.84,88.44 207.58,88.44 207.33,88.69 207.33,88.84 207,89.18 206.6,89.18 206.42,89.36 v2(206.42,89.36)
FBA_D59: length 24.8
  IN6 w0.097: v2(194.65,101.75) 194.25,102.15 194.25,102.15 194.25,103.54 194.45,103.74 196.25,103.74 196.74,104.22 197.6,104.22 197.84,103.99 199.01,103.99 199.74,103.25 199.74,100 199.89,99.85 199.89,99.39 206.48,92.8 206.48,92.12 206.5,92.1 206.5,91.58 v2(206.91,91.18)
  BOTTOM w0.089: UV6.T2 194.26,101.36 v2(194.65,101.75) ; UV1.AD33 207.2,90.95 207.14,90.95 v2(206.91,91.18)
FBA_D60: length 20.5
  IN6 w0.097: v2(205.6,89.29) 205.04,89.84 203.27,89.84 200.07,93.04 200.07,93.29 195.06,98.31 195.06,100.3 195.06,100.31 195.06,100.32 195.29,100.55 195.31,100.55 195.31,100.55 195.6,100.55 195.86,100.81 195.86,101.93 196.25,102.32 v2(196.25,102.56)
  BOTTOM w0.089: UV1.AF31 206,88.89 v2(205.6,89.29) ; v2(196.25,102.56) UV6.N4
FBA_D61: length 15.9
  IN6 w0.097: v2(197.86,100.96) 197.44,100.96 197.07,100.59 197.07,98.14 202.24,92.97 202.6,92.97 203.84,91.72 v2(204.95,91.72)
  BOTTOM w0.089: v2(197.86,100.96) 197.05,100.96 UV6.N2 ; UV1.AG34 204.95,91.5 v2(204.95,91.72)
FBA_D62: length 19.2
  IN6 w0.097: v2(197.05,102.56) 196.66,102.16 196.66,101.23 195.85,100.41 195.85,98.14 203.69,90.3 205.32,90.3 v2(205.6,90.02)
  BOTTOM w0.089: UV1.AG32 205.23,89.65 v2(205.6,90.02) ; v2(197.05,102.56) UV6.M4
FBA_D63: length 16.5
  IN6 w0.097: v2(197.86,101.76) 196.64,100.55 196.64,97.97 203.8,90.81 v2(204.76,90.81)
  BOTTOM w0.089: v2(204.76,90.81) 204.84,90.81 UV1.AG33 ; v2(197.86,101.76) UV6.M2
FBA_DBI0: length 17.2
  IN6 w0.097: v2(217.27,87.58) 218.37,88.67 218.37,89.6 220.19,91.42 220.19,92.21 220.88,92.9 220.88,95.79 220.95,95.87 220.95,99.87 221.08,100 221.08,100.55 v2(221.49,100.96)
  BOTTOM w0.089: v2(217.27,87.58) 216.47,87.58 UV1.P30
  BOTTOM w0.102: UV5.D2 v2(221.49,100.96)
FBA_DBI1: length 30.8
  IN1 w0.097: v2(222.3,110.55) 222.49,110.55 223.19,111.24 224.56,111.24 225.42,110.38 225.42,109.39 225.29,109.26 225.29,108.71 225.06,108.48 225.06,107.98 224.59,107.51 224.59,104.31 225.19,103.7 225.19,100.16 224.11,99.08 224.11,97.51 224.27,97.35 224.27,97.17 224.11,97.01 224.11,96.9 224.28,96.72 224.42,96.72 224.57,96.88 224.73,96.88 224.85,96.77 224.85,96.61 224.69,96.45 224.69,96.31 224.88,96.12 224.88,91.9 224.56,91.58 224.56,90.98 224.14,90.56 223.08,90.56 222.74,90.22 222.74,89.2 222.29,88.76 v2(222.29,88.4)
  BOTTOM w0.089: UV1.F31 222.7,88.81 v2(222.29,88.4) ; v2(222.3,110.55) 221.92,110.16 UV5.D13
FBA_DBI2: length 29.9
  IN1 w0.097: v2(221.7,92.18) 218.86,92.18 215.67,95.38 215.35,95.38 212.66,98.07 211.95,98.07 210.67,99.35 210.67,109.94 210.97,110.24 212,110.24 212.49,109.76 v2(213.49,109.76)
  BOTTOM w0.089: v2(213.49,109.76) UV5.P13
  BOTTOM w0.17: v2(221.7,92.18) 222.08,92.18 222.7,91.56 UV1.F34
FBA_DBI3: length 13.3
  IN6 w0.097: v2(214.29,100.96) 214.75,100.49 214.75,99.14 216.74,97.15 216.74,92.96 v2(216.85,92.84)
  BOTTOM w0.089: v2(214.29,100.96) UV5.P2
  BOTTOM w0.17: UV1.M32 217.63,89.65 217.3,89.98 217.3,90.52 216.98,90.84 216.98,91.85 216.85,91.98 v2(216.85,92.84)
FBA_DBI4: length 19.6
  IN6 w0.097: v2(208.13,89.3) 208.13,89.71 208.41,89.99 209.23,89.99 210.34,91.09 210.34,92 210.51,92.17 210.51,94.97 207.37,98.11 207.37,99.93 206.28,101.03 206.28,101.16 205.3,102.14 203.89,102.14 v2(203.48,101.74)
  BOTTOM w0.089: v2(208.13,89.3) 207.7,88.88 UV1.AD31 ; UV6.D2 v2(203.48,101.74)
FBA_DBI5: length 25.2
  IN1 w0.097: v2(203.47,109.76) 203.09,109.38 203.09,107.98 203.42,107.65 203.42,105.19 203.06,104.84 203.06,101.93 203.07,101.92 203.07,101.6 203.07,101.6 203.07,96.68 203.91,95.84 203.91,93.45 202.72,92.25 202.72,89.96 201.83,89.07 201.83,87.9 v2(202.21,87.52)
  BOTTOM w0.089: UV1.AL29 202.17,87.52 v2(202.21,87.52) ; UV6.D13 203.86,110.15 v2(203.47,109.76)
FBA_DBI6: length 25.8
  IN1 w0.097: v2(197.94,93.1) 197.74,93.3 197.74,94.19 195.84,96.09 195.84,103.15 195.45,103.54 195.45,106.69 195.86,107.1 195.86,107.52 196.1,107.75 196.4,107.75 196.64,108 196.64,109.92 196.4,110.16 195.85,110.16 v2(195.45,110.56)
  BOTTOM w0.102: UV6.P13 v2(195.45,110.56)
  BOTTOM w0.14: 198.58,92.11 199.43,91.27 199.83,90.86 200.39,90.86 200.57,90.68 200.57,90.05 200.97,89.65 UV1.AM32
  BOTTOM w0.17: v2(197.94,93.1) 197.97,93.07 197.97,92.42 198.27,92.11 198.58,92.11
FBA_DBI7: length 22.5
  IN6 w0.097: v2(195.45,100.96) 195.06,101.35 195.06,102.76 195.29,102.98 195.74,102.98 195.96,103.2 195.96,103.2 195.98,103.22 196.44,103.22 196.94,103.73 197.39,103.73 198.28,102.84 198.28,102.35 198.47,102.15 198.81,102.15 199.05,101.92 199.05,97.36 200.92,95.49 202.65,95.49 205.47,92.67 205.47,92.18 v2(205.87,91.78)
  BOTTOM w0.089: UV1.AF34 205.87,91.38 v2(205.87,91.78) ; v2(195.45,100.96) UV6.P2
FBA_EDC0: length 17.1
  IN6 w0.097: v2(218.1,87.58) 218.1,88.06 218.61,88.57 218.61,89.35 220.52,91.27 220.52,91.97 221.29,92.74 221.29,95.55 221.35,95.61 221.35,99.47 221.88,100 221.88,100.55 v2(222.31,100.98)
  BOTTOM w0.089: v2(218.1,87.58) 218.1,88.45 UV1.M31
  BOTTOM w0.102: v2(222.31,100.98) UV5.C2
FBA_EDC1: length 29.6
  IN1 w0.089: 224.46,92.01 224.03,91.58
  IN1 w0.097: 224.46,92.01 224.46,95.29 224.48,95.31 224.48,95.96 223.71,96.73 223.71,99.24 224.33,99.87 224.33,102.87 224.57,103.11 224.57,103.71 224.14,104.14 224.14,108.2 224.51,108.57 224.8,108.57 225.04,108.82 225.04,109.19 224.64,109.59 224.64,110.01 224.3,110.36 224.3,110.82 224.12,110.99 223.66,110.99 223.47,110.8 223.47,110.31 223.33,110.17 222.72,110.17 v2(222.32,109.76) ; v2(221.47,88.39) 221.57,88.39 222.5,89.33 222.5,90.25 223,90.75 223.01,90.75 223.84,91.58 224.03,91.58
  BOTTOM w0.089: v2(221.47,88.39) 221.85,88.77 UV1.G31 ; UV5.C13 222.69,110.13 v2(222.32,109.76)
FBA_EDC2: length 33.3
  IN1 w0.097: v2(213.49,110.56) 213.05,110.12 212.53,110.12 212.06,110.59 210.78,110.59 210.78,110.59 210.68,110.59 210.24,110.15 210.24,98.25 213.31,95.18 214.67,95.18 216.19,93.66 216.19,92.87 217.25,91.81 221.88,91.81 v2(222.01,91.67)
  BOTTOM w0.089: v2(222.01,91.67) 222.02,91.66 222.02,91.47 222.68,90.81 222.92,90.81 223.29,90.45 UV1.E33 ; v2(213.49,110.56) UV5.R13
FBA_EDC3: length 13.2
  IN6 w0.097: v2(217.34,92.24) 216.76,92.24 216.32,92.68 216.32,96.98 213.93,99.37 213.93,100.52 v2(213.49,100.96)
  BOTTOM w0.089: v2(213.49,100.96) UV5.R2
  BOTTOM w0.17: v2(217.34,92.24) 217.34,91.03 217.7,90.67 UV1.M33
FBA_EDC4: length 19.9
  IN6 w0.097: v2(207.37,87.63) 207.37,87.81 207.76,88.2 207.76,89.66 208.34,90.24 209.16,90.24 210.09,91.17 210.09,94.83 206.95,97.96 206.95,99.92 205.7,101.16 205.7,101.24 205.18,101.76 v2(205.06,101.76)
  BOTTOM w0.089: v2(205.06,101.76) UV6.C2
  BOTTOM w0.102: v2(207.37,87.63) 207.37,88.34 206.86,88.85 UV1.AE31
FBA_EDC5: length 24.7
  IN1 w0.097: v2(204.26,110.56) 203.87,110.18 203.87,100.33 203.87,100.32 203.87,99.8 203.5,99.43 203.5,96.82 204.31,96 204.31,93.28 203.16,92.13 203.16,89.89 202.26,88.98 v2(202.26,88.45)
  BOTTOM w0.089: v2(204.26,110.56) 204.65,110.16 UV6.C13 ; v2(202.26,88.45) 202.6,88.11 UV1.AK30
FBA_EDC6: length 23.3
  IN1 w0.097: v2(195.45,109.76) 195.86,109.35 195.86,107.96 195.66,107.75 195.62,107.75 195.62,107.75 195.29,107.75 195.06,107.53 195.06,96.27 197.3,94.04 v2(197.3,93.99)
  BOTTOM w0.102: UV6.R13 v2(195.45,109.76)
  BOTTOM w0.14: UV1.AN33 199.92,90.45 199.15,91.22 199.01,91.22 198.59,91.64
  BOTTOM w0.17: 198.59,91.64 198.02,91.64 197.3,92.36 v2(197.3,93.99)
FBA_EDC7: length 20.7
  IN6 w0.097: v2(195.45,101.76) 195.45,101.98 195.85,102.37 195.85,102.71 196.08,102.94 197.31,102.94 197.45,102.8 197.45,102.25 197.54,102.16 198.06,102.16 198.26,101.96 198.26,100.47 198.23,100.44 198.23,97.57 200.74,95.07 202.5,95.07 204.92,92.65 v2(204.92,92.32)
  BOTTOM w0.089: 205.06,92.18 205.35,91.9 205.35,91.59 205.52,91.41 205.52,90.94 206,90.46 UV1.AF33 ; v2(195.45,101.76) UV6.R2
  BOTTOM w0.17: 205.06,92.18 v2(204.92,92.32)
FBA_SEN0: length 4.6
  TOP w0.089: RV353.2 v3(219.72,106.99) 218.58,108.12 v2(217.48,108.12)
  BOTTOM w0.089: UV5.J10 217.84,107.76 v2(217.48,108.12)
FBA_SEN2: length 6.8
  TOP w0.089: 198.76,111.86 199.11,111.51 199.11,110.17 199.04,110.11 v3(199.04,107.97) 199.04,107.21 v2(199.47,106.79)
  TOP w0.102: 198.76,111.86 RV366.2
  BOTTOM w0.102: UV6.J10 199.47,107.37 v2(199.47,106.79)
FBA_WCK01: length 23.4
  BOTTOM w0.089: UV1.K31 219.35,88.85 219.48,88.71 219.61,88.71 219.69,88.79 219.69,90.66 219.64,90.71 219.55,90.71 219.54,90.73 219.54,91.14 219.52,91.15 219.52,91.17 ; 222.41,104.05 222.29,103.93 222.29,103.69 222.01,103.41 221.73,103.41 221.58,103.56 221.41,103.56 221.29,103.44 221.29,103.27 221.53,103.03 221.82,103.03 UV5.D4
  BOTTOM w0.114: 220.05,92.25 220.05,92.23 220.08,92.21 220.08,92.01 219.52,91.45 219.52,91.17
  BOTTOM w0.17: 222.41,104.05 222.56,104.2 224.61,104.2 225.29,103.53 225.29,100.94 224.76,100.42 224.31,99.97 v4(222.57,98.22) 220.05,95.71 220.05,92.25
FBA_WCK01#: length 23.6
  BOTTOM w0.089: UV5.D5 222.04,103.91 222.04,104.15 222.1,104.21 ; 219.8,91.17 219.8,91.15 219.79,91.14 219.79,90.83 219.88,90.74 219.88,88.73 219.61,88.46 218.91,88.46 UV1.L30
  BOTTOM w0.114: 219.8,91.17 219.8,91.34 220.36,91.9 220.36,92.21 220.38,92.23 220.38,92.25
  BOTTOM w0.17: 222.1,104.21 222.42,104.53 224.75,104.53 225.62,103.66 225.62,100.8 224.55,99.73 v4(221.36,96.55) 220.38,95.57 220.38,92.25
FBA_WCK23: length 29.2
  IN6 w0.097: v2(213.53,103.36) 213.73,103.57 213.73,103.81 214.06,104.14 214.06,104.45 214.76,105.15 216.35,105.15 216.71,105.52 222.51,105.52 225.85,102.18 225.85,98.37 225.51,98.02 225.2,98.02 v2(225.02,97.84)
  BOTTOM w0.089: UV5.P4 213.89,103 v2(213.53,103.36)
  BOTTOM w0.17: v2(225.02,97.84) 224.89,97.96 224.31,97.96 221.25,94.9 221.25,91.83 221,91.58 UV1.H34
FBA_WCK23#: length 29.3
  IN6 w0.097: v2(214.29,103.36) 214.04,103.36 213.91,103.49 213.91,103.74 214.23,104.07 214.23,104.38 214.83,104.97 216.42,104.97 216.79,105.34 222.44,105.34 225.68,102.1 225.68,98.44 225.44,98.19 225.25,98.19 v2(225.02,98.42)
  BOTTOM w0.089: v2(214.29,103.36) UV5.P5
  BOTTOM w0.17: v2(225.02,98.42) 224.89,98.29 224.17,98.29 220.92,95.04 220.92,91.97 UV1.J34
FBA_WCK45: length 24.3
  IN1 w0.097: v2(206.44,98.58) 206.73,98.29 206.96,98.29 207.37,97.88 207.37,95.85 207.56,95.67 207.56,93.5 208.06,92.99 208.06,90.2 206.68,88.82 206.11,88.82 206.02,88.73 206.02,88.17 205.9,88.05 205.73,88.05 205.61,88.17 v2(205.61,88.45)
  BOTTOM w0.089: UV1.AG30 205.2,88.33 205.32,88.45 v2(205.61,88.45)
  BOTTOM w0.17: v2(206.44,98.58) 206.63,98.58 206.74,98.7 206.74,99.55 207,99.8 207,103.12 206.63,103.49 206.63,104 205.84,104.78 204.72,104.78 204.28,104.34 204.28,103.38 UV6.D4
FBA_WCK45#: length 24.5
  IN1 w0.097: v2(204.74,88.42) 205.16,88.85 205.69,88.85 205.83,88.99 206.61,88.99 207.89,90.27 207.89,92.92 207.38,93.42 207.38,95.6 207.2,95.78 207.2,97.81 206.89,98.12 206.56,98.12 v2(206.44,98)
  BOTTOM w0.089: v2(204.74,88.42) 205.16,88.85 UV1.AG31
  BOTTOM w0.17: v2(206.44,98) 206.51,98 207.07,98.56 207.07,99.41 207.33,99.67 207.33,103.26 206.96,103.63 206.96,104.14 205.98,105.11 204.59,105.11 203.95,104.48 203.95,103.85 UV6.D5
FBA_WCK67: length 21.1
  TOP w0.089: v2(196.36,104.78) 196.36,104.59 196.53,104.42 198.39,104.42 198.71,104.1 199.15,104.1 199.62,103.63
  TOP w0.17: v2(202.2,94.5) 202.07,94.62 202.07,95.51 201.33,96.25 200.58,96.25 198.9,97.94 198.9,99.27 199.45,99.83 199.45,101.9 199.62,102.07 199.62,103.63
  BOTTOM w0.089: UV6.P4 196.29,103.4 196.29,104.72 v2(196.36,104.78)
  BOTTOM w0.17: v2(202.2,94.5) 202.01,94.31 202.01,93.24 203.11,92.13 203.11,91.64 UV1.AJ34
FBA_WCK67#: length 21
  TOP w0.089: v2(195.86,104.44) 195.88,104.42 196.18,104.42 196.43,104.17 198.28,104.17 198.6,103.85 199.05,103.85 199.25,103.65 199.29,103.65 199.29,103.63
  TOP w0.17: 199.29,103.63 199.29,102.2 199.12,102.04 199.12,99.97 198.57,99.41 198.57,97.8 200.45,95.92 201.2,95.92 201.74,95.38 201.74,94.65 v2(201.56,94.47)
  BOTTOM w0.089: v2(195.86,104.44) 195.59,104.44 195.45,104.3 195.45,103.44 195.57,103.32 195.74,103.32 195.85,103.44 UV6.P5
  BOTTOM w0.17: UV1.AK34 202.78,91.33 202.78,92 201.68,93.1 201.68,94.34 201.56,94.46 v2(201.56,94.47)
FBB_CMD0: length 32.7
  BOTTOM w0.089: UV1.D13 224.8,73.4 224.8,72.73 225.01,72.53 226.89,72.53 227,72.41 227.32,72.41 227.65,72.08 227.68,72.08
  BOTTOM w0.17: UV9.G12 244.3,70.83 243.94,71.19 243.67,71.19 243.66,71.2 243.36,71.2 243.36,71.19 242.87,71.19 242.86,71.2 242.56,71.2 242.49,71.13 241.94,71.13 240.54,72.53 240.54,74.18 239.98,74.73 239.98,78.35 238.63,79.7 235.72,79.7 234.71,78.69 234.71,76.07 v3(233.3,74.66) 230.53,71.89 227.87,71.89 227.68,72.08
FBB_CMD1: length 28.6
  TOP w0.17: v2(242.19,71.54) 241.91,71.54 239.89,69.53 239.89,65.85 239.47,65.43 v3(236.2,65.43) 234.45,65.43 233.38,66.49 230.58,66.49 226.85,70.23 226.58,70.23 224.47,72.34 224.47,73.86 v2(224.09,74.24)
  BOTTOM w0.089: v2(242.19,71.54) 242.28,71.63 UV9.H10 ; UV1.E14 224.01,74.24 v2(224.09,74.24)
FBB_CMD2: length 32.2
  TOP w0.14: 223.56,74.37 223.3,74.62 222.81,74.62 v2(222.36,75.06)
  TOP w0.17: 223.56,74.37 223.56,72.78 230.96,65.38 232.32,65.38 232.76,64.94 239.68,64.94 240.34,65.59 v3(240.34,67.43) 240.34,69.34 241.75,70.75 242.06,70.75 243.13,71.81 v2(243.13,72)
  BOTTOM w0.089: v2(243.13,72) 243.5,71.63 UV9.H11 ; v2(222.36,75.06) 222.36,75.04 UV1.F14
FBB_CMD3: length 27.7
  BOTTOM w0.089: UV1.A12 227,72.75 227.48,72.75 227.68,72.56
  BOTTOM w0.17: 227.68,72.56 227.86,72.37 230.35,72.37 v3(230.65,72.68) 234.24,76.27 234.24,78.89 235.53,80.17 238.83,80.17 240.46,78.55 240.46,74.99 241.02,74.43 241.02,73.39 241.65,72.76 242.44,72.76 242.52,72.84 243.13,72.84 UV9.K11
FBB_CMD4: length 24.4
  TOP w0.089: 234.67,70.84 238.46,70.84 238.9,70.39 240.23,70.39 241.22,71.38 241.22,72.94 241.46,73.18 v2(242.21,73.18)
  TOP w0.17: v2(228.98,72.87) 228.98,71.43 229.36,71.05 229.36,70.57 229.12,70.33 229.12,69.35 229.86,68.61 232.19,68.61 232.85,69.27 233.46,69.27 v3(233.97,69.78) 234.3,70.11 234.3,70.47 234.67,70.84
  BOTTOM w0.089: UV1.B12 226.32,73.27 226.74,73.27 226.75,73.27 227.22,73.27 227.39,73.1 227.67,73.1 227.9,72.87 ; UV9.K10 242.69,73.21 242.24,73.21 242.21,73.18 v2(242.21,73.18)
  BOTTOM w0.17: 227.9,72.87 v2(228.98,72.87)
FBB_CMD5: length 29.7
  BOTTOM w0.089: UV1.C14 225.55,74.3 226.1,74.3 226.36,74.04 226.78,74.04 227.15,73.67 227.43,73.67
  BOTTOM w0.17: UV9.L12 243.91,73.63 241.85,73.63 241.5,73.97 241.5,74.63 240.93,75.21 240.93,78.74 239.03,80.65 v3(236.45,80.65) 235.3,80.65 233.65,79 233.65,76.35 230.66,73.36 227.74,73.36 227.43,73.67
FBB_CMD6: length 31.4
  IN1 w0.089: v2(241.99,74.1) 241.81,74.1 240.97,73.26 238.74,73.26 v2(238.32,72.84)
  BOTTOM w0.089: 227.25,73.99 226.94,74.3 226.51,74.3 226.16,74.65 UV1.B14 ; UV9.K4 238.32,72.83 v2(238.32,72.84)
  BOTTOM w0.17: 227.25,73.99 227.67,73.99 227.82,73.84 230.47,73.84 230.91,74.29 233.18,76.55 v3(233.18,77.94) 233.18,79.19 235.11,81.12 239.72,81.12 241.41,79.44 241.41,75.42 241.99,74.84 v2(241.99,74.1)
FBB_CMD7: length 28.9
  TOP w0.089: 234.63,76 235.06,76 235.5,76.44 239,76.44 239.17,76.27 v2(239.17,73.65)
  TOP w0.14: 223.36,75.48 222.33,75.48 222.2,75.61 222.2,75.8 222.33,75.92 v2(222.52,75.92)
  TOP w0.17: 223.36,75.48 223.77,75.07 v3(225.91,75.07) 226.96,75.07 227.53,75.64 227.77,75.64 228.26,75.15 228.44,75.15 228.75,75.45 228.75,75.63 228.26,76.12 228.26,76.36 228.5,76.6 228.74,76.6 229.11,76.23 229.29,76.23 229.59,76.54 229.59,76.71 229.22,77.08 229.22,77.33 229.45,77.55 233.1,77.55 233.22,77.68 233.22,78.24 233.35,78.37 233.76,78.37 233.88,78.24 233.88,76.13 234.01,76 234.63,76
  BOTTOM w0.089: v2(239.17,73.65) 238.75,73.23 UV9.K5
  BOTTOM w0.102: v2(222.52,75.92) 222.04,75.45 UV1.G15
FBB_CMD8: length 27.7
  TOP w0.17: v2(223.14,75.87) 223.36,75.87 223.77,75.45 226.67,75.45 v3(227.58,76.36) 229.25,78.03 231.92,78.03 232.74,78.85 233.4,78.85 234.29,79.74 238.59,79.74 239.74,78.59 239.74,72.83 239.36,72.45 238.98,72.45 238.57,72.04 v2(238.32,72.04)
  BOTTOM w0.089: UV9.J4 237.92,72.43 v2(238.32,72.04) ; v2(223.14,75.87) 222.75,75.48 UV1.F15
FBB_CMD9: length 28.3
  TOP w0.089: 234.63,71.63 237.69,71.63 237.9,71.84 237.9,73.12 238.02,73.25 239.03,73.25 239.16,73.12 v2(239.16,72.88)
  TOP w0.17: 234.63,71.63 233.74,71.63 233.55,71.45 233.55,70.81 233.27,70.53 233.27,69.87 233.15,69.74 232.83,69.74 232.7,69.87 232.7,70.11 232.58,70.24 232.28,70.24 232.16,70.11 232.16,69.25 232.03,69.12 231.66,69.12 231.53,69.25 231.53,69.52 231.41,69.65 231.01,69.65 230.89,69.52 230.89,69.25 230.76,69.12 230.39,69.12 230.26,69.25 230.26,71.43 230.14,71.56 229.58,71.56 229.46,71.69 229.46,72.16 229.58,72.28 229.97,72.28 230.1,72.41 230.1,73.2 229.97,73.33 v3(228.28,73.33) 227.66,73.33 226.31,74.67 223.72,74.67 223.32,75.07 v2(223.16,75.07)
  BOTTOM w0.089: UV1.E15 223.22,75.07 v2(223.16,75.07) ; UV9.J5 v2(239.16,72.88)
FBB_CMD10: length 32.3
  TOP w0.17: v2(231.74,78.47) 231.74,79.4 v3(232.06,79.71) 233.03,80.69 238.98,80.69 240.58,79.09 240.58,71.21 240.16,70.79 239,70.79 238.57,71.22 v2(238.33,71.22)
  BOTTOM w0.089: UV9.H4 238.33,71.22 v2(238.33,71.22)
  BOTTOM w0.17: v2(231.74,78.47) 231.74,76.45 230.14,74.85 227.48,74.85 227.43,74.9 227.18,74.9 227.06,75.01 224.78,75.01 224.4,75.39 UV1.D15
FBB_CMD11: length 26.2
  TOP w0.17: v2(232.68,79.32) 233.2,79.32 234.09,80.21 v3(234.63,80.21) 238.79,80.21 240.18,78.82 240.18,72.59 239.62,72.03 v2(239.17,72.03)
  BOTTOM w0.089: v2(239.17,72.03) 238.77,71.63 UV9.H5
  BOTTOM w0.17: UV1.A14 227.06,74.65 227.24,74.47 227.93,74.47 228.08,74.31 230.27,74.31 230.72,74.76 232.68,76.72 v2(232.68,79.32)
FBB_CMD12: length 28.5
  TOP w0.089: v2(237.51,70.43) 237.51,70.18 237.34,70.01 234.87,70.01 234.63,69.77
  TOP w0.17: 234.63,69.77 234.33,69.47 234.33,66.9 234.2,66.77 233.77,66.77 233.64,66.9 233.64,68.67 233.52,68.79 233.12,68.79 233,68.67 233,67.78 232.87,67.66 232.42,67.66 232.3,67.78 232.3,67.93 232.17,68.06 231.1,68.06 230.97,67.93 230.97,67.44 230.84,67.32 230.43,67.32 230.3,67.44 230.3,67.93 230.18,68.06 229.74,68.06 227.98,69.82 227.98,70.74 228.12,70.87 228.38,70.87 228.51,71 228.51,71.4 228.38,71.52 227.8,71.52 227.67,71.65 227.67,72.03 227.8,72.16 228.38,72.16 228.51,72.28 228.51,72.68 228.38,72.81 v3(226.52,72.81) 226.2,72.81 226.07,72.93 226.07,74.07 225.95,74.2 v2(224.78,74.2)
  BOTTOM w0.089: UV1.D14 224.78,74.27 v2(224.78,74.2) ; v2(237.51,70.43) UV9.G3
FBB_CMD13: length 31
  TOP w0.17: v2(235.91,72.83) 235.88,72.8 234.63,72.8 234.51,72.92 234.51,75.4 234.38,75.53 233.96,75.53 233.83,75.4 233.83,73.2 233.71,73.07 233.26,73.07 233.13,73.2 233.13,74.34 233.01,74.47 230.89,74.47 230.76,74.6 230.76,74.99 230.89,75.12 233.1,75.12 233.22,75.24 233.22,75.66 233.1,75.79 231.59,75.79 231.46,75.92 231.46,76.26 231.59,76.39 v3(232.3,76.39) 233.11,76.39 233.24,76.51 233.24,76.95 233.11,77.08 230.43,77.08 230.3,76.95 230.3,76.57 230.52,76.35 v2(230.52,75.9)
  BOTTOM w0.132: v2(235.91,72.83) UV9.J2
  BOTTOM w0.17: v2(230.52,75.9) 229.94,75.33 227.45,75.33 227.32,75.45 UV1.A15 ; RV418.1 233.62,72.26 234.19,72.83 v2(235.91,72.83)
FBB_CMD14: length 33.2
  TOP w0.17: v2(236.71,72.03) 236.42,72.32 233.06,72.32 232.93,72.2 232.93,70.91 232.8,70.79 232.08,70.79 231.95,70.91 231.95,71.36 231.83,71.48 231.17,71.48 231.04,71.61 231.04,71.98 231.17,72.11 232.22,72.11 232.35,72.23 232.35,72.64 232.22,72.77 230.71,72.77 230.58,72.89 230.58,73.25 230.71,73.38 232.23,73.38 232.36,73.5 232.36,73.86 232.23,73.99 227.84,73.99 227.71,74.11 227.71,74.52 227.84,74.65 v3(229.77,74.65) 230.14,74.65 230.26,74.77 230.26,75.17 230.14,75.29 229.72,75.29 229.59,75.42 v2(229.59,75.81)
  BOTTOM w0.089: v2(236.71,72.03) 236.66,71.98 235.24,71.98 234.63,71.37
  BOTTOM w0.132: v2(236.71,72.03) UV9.J3
  BOTTOM w0.17: 234.63,71.37 234.36,71.1 234.36,70.26 233.59,69.49 RV410.1 ; UV1.B15 226.39,75.84 227.41,75.84 227.44,75.81 v2(229.59,75.81)
FBB_CMD15: length 30.1
  IN1 w0.089: v2(237.5,74.43) 237.91,74.84 239.7,74.84 240.51,75.65 v2(241.83,75.65)
  BOTTOM w0.089: v2(237.5,74.43) 237.11,74.04 UV9.L3 ; 227.48,76.25 227.38,76.15 226.64,76.15 226.16,76.62 225.73,76.62 UV1.C17
  BOTTOM w0.17: v2(241.83,75.65) 241.89,75.7 241.89,79.63 239.92,81.6 233.85,81.6 231.26,79 231.26,78.03 v3(230.53,77.31) 229.94,76.72 229.02,76.72 228.55,76.25 227.48,76.25
FBB_CMD16: length 28
  BOTTOM w0.089: UV1.D18 224.74,77.61 225.2,77.61 225.64,77.17 225.64,77.05 225.87,76.83 226.27,76.83 226.63,76.46
  BOTTOM w0.17: UV10.G12 243.89,88.44 242.48,88.44 241.55,87.51 241.55,84.55 239.08,82.07 v3(238.42,82.07) 233.64,82.07 230.78,79.21 230.78,78.23 229.71,77.16 228.91,77.16 228.4,76.65 227.41,76.65 227.22,76.46 226.63,76.46
FBB_CMD17: length 41.7
  BOTTOM w0.089: UV1.E18 223.6,78.18 223.87,78.45 225.42,78.45 225.6,78.63 225.6,79.04 225.87,79.3 227.06,79.3 227.25,79.5
  BOTTOM w0.17: UV10.H10 242.58,89.67 240.87,91.37 240.87,96.67 238.91,98.63 235.13,98.63 v3(231.99,95.49) 231.18,94.68 231.18,83.08 228.25,80.15 227.9,80.15 227.25,79.5
FBB_CMD18: length 43.4
  BOTTOM w0.089: 227.24,79.12 226.65,78.53 226.33,78.53 226.26,78.46 225.83,78.46 225.65,78.27 224.25,78.27 224,78.02 224,77.69 223.81,77.5 223.2,77.5 UV1.F18
  BOTTOM w0.17: 227.24,79.12 227.84,79.71 228.5,79.71 231.66,82.87 v3(231.66,83.23) 231.66,94.48 235.33,98.15 238.72,98.15 240.29,96.58 240.29,91.39 242.44,89.23 243.08,89.23 UV10.H11
FBB_CMD19: length 38.2
  BOTTOM w0.17: UV10.K11 243.13,90.88 242.25,90.88 241.38,91.75 241.38,96.83 239.11,99.1 234.93,99.1 230.71,94.88 v3(230.71,93.23) 230.71,83.65 229.72,82.66 229.72,82.2 228.23,80.71 228.04,80.71 226.97,79.65 UV1.A20
FBB_CMD20: length 38.2
  BOTTOM w0.17: UV1.B20 226.41,80.06 226.92,80.06 229.11,82.24 229.11,82.84 230.23,83.96 230.23,95.08 234.74,99.58 v3(239.33,99.58) 241.89,97.02 241.89,92.09 UV10.K10
FBB_CMD21: length 28.9
  TOP w0.17: v2(243.92,91.64) 243.59,91.64 241.1,89.15 v3(241.1,86.17) 241.1,84.08 238.53,81.52 230.94,81.52 229.39,79.97 v2(229.39,78.95)
  BOTTOM w0.132: UV10.L12 244.31,92.04 v2(243.92,91.64)
  BOTTOM w0.17: UV1.C18 225.37,77.95 225.78,77.54 226.91,77.54 227.29,77.92 227.84,77.92 228.87,78.95 v2(229.39,78.95)
FBB_CMD22: length 24.6
  TOP w0.17: v2(227.56,78.87) 227.5,78.94 227.5,80.29 v3(228.28,81.07) 230.72,83.51 230.72,84.47 230.89,84.64 232.19,84.64 232.36,84.81 232.36,85.15 232.19,85.32 230.89,85.32 230.72,85.49 230.72,85.99 230.85,86.12 231.55,86.12 231.68,86.24 231.68,89.27 233.38,90.97 234.63,90.97 234.75,90.85 237.45,90.85 v2(237.46,90.87)
  BOTTOM w0.089: UV1.B18 226.15,77.95 226.49,78.29 226.78,78.29 227.37,78.87 v2(227.56,78.87)
  BOTTOM w0.132: UV10.K4 237.51,90.87 v2(237.46,90.87)
FBB_CMD23: length 46.3
  TOP w0.17: v2(222.31,78.36) 222.76,78.81 223.1,78.81 223.1,78.82 223.34,78.82 225.98,81.46 225.98,81.68 228.65,84.35 228.65,87.08 227.25,88.48 227.25,89.71 227.09,89.87 227.09,90.76 227.53,91.21 227.53,92.91 228.65,94.03 230.72,94.03 231.6,94.91 231.6,97.34 v3(232.68,98.42) 234.2,99.93 238.55,99.93 241.33,97.16 241.33,92.67 239.47,90.81 v2(239.12,90.81)
  BOTTOM w0.089: UV10.K5 238.71,91.22 v2(239.12,90.81)
  BOTTOM w0.102: UV1.G18 v2(222.31,78.36)
FBB_CMD24: length 47.4
  TOP w0.14: 237.91,91.91 237.91,90.52 v2(238.35,90.08)
  TOP w0.17: v2(221.53,77.55) 221.89,77.19 223.15,77.19 223.89,77.92 224.79,77.92 225.97,79.1 225.97,80.2 229.77,83.99 229.77,89.48 228.5,90.75 228.5,92.44 229.11,93.05 231.09,93.05 232.55,94.51 232.55,96.94 234.45,98.84 238.14,98.84 240.41,96.57 v3(240.41,93.71) 240.41,93.05 239.51,92.15 238.15,92.15 237.91,91.91
  BOTTOM w0.089: v2(238.35,90.08) 237.96,90.47 UV10.J4
  BOTTOM w0.102: UV1.G17 221.53,77.52 v2(221.53,77.55)
FBB_CMD25: length 46.2
  TOP w0.17: v2(238.31,90.87) 239.02,91.58 239.7,91.58 240.85,92.73 240.85,96.96 238.42,99.39 234.33,99.39 232.08,97.14 v3(232.08,95.84) 232.08,94.71 230.92,93.55 228.85,93.55 228.02,92.72 228.02,89.02 229.25,87.79 229.25,84.17 225.49,80.41 225.49,79.26 224.73,78.49 223.92,78.49 223.08,77.65 v2(222.31,77.65)
  BOTTOM w0.089: v2(222.31,77.65) 222.31,77.59 UV1.F17 ; UV10.J5 v2(238.31,90.87)
FBB_CMD26: length 29.9
  TOP w0.17: v2(237.5,90.06) 237.92,89.65 239.6,89.65 240.41,88.83 240.41,84.25 238.15,81.99 v3(236.48,81.99) 230.66,81.99 228.91,80.23 228.91,78.9 226.34,76.34 224.49,76.34 224.04,75.89 v2(223.97,75.89)
  BOTTOM w0.089: v2(223.97,75.89) 223.99,75.89 UV1.D16
  BOTTOM w0.132: v2(237.5,90.06) 237.52,90.06 UV10.H4
FBB_CMD27: length 35.6
  BOTTOM w0.17: UV10.H5 239.75,90.7 239.75,96.41 238.48,97.68 235.52,97.68 232.13,94.29 v3(232.13,85.87) 232.13,82.66 228.88,79.41 228.69,79.41 227.67,78.39 227.24,78.39 UV1.A18
FBB_CMD28: length 26.8
  TOP w0.17: v2(237.51,88.47) 237.64,88.59 239.51,88.59 239.82,88.29 239.82,85.19 237.15,82.52 v3(231.15,82.52) 230.42,82.52 228.42,80.53 228.42,79.09 226.08,76.75 v2(224.02,76.75)
  BOTTOM w0.089: v2(224.02,76.75) 224.02,76.76 UV1.D17
  BOTTOM w0.132: v2(237.51,88.47) 237.5,88.47 237.11,88.85 UV10.G3
FBB_CMD29: length 24.9
  TOP w0.17: RV414.1 235.79,89.96 v2(235.89,90.06)
  BOTTOM w0.089: 234.63,89.95 234.74,90.06 v2(235.89,90.06)
  BOTTOM w0.102: UV10.J2 236.31,90.19
  BOTTOM w0.132: v2(235.89,90.06) 236.18,90.06 236.31,90.19
  BOTTOM w0.17: 234.63,89.95 233.86,89.95 233.71,89.81 232.74,89.81 232.61,89.68 232.61,89.3 232.74,89.18 233.69,89.18 233.82,89.05 233.82,88.58 233.69,88.45 v3(233,88.45) 232.74,88.45 232.61,88.32 232.61,87.92 232.74,87.79 233.31,87.79 233.44,87.66 233.44,87.41 232.61,86.58 232.61,82.4 229.8,79.6 229.8,78.6 229.24,78.03 228.58,78.03 228.02,77.47 227.32,77.47 227,77.15 UV1.A17
