# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA_CHG: length 17.6
  TOP w0.254: PR316.2 55.14,11.76 PC322.1 56.06,11.71 56.06,10.93 56.36,10.63 56.36,10.39 56.6,10.14 57.39,10.14 v3(58.04,10.79) 58.07,10.82 58.07,11.2 57.79,11.48 PC327.2 58.64,12.58 58.64,14.16 v2(58.24,14.55) ; PC330.1 PC332.2 54.25,23.06 v2(54.89,23.06) 55.06,23.22 55.65,23.22 PC333.1
  IN1 w0.254: v2(54.89,23.06) 54.89,21.05 54.42,20.58 v2(54.42,17.79)
  vias: v2(54.42,16.52) v2(55.11,17.11) v2(55.82,17.79) v2(55.82,16.52)
V1N: length 33.6
  TOP w0.14: v2(149.8,104.91) v1(150.5,104.91)
  IN1 w0.254: v2(149.8,104.91) 149.8,103.97 147.68,101.85 147.68,101.06 143.7,97.09 131.29,97.09 129.97,98.41 v2(126.58,98.41)
  BOTTOM w0.254: PR1219.2 150.05,105.16 v2(149.8,104.91) ; PR1203.2 127.76,98.28 126.71,98.28 v2(126.58,98.41) 126.18,98.81 PR1213.1 PR1212.1
V2N: length 38.5
  TOP w0.14: v2(149.86,112.59) v1(150.51,112.59)
  IN1 w0.254: v2(149.86,112.59) 149.86,111.77 146.13,108.04 144.43,108.04 144.14,107.75 144.14,105.93 143.69,105.47 143.69,101.66 141.06,99.03 133.02,99.03 131.42,100.63 127.07,100.63 v2(126.85,100.41)
  BOTTOM w0.254: PR1207.2 127.66,100.34 126.92,100.34 v2(126.85,100.41) 126.54,100.71 125.74,100.71 PR1215.1 PR1214.1 ; PR1221.2 v2(149.86,112.59)
V3N: length 46.7
  TOP w0.14: v2(158.62,105.99) 158.85,105.76 v1(158.85,105.37)
  IN1 w0.254: v2(126.3,95.72) 126.33,95.69 127.12,95.69 127.72,95.08 129.96,95.08 130.53,95.66 133.33,95.66 133.96,96.29 145.11,96.29 148.43,99.6 156.49,99.6 157.93,101.04 157.93,105.29 v2(158.62,105.99)
  BOTTOM w0.254: PR1217.1 125.67,96.67 PR1216.1 125.68,96.54 126.3,95.92 v2(126.3,95.72) 126.33,95.69 127.7,95.69 128.07,96.06 PR1211.2 ; v2(158.62,105.99) 158.18,105.55 PR1223.2
VBATT: length 36.6
  IN6 w0.254: v2(52.57,19.91) 52.6,19.94 52.6,20.53 52.3,20.84 51.9,20.84 51.45,20.39 50.81,20.39 50.42,20.78 48.76,20.78 47.94,21.61 39.99,21.61 38.13,23.46 37.9,23.46 35.83,23.46 35,22.64 30.85,22.64 30.33,22.13 28,22.13 27.74,22.39 26.26,22.39 25.97,22.68 v2(25.97,22.87)
  BOTTOM w0.254: PR320.2 55.94,22.61 54.32,20.99 53.18,20.99 v3(52.97,20.79) 52.69,20.51 52.69,20.03 v2(52.57,19.91) 52.46,19.8 51.96,19.8 51.5,20.26 PD302.2
VBUS_ACOK: length 139.9
  TOP w0.14: PR280.2 v2(18.23,8.39) ; v1(26.84,98.33) 26.67,98.17 v2(26.67,97.24) ; PQ229.1 23.85,28.69 21.44,28.69 v2(20.92,28.16)
  TOP w0.254: v2(24.08,5.63) 25.07,4.64 PR262.1
  IN2 w0.099: v2(18.23,8.39) 17.59,7.76 9.78,7.76 7.49,10.04 7.49,13.34 8.76,14.61 11.05,14.61 14.23,17.79 17.31,17.79 18.3,18.78 18.3,20.51 19.25,21.46 v2(20.14,21.46)
  IN5 w0.099: v2(18.23,8.39) 23.43,8.39 24.08,7.74 v2(24.08,5.63) ; v2(26.67,97.24) 25.96,97.24 23.78,95.06 23.32,95.06 21.63,93.37 21.63,90.62 22.65,89.6 22.65,84.4 22.4,84.16 22.4,79.46 20.75,77.81 20.75,63.01 18.05,60.31 18.05,42.3 20.29,40.07 20.29,32.57 20.96,31.89 20.96,28.21 v2(20.92,28.16) 21.06,28.03 21.06,26.07 22.07,25.06 22.07,21.37 21.87,21.17 20.43,21.17 v2(20.14,21.46)
  BOTTOM w0.254: PR267.1 v2(26.67,97.24) ; v2(20.14,21.46) 20.03,21.57 20.03,22.35 19.49,22.89 18.59,22.89 PR255.1 PC217.1 18.54,21.93 PR258.2 17.13,21.41 16.62,21.41 16.42,21.6 PU202.1
VBUS_HV_DIS#: length 349.7
  TOP w0.14: UE3.B2 295.52,11.28 v2(295.36,11.45)
  IN5 w0.099: v2(10.85,15.81) 10.58,15.81 10.07,16.32 8.41,16.32 7.69,17.03 7.69,17.96 9.61,19.87 14.89,19.87 15.71,20.69 15.71,23.91 16.52,24.72 17.63,24.72 19.18,26.27 v2(19.18,28.12)
  IN6 w0.089: 101.98,8.79 101.89,8.7 99.1,8.7 98.47,8.07 97.55,8.07 97.2,7.72 96.2,7.72 95.73,8.19 94.99,8.19 94.65,7.85 94.65,7.18 94.4,6.93 93.7,6.93 93.52,6.75 92.9,6.75 92.53,7.11 92.53,7.41 92.44,7.5 92.44,7.58 92.23,7.79 91.58,7.79 91.24,7.46 91.24,6.87 90.98,6.61 90.57,6.61 89.93,5.97 89.37,5.97 88.84,5.44 88.3,5.44 87.63,4.77 87.26,4.77 86.81,5.23 85.99,5.23 85.59,5.63 84.63,5.63 84.16,5.17 83.72,5.17 83.29,5.6 83.29,7.41 83.1,7.6 82.01,7.6 81.98,7.63 80.38,7.63 80.08,7.93 78.66,7.93 77.58,6.84 75.92,6.84 75.39,7.37 75.39,7.4 75.06,7.73
  IN6 w0.099: v2(293.58,8.62) 293.21,8.62 292.07,7.48 283.91,7.48 282.82,6.39 273.61,6.39 272.54,7.46 262.81,7.46 262.47,7.8 256.98,7.8 256.25,7.07 246.73,7.07 245.94,7.07 245.15,6.27 243.8,6.27 243.03,7.04 238.93,7.04 237.96,6.08 228.11,6.08 226.61,7.58 213.4,7.58 210.79,10.19 200.32,10.19 199.47,11.04 187.8,11.04 186.49,9.74 174.79,9.74 174.34,10.19 171.18,10.19 169.38,8.39 157.68,8.39 156.91,7.63 155.5,7.63 155.34,7.79 152.27,7.79 151.8,7.32 149.57,7.32 146.42,10.48 126.75,10.48 126.5,10.23 118.14,10.23 117.48,9.57 107.69,9.57 107.2,9.09 106.15,9.09 105.85,9.39 102.58,9.39 101.98,8.79 ; 75.06,7.73 73.03,7.73 71.62,9.14 69.79,9.14 68.07,10.86 64.62,10.86 63.73,11.74 60.69,11.74 59.92,10.97 58.2,10.97 57.16,12.01 55.63,12.01 55.27,12.38 55.26,12.38 54.3,13.33 54.3,15.55 53.74,16.1 53.74,17.84 51.67,19.91 50.61,19.91 50.22,20.3 41.7,20.3 40.87,21.13 34.87,21.13 33.9,22.09 31.19,22.09 30.54,21.44 29.6,21.44 28.72,20.57 27.21,20.57 22.48,15.83 10.87,15.83 v2(10.85,15.81)
  BOTTOM w0.14: v2(295.36,11.45) 295.36,10.69 293.58,8.91 v2(293.58,8.62) ; PR290.1 20.31,29.89 19.18,28.76 v2(19.18,28.12)
  BOTTOM w0.254: PD211.1 5.65,14.99 6.61,14.04 8.36,14.04 v3(8.6,14.28) 9.32,14.28 v2(10.85,15.81) 10.85,16.35 10.55,16.65 PR270.2
VBUS_LPS_OVP: length 36.7
  TOP w0.254: v2(20.02,25.51) 20.98,25.51 21.13,25.66 v1(21.93,25.66) 22.08,25.66 22.73,25.02 24.52,25.02 25.02,25.51 PR247.2 PR241.1 PR27.1
  IN6 w0.099: v2(6.18,18.33) 6.17,18.34 6.17,18.91 7.24,19.97 8.61,19.97 10.01,21.37 11.38,21.37 13.12,23.11 14.21,23.11 15.8,24.7 17.48,24.7 18.36,25.58 19.95,25.58 v2(20.02,25.51)
  BOTTOM w0.254: v2(20.02,25.51) 20.16,25.65 20.16,26.87 20.43,27.14 20.43,29.08 20.72,29.37 22.04,29.37 PC213.1 22.92,28.84 23.38,28.38 PU201.7 ; PD201.2 3.3,17.28 3.96,17.93 5.78,17.93 v2(6.18,18.33)
VCC0V9_LVR_OUT: length 2.2
  IN2 w0.254: v2(25.4,40.99) 25.41,41 v2(26.05,41) ; v2(24.76,38.38) v2(24.11,38.38)
  BOTTOM w0.203: UT1.H18 25.06,38.07 v2(24.76,38.38) ; UT1.F18 24.4,38.07 24.11,38.36 v2(24.11,38.38)
  vias: v3(24.09,39.07)
VCC0V9_SVR: length 2.9
  IN4 w0.254: v2(26.06,41.64) 25.59,42.11 23.33,42.11
  vias: v1(23.5,41.01) v2(21.9,46.97) v2(22.48,47.13) v2(22.47,46.54) v2(24.11,40.99) v2(24.11,40.34) v2(24.11,39.69) v2(26.71,41.64)
VCC1V8A_TBTA_LDO: length 8.4
  BOTTOM w0.203: v1(12.49,31.35) 13.44,31.35 RT246.2 13.72,31.07 14.35,31.7 14.35,32.2 13.97,32.58 13.97,34 13.8,34.18 13.33,34.18 13.11,34.4 CT151.1 12.49,34.69 11.3,35.87 UT4.K1
VCC1V8D_TBTA_LDO: length 2.5
  BOTTOM w0.081: 11.29,41.35 11.29,41.16 10.8,40.67 UT4.A2
  BOTTOM w0.14: CT152.1 11.01,42.11 v3(11.28,41.84) 11.38,41.74 11.38,41.59 11.29,41.5 11.29,41.35
VCC3V3_FLASH: length 42.9
  TOP w0.305: RT226.1 11.7,37.05 v2(11.79,37.14) ; v2(8.05,43.99) 8.43,43.61 RT192.1 RT227.1
  TOP w0.356: RT193.1 13.44,44 v2(13.69,44.26)
  IN2 w0.508: v2(8.05,43.99) 8.05,43.84 7.54,43.33 6.92,43.33 6.35,43.9 5.15,43.9 3.19,41.94 3.19,37.74 2.76,37.32 v2(2.49,37.32)
  IN3 w0.457: v2(18.61,35.31) 18.53,35.24 18.53,28.08 v2(18.54,28.07)
  IN3 w0.508: v2(8.05,43.99) 8.88,43.16 11.23,43.16 12.32,44.26 v2(13.69,44.26)
  BOTTOM w0.254: v2(11.79,37.14) 11.76,37.14 11.49,37.42 UT4.G1
  BOTTOM w0.305: RT169.1 RT168.1 10.42,43.42 10.16,43.67 10.16,44.12 10.42,44.38 12.37,44.38 12.93,43.82
  BOTTOM w0.356: RT189.2 2.49,36.53 v2(2.49,37.32) ; v2(18.61,35.31) 18.63,35.29 RT170.1
  BOTTOM w0.508: v2(18.54,28.07) 17.91,28.7 13.48,28.7 12.7,27.92 12.7,27.44
  vias: v1(12.49,42.67) v2(12.21,41.19)
VCC3V3_TBT_SX: length 2
  TOP w0.14: CT145.1 11.05,35.68 v2(10.28,36.46)
  BOTTOM w0.081: UT4.H2 10.74,36.92 v2(10.28,36.46)
VCC5V0_SYS: length 6.1
  IN6 w0.508: v2(7.29,36.95) 6.95,36.95 6.61,37.3 6.61,38.01 6.05,38.57 6.05,41.77 v2(6,41.82)
  BOTTOM w0.203: UT4.H10 7.26,36.92 v2(7.29,36.95)
  vias: v1(3.66,37.95) v2(5.4,43.29) v2(5.4,42.67) v2(5.4,42.08) v2(5.97,43.06) v2(5.97,42.44)
VCC_3V3_PCIE: length 1.1
  TOP w0.254: CT99.1 25.98,38.31 v2(26.06,38.39)
  BOTTOM w0.254: v2(26.06,38.39) UT1.L16
VCC_3V3_USB2: length 1.1
  TOP w0.254: CT100.1 25.95,38.93 v2(26.06,39.04)
  BOTTOM w0.254: v2(26.06,39.04) UT1.J16
VCC_SENSE: length 47.1
  TOP w0.14: v2(152,95.27) 152,95.83 v1(151.35,96.49)
  IN6 w0.254: v2(117.22,98.88) 117.22,99.69 117.62,100.08 119.66,100.08 120.32,100.75 124.98,100.75 125.27,101.04 127.56,101.04 127.84,100.76 129.4,100.76 129.68,101.04 134.18,101.04 136.71,98.51 143.15,98.51 145.62,96.03 149.85,96.03 151.14,94.74 151.73,94.74 152,95.01 v2(152,95.27)
  BOTTOM w0.254: v2(152,95.27) 151.99,95.27 151.84,95.12 151.84,93.93 152.7,93.07 RH198.2 ; v2(117.22,98.88) 117.06,98.71 PC1130.2 PR1142.1
VCCGT_B+:
  vias: v1(104.45,81.86) v2(105.36,76.65) v2(105.36,76.02) v2(105.5,74.93) v2(105.51,74.28) v2(105.51,73.64) v2(105.51,72.82) v2(105.93,77.03) v2(105.93,76.4) v2(105.93,75.76) v2(105.91,70.21) v2(106.05,70.81) v2(106.21,82.55) v2(106.2,81.9) v2(106.22,81.26) v2(106.17,74.93) v2(106.17,74.28) v2(106.17,73.62) v2(106.16,72.82) v2(106.27,85.66) v2(106.27,85.02) v2(106.27,84.39) v2(106.27,83.75) v2(106.26,80.48) v2(106.45,69.95) v2(106.62,70.56) v2(106.81,83.32) v2(106.91,81.92) v2(106.91,81.21) v2(106.95,80.5) v2(106.96,82.56) v2(107.05,69.95)
VCCGT_SENSE: length 58.3
  TOP w0.14: v1(148.82,96.43) 148.82,95.52 v2(149.15,95.2)
  TOP w0.254: v2(109.73,103.7) PR1113.1 PC1106.1
  IN6 w0.254: v2(109.73,103.7) 110.43,103 110.43,101 110.97,100.47 114.59,100.47 116.66,98.4 119.46,98.4 119.93,97.93 121.02,97.93 122.06,98.97 125.07,98.97 126.11,97.93 127.07,97.93 128.76,99.62 133.88,99.62 136.14,97.36 142.63,97.36 144.92,95.07 149.02,95.07 v2(149.15,95.2)
  BOTTOM w0.254: RH204.2 154.73,88.82 149.48,94.08 149.47,94.08 149.31,94.23 149.31,95.03 v2(149.15,95.2)
VCCIO_SENSE: length 2.9
  TOP w0.254: v2(173.12,68.36) 173.16,68.4 v3(173.16,68.89) 172.89,69.16 172.59,69.16 171.98,69.77 PR808.2
  BOTTOM w0.254: v2(173.12,68.36) 173.48,68.72 UH1.H14
VCCSA_SENSE: length 67.1
  TOP w0.14: PC1118.2 124.91,106.26 ; v2(177.5,92.77) v1(176.79,92.77)
  TOP w0.254: 124.91,106.26 v2(124.22,106.26)
  IN6 w0.254: v2(177.5,92.77) 177.33,92.77 176,91.44 172.18,91.44 171.5,92.11 171.5,92.8 170.84,93.46 159.41,93.46 152.78,100.08 142.55,100.08 142.2,99.74 137.53,99.74 135.6,101.67 135.6,102.64 134.35,103.88 130.61,103.88 129.55,102.82 124.77,102.82 123.74,103.85 123.74,105.77 v2(124.22,106.26)
  BOTTOM w0.254: v2(177.5,92.77) 178,92.77 RH202.2 ; PR1128.2 124.21,106.24 v2(124.22,106.26)
VCCST_PWRGD_CPU: length 6.6
  TOP w0.089: RH154.2 178.31,67.78 v3(179.33,67.78)
  TOP w0.102: RH154.2 177.78,67.51 177.18,68.11 175.63,68.11 175.15,67.62 v2(173.87,67.62)
  BOTTOM w0.076: UH1.H13 173.51,67.99 v2(173.87,67.62)
VDD_1.2V: length 6.1
  TOP w0.14: v1(288.98,27.9) 289.46,27.9 v2(289.81,27.56)
  TOP w0.254: v2(289.81,27.56) 289.54,27.29 PR603.2
  BOTTOM w0.203: PC610.1 289.94,26.49 PR601.1 288.99,26.73 289.31,27.05 289.31,27.5 289.07,27.75 PU600.11
  BOTTOM w0.254: v2(289.81,27.56) 290.13,27.23 PC610.1
VSS_SENSE: length 47
  TOP w0.14: v2(151.38,95.27) 151.38,94.64 v1(151.64,94.38)
  TOP w0.203: PC1107.1 117.54,100.72 v2(117.16,101.1) 117.16,101.16 116.92,101.41 116.92,102.19 117,102.27 PU1100.18
  IN6 w0.254: v2(117.16,101.1) 117.79,100.47 119.53,100.47 120.21,101.14 124.87,101.14 125.12,101.39 127.71,101.39 127.99,101.11 129.25,101.11 129.53,101.39 134.33,101.39 136.86,98.86 143.29,98.86 145.77,96.39 150.26,96.39 v2(151.38,95.27)
  BOTTOM w0.254: RH465.2 154.73,91.61 153.65,91.61 151.49,93.77 151.49,95.17 151.39,95.27 v2(151.38,95.27)
VSSGT_SENSE: length 63.7
  TOP w0.14: v2(149.84,95.2) 149.84,94.67 v1(149.53,94.36)
  TOP w0.203: PU1100.6 112.68,106.09 v2(112.65,106.05)
  TOP w0.254: PC1109.1 112.27,105.86 112.46,106.05 v2(112.65,106.05)
  IN6 w0.254: v2(112.65,106.05) 111.19,104.59 109.41,104.59 109.09,104.28 109.09,103.39 110.05,102.43 110.05,100.88 110.82,100.11 114.45,100.11 116.52,98.04 119.31,98.04 119.78,97.57 121.17,97.57 122.2,98.6 124.94,98.6 125.96,97.57 127.22,97.57 128.91,99.26 133.74,99.26 135.99,97.01 142.48,97.01 144.77,94.71 149.36,94.71 v2(149.84,95.2)
  BOTTOM w0.254: RH471.2 154.73,90.28 153.79,90.28 149.68,94.38 149.68,95.04 149.84,95.2 v2(149.84,95.2)
VSSIO_SENSE: length 2.5
  TOP w0.254: v2(172.29,68.75) 171.79,68.75 v3(171.77,68.78) 171.34,69.21 171.29,69.21 PR809.2
  BOTTOM w0.254: v2(172.29,68.75) 172.8,68.75 UH1.J14
VSSSA_SENSE: length 73.9
  TOP w0.14: v2(177.5,92.17) 178.14,92.17 v1(178.56,92.59)
  TOP w0.203: PU1100.31 120.76,106.09 120.93,105.91 121.35,105.91 121.62,106.18 121.62,106.77 121.92,107.07 121.92,107.98 v2(121.84,108.06) 121.97,108.19 122.39,108.19 PC1121.1
  IN6 w0.254: v2(121.84,108.06) 122.68,108.06 123.38,107.36 123.38,103.7 124.63,102.46 129.69,102.46 130.76,103.53 134.21,103.53 135.24,102.49 135.24,101.52 137.38,99.38 142.35,99.38 142.69,99.73 152.62,99.73 159.25,93.1 170.7,93.1 171.15,92.65 171.15,91.96 172.03,91.08 176.15,91.08 177.24,92.17 v2(177.5,92.17)
  BOTTOM w0.254: RH470.2 177.1,92.39 177.18,92.39 177.39,92.17 v2(177.5,92.17)
+AC_IN: length 14.2
  TOP w0.508: PQ216.3 23.61,62.63 v1(22.35,63.89) 22.35,63.95 22.86,64.46 v2(22.92,64.46)
  IN3 w0.508: 22.81,55.89 22.54,55.89 21.64,56.79 21.64,58.58 21.96,58.9 21.96,61.94 20.81,63.09 v2(19.19,63.09)
  BOTTOM w0.254: v2(23.41,55.41) 22.79,56.03 PR220.1
+CLK_PLLVDD:
  vias: v1(206.99,66.95) v2(206.54,71) v2(207.17,68.33)
+DC_IN: length 136.5
  TOP w0.127: v1(16.23,79.23) 16.23,78.63 16.3,78.57 v2(16.3,77.78) 15.72,77.78 15.14,78.37 v1(14.67,78.37)
  TOP w0.508: PD202.2 32.65,25.07 v2(32.65,26.01) ; v1(20.73,87.77) 20.79,87.71 v2(22.23,87.71)
  IN2 w0.508: v2(22.23,87.71) 20.7,87.71 15.88,82.88 15.88,78.2 v2(16.3,77.78) ; v2(32.65,26.01) 31.6,26.01 31.28,26.33 29.19,26.33 26.96,24.1 26.63,24.1 26.02,23.49 25.69,23.49 24.11,21.92 23.27,21.92 20.61,19.25 19.63,19.25 17.56,17.18 15.78,17.18 10.99,12.39 8.98,12.39 8.52,12.85 v2(8.29,12.85)
  IN4 w0.508: v2(14.48,44.25) 15.46,44.25 16.65,45.44 16.65,58.49 18.31,60.14 18.31,64.64 18.92,65.25 18.92,69.43 16.3,72.05 v2(16.3,77.78)
  IN5 w0.508: v2(14.48,44.25) 14.48,44.18 13.46,43.16 10.33,43.16 8.34,41.18 8.34,40.83 7.69,40.17 7.31,40.17 6.68,39.54 6.68,36.21 7.18,35.72 10.2,35.72 10.8,35.12 10.8,33.83 11.92,32.71 11.92,31.63 12.33,31.23 12.33,30.33 12.61,30.05 12.61,27.25 7.75,22.39 7.75,22.24 5.65,20.14 5.65,19 5.22,18.56 5.22,17.84 7.35,15.71 7.35,13.5 8,12.85 v2(8.29,12.85)
  BOTTOM w0.508: PC115.1 PC114.1 21.2,88.34 PR201.1 20.26,87.65 PC200.1
+DC_IN_SS: length 161.2
  TOP w0.127: v1(25.21,5.78) 24.58,5.78 24.07,6.3 v2(23.41,6.3)
  IN2 w0.508: v2(34.01,34.79) 34.01,40.22 32.39,41.84 32.39,42.76 31.94,43.22 31.94,43.82 30.56,45.21 30.56,46.23 30.93,46.6 30.93,47.23 30.65,47.51 28.04,47.51 27.85,47.69 26.36,47.69 26.21,47.85 24.31,47.85 23.13,49.03 23.13,50.34 23.9,51.11 23.9,52.96 21.73,55.13 21.73,62.32 22.38,62.96 22.38,62.98 23.88,64.48 23.88,65.41 25.6,67.14 25.6,68.21 25.12,68.69 18.07,68.69 v2(17.94,68.83) ; v2(55.05,1.85) 55.21,2.01 55.21,3.28 54.29,4.2 54.29,5.62 52.02,7.9 52.02,11.67 53.76,13.41 53.76,15.05 53.05,15.76 53.05,18.53 50.86,20.71 48.64,20.71 47.69,19.76 45.21,19.76 44.83,20.14 41.7,20.14 37.97,23.86 30.63,23.86 v2(30,24.49)
  IN3 w0.508: v2(23.41,6.3) 23.41,8.06 27.46,12.11 27.46,19.97 29.01,21.52 29.01,23.55 30,24.54 v2(30,24.49)
  IN5 w0.508: v2(34.01,34.79) 34.68,34.11 34.68,32.15 33.76,31.23 33.76,30.46 32.61,29.32 32.61,27.2 30.13,24.72 30.13,24.63 v2(30,24.49) ; v2(23.41,6.3) 19.24,6.3 17.58,7.96 17.58,10.98 12.01,16.55 10.56,16.55 9.82,17.29 v2(9.82,17.43)
  BOTTOM w0.457: PR261.1 9.4,18.46 9.79,18.07 9.79,17.46 v2(9.82,17.43)
  BOTTOM w0.508: PD304.2 57.34,4.54 57.44,4.44 57.44,3.53 55.77,1.85 v2(55.05,1.85)
+DCPRTC: length 4.4
  TOP w0.089: CH70.1 86.71,5.27 87.03,5.58 87.75,5.58 87.96,5.36 87.96,4.32 v1(87.6,3.96)
  TOP w0.254: v2(86.31,5.89) 86.31,5.58 CH70.1
  BOTTOM w0.203: v2(86.31,5.89) 86.47,6.05 UH2.BA26
+EDPVDD: length 13.9
  TOP w0.254: 65.37,32.14 66.65,30.85 69.28,30.85 71.3,28.83 71.3,26.81 RV545.1 RV547.1 ; RV546.1 65.74,27.83 65.92,28.02 65.92,28.94 64.7,30.16
  vias: v1(61.25,32.64) v2(61.66,31.71) v2(62.26,31.7)
+FB_VREF: length 4.3
  TOP w0.127: v3(221.82,83.83) 221.49,84.16 v2(221.49,84.24)
  TOP w0.508: RV342.2 220.56,85.54 RV343.1 221.02,85.68 221.4,85.3 CV638.1 221.64,84.83 221.49,84.68 v2(221.49,84.24)
  BOTTOM w0.254: v2(221.49,84.24) 221.49,84.26 UV1.H26
+FBA_DLL_AVDD: length 7.6
  IN4 w0.508: 222.77,90.74 223.42,91.39 223.42,92.64 225.95,95.17 v2(227.01,95.17)
  BOTTOM w0.381: UV1.K27 219.07,85.27 v2(219.07,84.9)
  vias: v3(225.88,94.99)
+FBA_PLL_AVDD: length 34.1
  TOP w0.508: RV510.1 225.4,97.09 v3(226.29,97.98) v2(226.91,97.98) ; CV636.1 221.26,76.58 v2(221.4,76.72)
  IN1 w0.508: v2(221.4,76.72) 220.37,76.72 219.9,77.19 219.9,81.8 217.3,84.4 216.23,84.4 215.2,85.43 213.6,85.43 v2(213.09,85.94)
  IN4 w0.508: 218.01,88.24 218.01,91.98 222.7,96.67 225.61,96.67 v2(226.91,97.98)
  BOTTOM w0.254: v2(221.4,76.72) 221.1,77.01 UV1.H17
  BOTTOM w0.305: v2(213.09,85.94) 213.11,85.94 UV1.U27
+FBA_VREFC_H: length 13.6
  TOP w0.508: CV676.1 RV369.1 v2(203.92,112.92) 204.18,113.18 v1(204.88,113.18) 208.19,113.18 209.18,112.19 RV373.2 209.18,110.99 RV372.1
  BOTTOM w0.254: 200.79,112.02 199.86,111.09 UV6.J14
  BOTTOM w0.508: v2(203.92,112.92) 201.69,112.92 200.79,112.02
+FBA_VREFC_L: length 37.2
  TOP w0.254: RV356.1 217.49,113.89 v1(218,114.4) ; RV360.2 225.82,99.55 RV359.1 226.72,98.65 v2(227.25,98.65)
  TOP w0.508: RV356.1 CV651.1 217.49,111.75 v2(217.7,111.54)
  BOTTOM w0.254: UV5.J14 217.89,111.35 v2(217.7,111.54)
  BOTTOM w0.508: v2(227.25,98.65) 227.94,98.65 233.94,104.64 233.94,108.34 230.3,111.97 218.14,111.97 v2(217.7,111.54)
+FBA_VREFD_H: length 18.5
  TOP w0.127: RV371.2 207.38,111.6 v3(207.05,111.93)
  TOP w0.508: CV777.1 193.82,107.36 v2(193.81,107.36)
  IN4 w0.508: v2(193.81,107.36) 193.81,106.51 194.15,106.18 206.25,106.18 206.66,106.59 v2(206.66,108.16)
  BOTTOM w0.254: UV6.A10 v2(206.66,108.16) ; v2(193.81,107.36) 193.45,107.72 UV6.U10
+FBA_VREFD_L: length 25
  TOP w0.508: RV357.1 RV358.2 225.83,101.3 v1(225.83,102.79) 225.83,103.53 224.02,105.34 CV650.1 RV355.1 224.02,107.02 224.18,107.18 224.18,107.64 v2(224.68,108.13)
  IN4 w0.508: v2(224.68,108.13) 223.21,106.66 220.89,106.66 219.77,105.55 218.63,105.55 218,106.18 212.38,106.18 211.9,106.66 v2(211.9,107.36)
  BOTTOM w0.254: UV5.A10 224.3,107.76 v2(224.68,108.13) ; UV5.U10 211.62,107.76 211.96,107.41 211.96,107.36 v2(211.9,107.36)
+FBB_VREFC_H: length 9.1
  TOP w0.127: v2(247.03,88.46) 247.35,88.46 248.13,89.25 v3(248.13,89.86)
  TOP w0.508: v2(247.03,88.46) 247.52,87.97 RV395.1 CV726.1 247.52,85.49 RV398.1 247.51,84.65 RV399.2
  BOTTOM w0.254: v2(247.03,88.46) 247.03,90.2 246.76,90.47 UV10.J14
+FBB_VREFC_L: length 11.7
  TOP w0.508: v2(247.83,65.57) 247.68,65.41 RV382.1 RV385.1 ; v2(247.83,65.57) 248.29,66.02 RV386.2 ; v2(247.83,65.57) 248.29,65.11 CV701.1
  BOTTOM w0.254: UV9.J14 246.68,72.43
  BOTTOM w0.508: v2(247.83,65.57) 247.83,68.59 248.12,68.88 v3(248.12,70.38) 248.12,70.99 246.68,72.43
+FBB_VREFD_H: length 28.4
  TOP w0.508: RV397.2 246.52,100.38 RV396.1 246.35,99.54 v2(245.69,98.88) ; CV725.1 242.11,82.84 v2(242.11,83.77) ; RV394.1 CV789.1 242.84,99.59 v1(242.31,99.07) v2(242.31,96.47)
  IN4 w0.508: v2(242.11,83.77) 241.15,84.74 241.15,95.58 242.04,96.47 v2(242.31,96.47) 242.31,97.5 243.05,98.24 245.06,98.24 v2(245.69,98.88)
  BOTTOM w0.254: v2(242.31,96.47) UV10.U10 ; v2(242.11,83.77) 242.41,84.07 242.71,84.07 UV10.A10
+FBB_VREFD_L: length 35
  TOP w0.127: RV384.2 242.79,79.28 243.8,80.3 v3(243.8,80.97)
  TOP w0.508: RV384.2 CV778.1 241.85,78.9 v2(242.31,78.43) ; v2(242.08,65.6) 242.14,65.53 RV381.1 242.43,64.51 CV700.1 243.84,64.51 RV383.1
  IN6 w0.508: v2(242.08,65.6) 242.08,64.75 242.76,64.07 246.46,64.07 247.09,64.7 247.09,78.91 246.1,79.9 243.25,79.9 242.31,78.97 v2(242.31,78.43)
  BOTTOM w0.254: v2(242.08,65.6) 242.27,65.6 242.71,66.04 UV9.A10 ; v2(242.31,78.43) UV9.U10
+GPU_CORE: length 107.4
  TOP w0.508: RZ10.1 v2(202.17,57.01)
  IN3 w0.508: v2(202.17,57.01) 202.77,57.6 202.77,59.28 200.71,61.34 200.71,70.41
  BOTTOM w0.305: v2(210,70.99) 209.6,71.38 UV1.AA12 209.73,72.05 v2(210.2,72.52) 210.6,72.92 UV1.Y13 UV1.W14 UV1.V15 UV1.U15 213.86,75.05 v2(214.16,74.75) 214.6,74.31 UV1.T14 UV1.R13 216,72.65 v2(216,72.52) 216.13,72.52 UV1.P12 ; UV1.AC21 207.6,80.96 v2(208.07,80.49) 208.51,80.05 UV1.AB20 UV1.AA19 UV1.Y18 210.8,77.85 v2(210.8,77.57) 210.8,77.25 UV1.Y17 UV1.AA16 UV1.AB15 v2(208.06,74.51) UV1.AC14 ; v2(218.87,83.64) 218.6,83.37 UV1.M23 UV1.N22 UV1.P21 UV1.R20 UV1.T19 214.6,78.78 v2(214.39,78.57) 214.41,78.57 214.41,78.55 213.9,78.05 UV1.U18 ; UV1.AC16 207.77,76.22 v2(208.15,76.6) UV1.AB17 UV1.AB18 208.6,78.18 v2(208.22,78.56) ; v2(208.22,78.56) 207.73,79.05 UV1.AC19 ; v2(208.22,78.56) 208.22,78.56 208.21,78.56 v2(208.22,78.56) ; UV1.M19 UV1.N18 217.55,78.05 v2(217.02,77.53) ; v2(212,77.55) 212.1,77.55 UV1.V18 v2(212.07,78.58) UV1.W19 UV1.Y20 UV1.AA21 UV1.AB22 208.6,82.16 v2(208.19,82.56) 207.71,83.05 UV1.AC23 ; 215.6,77.57 UV1.R18 215.6,78.1 216.55,79.05 UV1.P19 217.04,79.49 v2(217.04,79.5) 217.05,79.5 UV1.N20 UV1.M21 ; 215.6,77.57 214.41,77.57 v2(214.4,77.56) ; 215.6,77.57 UV1.R17 215.6,76.79 v2(216.07,76.32) 216.34,76.05 UV1.P16 216.6,75.76 v2(217.09,75.27) 217.27,75.27 217.49,75.05 UV1.N15 UV1.M14 218.91,74.36 v2(218.91,74.53) 219.04,74.66 219.04,75.61 UV1.M16 UV1.N17 ; 210.6,82.09 209.64,83.05 UV1.AA23 209.6,83.87 v2(209.26,84.21) ; 210.6,82.09 211.6,81.09 UV1.W21 212.01,80.64 v2(212.01,80.58) 212.07,80.58 UV1.V20 UV1.U20 213.85,80.3 214.11,80.3 v2(214.13,80.32) 214.6,80.79 UV1.T21 UV1.R22 UV1.P23 216.6,83.3 v2(217.07,83.77) ; 210.6,82.09 UV1.Y22 ; UV1.T12 214.54,72.05 v2(214.05,72.54) 213.6,72.98 UV1.U13 UV1.V13 212.6,73.02 v2(212.1,72.52) 211.63,72.05 UV1.W12 ; UV1.AC12 207.77,72.05 v2(208.22,72.5) 208.6,72.88 UV1.AB13 208.6,73.25 v2(209.11,73.76) 209.4,74.05 UV1.AA14 UV1.Y15 UV1.W16 v2(212.05,76.5) UV1.V17 UV1.U17 213.66,77.05 214.6,76.11 UV1.T16 ; v2(214.11,83.57) 214.6,83.08 UV1.T23 UV1.U22 UV1.V22 212.54,82.05 v2(212.01,82.58) 211.6,82.99 UV1.W23 ; UV1.M12 218.47,72.05 v2(218,72.52) 217.6,72.92 UV1.N13 UV1.P14 UV1.R15
  vias: v1(193.36,118.2) v2(182.55,97.6) v2(182.55,97.01) v2(182.6,96.4) v2(183.16,97.52) v2(183.21,96.43) v2(186.17,98.98) v2(186.17,98.34) v2(186.81,98.98) v2(186.81,98.34) v2(187.14,111.32) v2(187.14,110.69) v2(187.14,109.99) v2(187.14,109.36) v2(187.14,108.34) v2(187.14,107.7) v2(187.14,107.07) v2(187.14,106.43) v2(187.14,105.8) v2(187.11,104.38) v2(187.11,103.74) v2(187.11,103.11) v2(187.11,102.47) v2(187.11,101.84) v2(187.14,100.85) v2(187.14,100.21) v2(187.14,99.58) v2(187.21,118.69) v2(187.21,118.06) v2(187.21,117.34) v2(187.21,116.71) v2(187.21,116.07) v2(187.21,115.44) v2(187.21,114.8) v2(187.21,113.66) v2(187.21,113.03) v2(187.21,112.39) v2(187.16,105.11) v2(187.44,98.98) v2(187.44,98.34) v2(187.74,104.38) v2(187.74,103.74) v2(187.74,103.11) v2(187.74,102.47) v2(187.74,101.84) v2(187.85,118.69) v2(187.85,118.06) v2(187.85,117.34) v2(187.85,116.71) v2(187.85,116.07) v2(187.85,115.44) v2(187.85,114.8) v2(187.81,113.65) v2(187.85,113.03) v2(187.85,112.39) v2(187.77,111.32) v2(187.77,110.69) v2(187.77,109.99) v2(187.77,109.36) v2(187.77,108.34) v2(187.77,107.7) v2(187.77,107.07) v2(187.77,106.43) v2(187.77,105.8) v2(187.8,105.11) v2(187.77,100.85) v2(187.77,100.21) v2(187.77,99.58) v2(188.43,113.66) v2(188.41,111.32) v2(188.41,110.69) v2(188.41,110.02) v2(188.41,109.38) v2(188.43,105.11) v2(188.38,104.38) v2(188.38,103.74) v2(188.38,103.11) v2(188.42,102.49) v2(188.42,101.85) v2(188.47,118.7) v2(188.47,118.07) v2(188.46,113) v2(188.46,112.37) v2(189.04,111.32) v2(189.04,110.69) v2(189.04,110.02) v2(189.04,109.38) v2(189.01,104.38) v2(189.01,103.74) v2(189.01,103.11) v2(189.1,118.7) v2(189.1,118.07) v2(189.08,113.67) v2(189.09,113) v2(189.09,112.37) v2(189.07,105.11) v2(189.05,102.49) v2(189.05,101.85) v2(189.65,104.38) v2(189.65,103.74) v2(189.65,103.11) v2(189.74,118.7) v2(189.74,118.07) v2(189.7,113.67) v2(189.73,113.03) v2(189.73,112.37) v2(189.68,111.32) v2(189.68,110.69) v2(189.68,110.02) v2(189.68,109.38) v2(189.7,105.11) v2(189.69,102.49) v2(189.69,101.85) v2(190.31,111.32) v2(190.31,110.69) v2(190.31,110.02) v2(190.31,109.38) v2(190.34,105.11) v2(190.31,104.02) v2(190.31,103.39) v2(190.31,102.75) v2(190.37,118.7) v2(190.37,118.07) v2(190.36,113.67) v2(190.36,113.03) v2(190.36,112.37) v2(192.15,116.47) v2(192.15,115.83) v2(192.79,116.47) v2(192.79,115.83)
+INV_PWR_SRC: length 1.4
  TOP w0.127: v1(48.82,27.91) 48.44,27.53 v2(48.44,26.67)
+ODR_PWR: length 11.2
  IN6 w1.016: 331.56,43.68 331.56,36.9
  BOTTOM w0.203: UR1.12 331.34,35.88
  BOTTOM w0.305: v2(330.81,35.57) 331.12,35.88 331.34,35.88
  BOTTOM w0.508: v1(326.54,53.02) 326.29,53.02 324.56,51.29 v2(324.56,50.75)
  vias: v2(324.56,50.11) v2(329.95,44.71) v2(330.23,35.53) v2(330.58,44.71)
+PEX_PLLVDD: length 21.2
  TOP w0.127: v1(194.45,91.73) 195.09,91.73 v2(195.17,91.82)
  TOP w0.508: CV612.1 196.67,91.32 LV3.1 195.82,92.46 v2(195.17,91.82) ; v2(205.53,84.22) 205.46,84.3 CV610.1 205.64,85.21 206.21,85.78 CV611.1
  IN1 w0.508: v2(205.53,84.22) 204.85,84.91 204,84.91 202.98,85.92 199.44,85.92 196.42,88.95 196.42,90.57 v2(195.17,91.82)
  BOTTOM w0.381: UV1.AG26 205.11,84.65 v2(205.53,84.22)
+PLLVDD: length 2.1
  BOTTOM w0.305: 207.9,69.8 207.7,69.6 UV1.AD8
  BOTTOM w0.508: v2(209.27,70.75) 208.79,70.75 208.66,70.62 207.9,69.86 207.9,69.8
  vias: v1(210.05,69.81)
+PWR_SRC_AC:
  vias: v3(53.66,9.85)
+RTC_CELL_VBAT: length 6.5
  TOP w0.305: v2(295.22,13.62) 294.97,13.38 UE3.B64
  TOP w0.508: v2(292.41,12.37) 291.91,12.37 291.49,12.79 CE17.1 RE16.2
  BOTTOM w0.508: v2(292.41,12.37) 292.76,12.37 294.02,13.62 v2(295.22,13.62)
+RTCBATT: length 30.1
  TOP w0.127: v1(324.87,105.69) 326.2,105.69 326.75,105.14 JRTC.1
  TOP w0.508: RH67.2 330.77,79.55 v2(330.67,79.45) ; v2(326.75,102.75) JRTC.1
  IN1 w0.508: v2(326.75,102.75) 326.75,99.31 330.67,95.39 v2(330.67,79.45)
+RTCVCC: length 338.5
  TOP w0.254: RP19.6 289.31,8.64 v2(288.85,9.1) 288.89,9.14 RP19.5
  TOP w0.381: v2(89.56,6.33) 89.34,6.33 89.16,6.52 CH196.1 89.16,7.86 CH80.1 CH173.1 ; v2(287.22,15.79) 287.29,15.73 287.29,15.18 RE50.1
  TOP w0.508: v2(281.3,7.6) v1(282,7.6) 283.1,7.6 287.26,3.44 291.34,3.44 291.59,3.69 RE90.1 RE34.1 ; CH44.1 328.82,76.18 D122.3 331.17,76.18 v2(332.13,75.22) ; RE16.1 v2(290.32,11.25)
  IN1 w0.508: v2(332.13,75.22) 332.13,75.21 333.33,74.01 333.33,67.28 333.82,66.79 333.82,58.02 331.14,55.34 331.14,51.3 330.01,50.17 330.01,48.07 327.57,45.63 327.57,38.34 328.14,37.77 328.14,32.57 327.38,31.81 326.48,31.81 324.53,29.87 324.53,24.3 323.07,22.83 322.01,22.83 319.74,20.56 319.74,14.87 318.03,13.16 312.11,13.16 v2(311.98,13.03) ; v2(288.85,9.1) 287.44,7.69 281.39,7.69 v2(281.3,7.6)
  IN4 w0.381: v2(96.33,5.23) 95.67,4.57 91.15,4.57 89.56,6.16 v2(89.56,6.33)
  IN5 w0.508: 301.51,12.99 301.42,12.9 296.87,12.9 296.76,13.01 295.47,13.01 295.47,13.01 294.87,13.01 293.42,14.46 291.57,14.46 290.32,13.22 v2(290.32,11.25) ; 98.98,6.28 100.41,6.28 103.11,8.99 107.4,8.99 107.61,9.2 112.38,9.2 113.15,8.43 113.15,8.15 113.64,7.65 116.73,7.65 118,8.92 145.39,8.92 147.36,6.95 151.54,6.95 152.46,7.88 154.94,7.88 155.32,7.5 158.51,7.5 160.02,5.99 162.07,5.99 163.13,7.06 166.25,7.06 168,5.31 170.4,5.31 170.82,4.9 171.75,4.9 171.84,4.81 172.98,4.81 174.11,3.67 178.18,3.67 179.15,4.64 181.25,4.64 187.08,10.47 214.52,10.47 215.69,11.64 219.18,11.64 220.4,10.42 251.78,10.42 252.1,10.1 265.26,10.1 265.57,9.8 268.91,9.8 269.32,10.21 270.96,10.21 271.27,10.52 278.12,10.52 279.22,9.42 279.22,8.6 280.23,7.6 v2(281.3,7.6) ; v2(96.33,5.23) 96.28,5.28 96.28,5.71 96.75,6.18 97.69,6.18
  BOTTOM w0.203: UH2.BA22 89.22,5.99 v2(89.56,6.33)
  BOTTOM w0.508: v2(288.85,9.1) 288.85,10.3 289.8,11.25 v2(290.32,11.25) 290.32,12.42 289.94,12.8 289.44,12.8 288.95,13.28 288.95,15.29 288.44,15.79 v2(287.22,15.79)
+SD_VDD2: length 31.7
  TOP w0.508: JCR.16 v2(346.66,47.3)
  IN3 w0.762: v2(346.39,45.86) 348.02,44.23 348.02,40.14 346.29,38.41 332.68,38.41 331.15,36.89
  BOTTOM w0.127: v2(346.66,47.3) 346.25,47.71 v1(345.99,47.71)
  BOTTOM w0.203: UR1.13 330.65,36.28 v2(330.63,36.25)
  BOTTOM w0.508: v2(346.66,47.3) 347.41,47.3 CR18.1 347.65,46.29 CR17.1 v2(346.39,45.86)
+SDC_IN: length 19.7
  TOP w0.127: v1(54.74,4.07) 54.26,3.59 v2(54.26,3.37)
  TOP w0.508: v2(25.5,71.4) 26.09,71.4 PL200.2 ; v2(27.52,56.83) 27.06,56.37 PR208.1
  IN1 w0.508: v2(53.26,4.06) 53.76,4.55 53.76,7.91 51.64,10.03 51.64,11.35 51.69,11.39 v2(51.69,13.66)
  BOTTOM w0.381: PR399.2 52.69,12.66 v2(51.69,13.66)
  BOTTOM w0.508: v2(51.69,13.66) 51.69,14.49 PR304.1 50.61,15.57 50.61,16.77 51.12,17.28 PD302.1
  vias: v2(24.85,75.02) v2(24.85,74.43) v2(24.85,73.85) v2(24.85,73.26) v2(24.85,72.63) v2(24.85,72.03) v2(24.85,71.4) v2(25.5,75.02) v2(25.5,74.43) v2(25.5,73.85) v2(25.5,73.26) v2(25.52,72.64) v2(25.5,72.03) v2(52.5,3.37) v2(52.5,2.32) v2(52.5,1.74) v2(52.77,2.85) v2(53.09,3.37) v2(53.09,2.32) v2(53.09,1.74) v2(53.35,2.85) v2(53.67,3.37) v2(53.67,2.32) v2(53.67,1.74) v2(53.94,2.85) v2(54.26,2.32) v2(54.52,2.85)
+V_DDR_REF: length 3
  BOTTOM w0.127: v3(289.43,32.88) 288.52,32.88 PC609.1
  BOTTOM w0.203: PC609.1 288.74,32.2 288.74,31.7 288.67,31.63 PU600.4
+V_DDR_REFA: length 31.5
  TOP w0.508: CD18.1 150.19,16.86 v2(150.2,16.86) ; v2(126.99,16.7) 126.99,17.53 v1(126.59,17.93) 126.2,18.32 RH206.2 RH209.1 RH484.2
  IN3 w0.508: v2(150.2,16.86) 150.2,16.45 149.7,15.96 127.73,15.96 v2(126.99,16.7)
  BOTTOM w0.305: JDIMM1.164 150.12,16.93 v2(150.2,16.86)
+V_DDR_REFA_R: length 64.8
  TOP w0.127: v1(139.14,67.97) 139.5,67.97 v2(139.73,68.2)
  TOP w0.508: RH484.1 CH101.1 122,20.23 v2(122.19,20.42)
  IN3 w0.381: v2(139.73,68.2) 139.65,68.27 138.06,68.27 137.69,67.9 137.69,65.56 138.21,65.04 138.21,64.59
  IN3 w0.508: 138.21,64.59 138.32,64.48 138.32,60.86 138.66,60.51 140.02,60.51 140.81,59.72 140.81,58.74 137.18,55.11 137.18,52.43 134.37,49.62 130.16,49.62 122.71,42.16 122.71,24.54 122.19,24.02 v2(122.19,20.42)
+V_DDR_REFB: length 15.2
  TOP w0.508: CD29.1 226.5,16.87 v2(226.5,16.87) ; RH485.2 RH207.2 RH210.1 234.3,17.61 v1(234.56,17.36) 234.93,16.99 v2(234.93,16.86)
  IN4 w0.508: v2(226.5,16.87) 226.5,17.08 226.89,17.48 234.5,17.48 234.93,17.05 v2(234.93,16.86)
  BOTTOM w0.305: v2(226.5,16.87) 226.42,16.95 JDIMM2.164
+V_DDR_REFB_R: length 130.8
  TOP w0.508: v2(230.57,20.87) 231.31,20.14 CH100.1 RH485.1
  IN3 w0.381: 139.6,65.39 139.6,66.02 138.43,67.19 v2(138.43,67.4)
  IN3 w0.508: v2(230.57,20.87) 230.17,20.87 229.08,19.79 228.33,19.79 227.59,19.04 222.22,19.04 222,18.81 206.44,18.81 205.65,19.6 205.65,24.8 203.21,27.24 203.21,29.4 202.33,30.29 184.84,30.29 183.88,31.25 161.33,31.25 141.53,51.05 141.53,56.29 143.11,57.87 143.11,57.91 143.71,58.51 143.71,61.34 143.11,61.94 143.11,62.52 142.31,63.32 140.45,63.32 139.6,64.17 139.6,65.39
+VCHGR:
  vias: v1(30.23,22.42) v2(30.7,20.84) v2(30.7,20.24) v2(30.7,19.63)
+VDISPLAY_VCC: length 6.6
  IN6 w0.508: v2(13.86,91.12) 12.35,89.61 11.72,89.61 10.57,88.47 JHDMI1.18
  BOTTOM w0.508: RV125.2 v2(13.86,91.12) ; v2(19.2,91.51) 18.81,91.12 RV124.2
  vias: v1(16.08,90.64)
+VGA_B+: length 25.7
  TOP w0.254: PR1009.1 164.4,109.9 164.4,118.06 165.71,119.37 172.61,119.37 173.48,120.24 175.68,120.24 176.21,119.71 PC1006.1
  vias: v1(173.7,107.21) v2(172.28,114.12) v2(172.78,114.82) v2(172.91,114.12) v2(173.42,114.82) v2(173.74,104.28) v2(173.99,112.21) v2(174.05,114.82) v2(174.12,104.72) v2(174.63,112.21) v2(174.57,99.09) v2(174.64,96.33) v2(174.69,114.82) v2(174.69,105.86) v2(174.69,105.23) v2(174.69,104.59) v2(174.65,98.51) v2(174.68,95.73) v2(174.84,97.93) v2(175.18,99.01) v2(175.29,105.86) v2(175.29,105.23) v2(175.29,104.59) v2(175.29,98.37) v2(175.29,95.65)
+VLDOIN_1.2V: length 1.8
  BOTTOM w0.127: 284.51,30.79 284.51,32.06 v3(284.1,32.47)
+VR_CAP: length 8.4
  TOP w0.127: v1(302.22,8.57) 302.73,8.06 v2(302.83,8.06)
  TOP w0.305: UE3.B12 300.52,11.43 v2(300.57,11.48)
  TOP w0.508: CE40.1 302.64,7.87 v2(302.83,8.06)
  IN5 w0.508: v2(302.83,8.06) 302.34,7.57 301.3,7.57 300.88,7.98 300.83,7.98 300.47,8.34 300.47,9.84 300.57,9.94 v2(300.57,11.48)
+VSBP:
  vias: v1(28.34,13.98) v2(14.16,18.93) v2(14.59,18.51) v2(15.03,18.91) v2(15.69,19.06) v2(30.1,15.19) v2(30.11,14.55) v2(30.1,13.92) v2(30.86,15.19) v2(30.86,14.55) v2(30.86,13.92)
A_DE0: length 1.9
  BOTTOM w0.14: RI19.1 322.68,31.57 322.11,32.14 UI3.16
A_DE1: length 4
  BOTTOM w0.14: v3(324.64,28.81) 324.16,29.3 323.83,29.3 RI20.1 322.57,30.55 322.57,30.72 322.14,31.14 UI3.18
A_EQ0: length 2
  BOTTOM w0.14: UI3.17 322.1,31.64 323.06,30.68 RI15.1
A_EQ1: length 1.7
  BOTTOM w0.14: UI3.15 323.14,32.64 RI16.1
AC_DET: length 3.4
  TOP w0.14: v1(17.24,3.28) 16.06,3.28 15.58,3.76 PR240.1
  TOP w0.254: PR240.1 PR243.2
AC_DIS: length 391.1
  TOP w0.14: UE3.A50 292.69,18.63 292.55,18.77 291.52,18.77 291.33,18.58 289.35,18.58 288.84,19.09 288.84,19.57 288.53,19.87 286.73,19.87 286.2,19.34 286.2,16.2 285.23,15.24 285.23,14.44 v3(284.67,13.87) 284.53,13.74 v2(284.53,11.31)
  IN2 w0.099: v2(57.24,13.98) 57.47,14.21 57.47,20.25 56.77,20.95 56.3,20.95 55.73,21.52 55.73,21.61 53.09,24.25 51.76,24.25 50.96,25.05 46.9,25.05 45.31,26.64 43.29,26.64 41.78,28.15 37.16,28.15 36.18,29.14 34.16,29.14 32.74,27.72 28.71,27.72 28.39,27.4 28.39,26.74 25.75,24.1 24.92,24.1 23.76,22.94 v2(23.6,22.94)
  IN5 w0.089: 101.98,15.18 101.41,15.18 100.97,14.74 99.32,14.74 98.72,15.34 91.25,15.34 89.91,13.99 85.58,13.99 85.42,14.15 78.43,14.15 78,13.72 75.06,13.72
  IN5 w0.099: v2(22.23,93.39) 21.83,92.99 21.83,90.71 22.85,89.69 22.85,84.32 22.6,84.07 22.6,79.37 20.95,77.72 20.95,62.91 18.25,60.21 18.25,42.39 20.49,40.15 20.49,32.65 21.17,31.97 21.17,28.49 21.35,28.31 21.35,26.37 22.58,25.14 22.58,22.74 22.8,22.53 23.19,22.53 v2(23.6,22.94) ; 75.06,13.72 67.5,13.72 67.29,13.94 57.28,13.94 v2(57.24,13.98) ; 101.98,15.18 105.1,15.18 105.42,14.87 161.12,14.87 161.24,14.75 168.61,14.75 168.72,14.86 174.87,14.86 179.06,19.05 179.06,22.64 182.55,26.12 186.76,26.12 186.94,25.95 218.07,25.95 219.63,24.39 219.63,19.98 221.5,18.11 247.23,18.11 248.52,16.82 248.52,16.69 252.17,13.05 265.24,13.05 266.27,12.02 270.7,12.02 271.2,11.53 274.17,11.53 274.6,11.95 283.89,11.95 v2(284.53,11.31)
  BOTTOM w0.127: v2(57.24,13.98) 56.77,13.51 PQ304.2
  BOTTOM w0.14: PR327.1 58.04,11.41 58.04,11.73 57.62,12.15 57.07,12.15 56.77,12.46 PQ304.2
  BOTTOM w0.254: v2(22.23,93.39) 22.08,93.25 PQ211.2
AC_PRESENT: length 280.1
  TOP w0.14: v1(314.19,5.52) 314.19,5.1 v2(313.93,4.85) ; UE3.A54 293.05,16.63 292.8,16.87 v2(292.8,16.89)
  IN2 w0.089: v2(92.37,1.93) 92.37,1.93 92.6,1.93 93.12,1.41 ; 98.45,1.41 100.67,3.63 101.91,3.63 101.92,3.61 101.98,3.61
  IN2 w0.099: 101.98,3.61 105.32,3.61 106.89,2.04 107.87,2.04 v2(108.41,1.5) 108.59,1.32 114.24,1.32 119.1,6.18 129.59,6.18 130.4,5.37 131.51,5.37 131.59,5.45 134.64,5.45 135.9,6.7 140.68,6.7 141.21,7.24 145.01,7.24 148.57,3.68 150.08,3.68 151.39,2.37 186.09,2.37 190.55,6.82 201,6.82 201.52,7.35 209.36,7.35 214.53,2.17 225.8,2.17 226.66,1.32 244.27,1.32 247.48,4.52 250.5,4.52 251.66,3.35 262.99,3.35 264.1,4.46 267.46,4.46 269.3,2.62 309.22,2.62 310.59,4 312.6,4 312.8,4.2 313.28,4.2 v2(313.93,4.85) ; 98.45,1.41 98.37,1.32 93.21,1.32 93.12,1.41
  IN3 w0.091: v2(312.3,19.67) 312.74,19.67 313.4,19 313.4,5.44 313.93,4.91 v2(313.93,4.85)
  IN6 w0.099: v2(292.8,16.89) 293.43,16.89 294.12,17.59 296.66,17.59 296.83,17.76 301.34,17.76 301.82,18.24 303.54,18.24 304.46,19.16 311.79,19.16 v2(312.3,19.67)
  BOTTOM w0.089: v2(92.37,1.93) 92.37,1.93 92,2.3 92,2.71 92.06,2.77 92.06,3.8 92.27,4.01 92.27,4.31 92.27,4.88 92.35,4.96 92.35,5.15 92.56,5.36 UH2.BB15
  BOTTOM w0.127: v2(108.41,1.5) 108.57,1.66 RH533.1
ACAV_IN: length 269.9
  TOP w0.14: v2(285.31,16.85) 285.31,16.61 284.08,15.38 v3(284.08,9.28) 284.08,8.91 286.2,6.79 286.2,6.42 287.08,5.53 289.57,5.53 290.53,6.49 290.72,6.49 291.76,7.53 291.76,8.19 292.95,9.38 292.95,11.3 293.28,11.63 UE3.A64
  IN1 w0.099: v2(285.31,16.85) 284.84,16.85 282.55,14.56 272.14,14.56 269.85,12.26 268.97,12.26 266.39,9.68 266.1,9.68 264.83,8.42 262.8,8.42 262.74,8.47 256.25,8.47 255.43,7.65 253.56,7.65 253.01,8.19 245.62,8.19 245.53,8.28 232.33,8.28 231.56,9.05 218.91,9.05 217.89,8.03 213.59,8.03 211.39,10.23 206.23,10.23 206.12,10.34 183.21,10.34 182.21,9.34 175.96,9.34 174.32,10.98 166.17,10.98 165.23,10.04 154.74,10.04 152.71,12.07 129.79,12.07 128.89,12.98 110.45,12.98 109.71,13.71 108.42,13.71 107.68,12.98 102.81,12.98 101.81,11.98 101.5,11.98 100.79,11.27 99.1,11.27 98.43,11.94 96.02,11.94 94.95,13.01 92.54,13.01 91.23,11.7 79.74,11.7 78.96,10.92 76.07,10.92 75.9,11.09 72.2,11.09 71.92,10.81 70.3,10.81 70.11,11.01 69.09,11.01 68.14,11.95 61.54,11.95 59.76,10.16 56.9,10.16 55.46,11.6 54.66,11.6 53.85,10.79 v2(53.84,10.79)
  BOTTOM w0.254: v2(53.84,10.79) 53.82,10.79 54.04,11.01 PR312.1
ACAV_IN_NB: length 12.7
  TOP w0.14: DE11.2 308.04,7.59 v2(308,7.55) ; UE3.B20 302.64,12.38 v2(302.22,11.96)
  IN3 w0.091: v2(302.22,11.96) 302.24,11.96 302.69,12.42 304.19,12.42 304.73,11.87 304.73,10.79 305.44,10.08 306.81,10.08 307.84,9.05 307.84,7.72 v2(308,7.55)
ALL_GPWRGD: length 70.4
  TOP w0.14: PU700.1 245.19,53.16 245.89,53.86 v1(246.57,53.86) 246.91,53.86 PR704.2 247.05,52.55 v2(246.76,52.55) ; QV39.2 197.01,55.59 v2(197.59,56.17)
  IN3 w0.091: v2(246.76,52.55) 247.57,51.74 247.57,45.61 244.21,42.25 225.49,42.25 219.47,48.27 216.14,48.27 212.18,52.23 210.23,52.23 206.96,55.49 204.45,55.49 204.19,55.24 200.53,55.24 199.59,56.17 v2(197.59,56.17)
ALW_PWRGD_3V_5V: length 407.3
  TOP w0.14: v2(319.52,26.18) 319.52,26.76 v1(319.42,26.86) ; PR277.1 31.1,31.05 v2(30.53,31.63)
  TOP w0.254: PQ225.2 25.91,24.79 25.67,25.03 25.27,25.03 24.35,24.11 24.35,22.44 24.89,21.9 v2(24.89,18.91) ; PR407.1 345.12,24.71 v2(345.44,25.03)
  IN3 w0.091: v2(319.52,26.18) 319.52,26.82 323.1,30.4 338.44,30.4 340.37,32.33 344.88,32.33 346.52,30.69 346.52,26.11 v2(345.44,25.03)
  IN5 w0.099: v2(24.89,18.91) 25.4,19.42 25.4,23.74 25.02,24.12 25.02,25.25 25.91,26.14 25.91,29.1 25.35,29.66 25.35,30.01 25.88,30.54 26.63,30.54 27.42,31.33 30.23,31.33 v2(30.53,31.63)
  IN6 w0.089: 75.06,7.98 76.39,7.98 76.79,8.38 77.65,8.38 77.82,8.54 78.39,8.54 78.47,8.46 78.49,8.46 78.98,8.46 79.28,8.76 79.47,8.76 79.77,8.46 79.8,8.46 80.45,7.81 82.05,7.81 82.08,7.78 83.28,7.78 83.47,7.59 83.47,5.67 83.8,5.34 84.09,5.34 84.56,5.81 85.74,5.81 86.11,5.44 86.7,5.44 86.91,5.65 87.52,5.65 87.75,5.88 87.75,6.49 88.89,7.64 89.14,7.64 89.42,7.36 90.29,7.36 90.36,7.44 90.97,7.44 91.5,7.97 92.43,7.97 92.62,7.78 92.62,7.57 92.71,7.48 92.71,7.18 92.97,6.92 93.24,6.92 94.16,7.84 94.4,7.84 94.93,8.38 96.39,8.38 96.53,8.52 98.65,8.52 99.05,8.91 101.81,8.91 101.98,9.09
  IN6 w0.099: v2(24.89,18.91) 27.63,21.64 30.45,21.64 31.1,22.29 33.99,22.29 34.3,21.98 34.73,21.98 35.94,23.19 38.01,23.19 39.87,21.33 40.95,21.33 41.78,20.5 50.31,20.5 50.7,20.11 51.75,20.11 53.95,17.92 53.95,16.18 54.5,15.63 54.5,15.46 54.5,13.42 55.34,12.58 55.35,12.58 55.7,12.23 65.16,12.23 65.63,11.76 68.75,11.76 70.09,10.42 71.4,10.42 72.59,9.23 72.59,8.63 73.24,7.98 75.06,7.98 ; 101.98,9.09 102.49,9.59 105.93,9.59 106.23,9.29 107.12,9.29 107.61,9.77 117.4,9.77 118.06,10.43 126.42,10.43 126.72,10.73 146.45,10.73 149.66,7.52 151.71,7.52 152.18,7.99 154.34,7.99 156.41,10.06 157.59,10.06 159.06,8.59 160.35,8.59 161.16,9.41 163.52,9.41 164.34,8.59 169.3,8.59 171.09,10.39 174.42,10.39 174.88,9.94 186.41,9.94 187.71,11.24 199.55,11.24 200.4,10.39 210.87,10.39 213.49,7.78 226.69,7.78 228.19,6.28 237.88,6.28 238.87,7.27 246.15,7.27 256.16,7.27 256.9,8 262.55,8 262.9,7.66 273.98,7.66 275.05,6.59 282.74,6.59 283.83,7.68 291.99,7.68 293.33,9.02 293.99,9.02 294.34,8.68 294.64,8.68 294.93,8.39 294.93,8.23 295.62,7.54 305.87,7.54 306.27,7.95 306.27,8.54 306.81,9.08 312.18,9.08 312.89,8.37 317.17,8.37 319.28,10.47 319.28,23.85 320.15,24.72 320.15,25.54 v2(319.52,26.18)
ALWON: length 72.1
  TOP w0.14: v2(292.62,13.84) 292.84,13.63 UE3.A60 ; v2(316.16,25.64) 315.95,25.43 v1(315.95,24.88)
  TOP w0.254: PR326.1 v2(346.97,26.93)
  IN3 w0.091: v2(316.16,25.64) 316.23,25.57 318,25.57 323.44,31.01 338.77,31.01 340.33,32.56 344.92,32.56 346.97,30.51 v2(346.97,26.93)
  IN6 w0.099: v2(292.62,13.84) 292.84,14.06 300.47,14.06 300.88,14.46 304.13,14.46 304.59,14.92 306.56,14.92 307.76,16.13 311.72,16.13 312.29,16.7 312.29,17.23 316.16,21.1 v2(316.16,25.64)
AUD_AZA_CPU_SCLK: length 161.9
  IN5 w0.099: v2(176.16,26.11) 175.39,25.33 175.39,23.61 176.01,22.98 176.01,20.99 175.16,20.13 175.16,19.57 174.83,19.25 150.93,19.25 150.65,18.97 150.08,18.97 149.86,19.19 141.63,19.19 141.42,18.97 134.52,18.97 134.21,19.28 107.67,19.28 107.05,19.9 v2(106.55,19.9)
  IN6 w0.089: 181.1,65.05 180.15,65.05 178.35,66.84 178.35,68.04 177.95,68.44 177.95,78.92 177.12,79.75 174.94,79.75 v2(174.48,80.21)
  IN6 w0.099: v2(176.16,26.11) 176.79,26.11 177.67,26.99 177.67,31.03 178.89,32.25 191.57,44.94 191.57,58.89 187.38,63.09 186.44,63.09 184.48,65.05 181.1,65.05
  BOTTOM w0.076: UH1.G27 174.48,79.32 v2(174.48,80.21)
  BOTTOM w0.127: RH147.1 109.49,11.48 109.49,12.92 109.01,13.4 109.01,14.79 107.7,16.1 107.7,16.55 107.05,17.19 107.05,18.55 106.36,19.24 106.36,19.71 v2(106.55,19.9)
AUD_AZA_CPU_SCLK_R: length 9.2
  BOTTOM w0.089: UH2.AM2 98.85,10.48 99.21,10.12 99.57,10.12 99.57,10.12 101.98,10.12
  BOTTOM w0.127: 101.98,10.12 102.67,10.12 102.73,10.06 102.73,10.05 102.82,9.97 105,9.97
  BOTTOM w0.14: 105,9.97 105.67,9.97 106.25,10.55 v3(106.5,10.55) 107.27,10.55 RH147.2
AUD_AZA_CPU_SDI_R: length 166.4
  IN5 w0.099: v2(106.82,19.38) 107.12,19.08 134.11,19.08 134.44,18.75 141.49,18.75 141.72,18.99 149.78,18.99 150,18.77 150.73,18.77 151.01,19.05 174.91,19.05 175.36,19.49 175.36,19.95 176.23,20.82 176.23,23.1 175.68,23.65 175.68,24.87 175.88,25.08 v2(177.33,25.08)
  IN6 w0.099: v2(181.49,78.8) 181.49,70.18 186.01,65.66 189.01,65.66 190.24,64.43 190.24,62.51 192.89,59.86 192.89,58.77 192.91,58.76 192.91,44.39 180.2,31.68 180.2,27.95 v2(177.33,25.08)
  BOTTOM w0.089: UH2.AN2 99.08,10 99.19,9.89 101.98,9.89
  BOTTOM w0.127: 101.98,9.89 101.99,9.89 102.15,9.74 104.71,9.74 104.97,9.48 108.54,9.48 109.72,10.66 109.72,13.01 109.23,13.49 109.23,15.01 107.93,16.32 107.93,16.64 107.28,17.29 107.28,18.92 v2(106.82,19.38)
  BOTTOM w0.14: RH145.2 181.65,79.88 181.65,78.96 v2(181.49,78.8)
AUD_AZA_CPU_SDO: length 160.3
  IN5 w0.099: v2(106.13,20.32) 106.12,20.3 106.12,19.36 106.85,18.62 134.28,18.62 134.36,18.55 141.56,18.55 141.73,18.71 149.77,18.71 149.93,18.55 174.7,18.55 175.56,19.41 175.56,19.87 176.43,20.74 176.43,23.23 175.96,23.69 175.96,24.53 v2(176.09,24.65)
  IN6 w0.089: v2(173.84,77.8) 174.22,77.43 177.47,77.43 177.71,77.19 177.71,68.3 178.04,67.97 178.04,66.77 180.05,64.77 181.1,64.77
  IN6 w0.099: v2(176.09,24.65) 175.72,25.02 175.72,26.24 175.99,26.51 176.88,26.51 177.47,27.1 177.47,31.12 178.69,32.34 191.37,45.02 191.37,58.79 187.28,62.89 186.32,62.89 184.44,64.77 181.1,64.77
  BOTTOM w0.076: UH1.G25 174.18,77.46 v2(173.84,77.8)
  BOTTOM w0.127: v2(106.13,20.32) 106.13,19.67 106.14,19.67 106.14,19.15 106.82,18.46 106.82,17.1 107.47,16.45 107.47,15.9 108.78,14.59 108.78,13.41 108.18,12.81 v3(108.18,12.63) RH146.1
AUD_AZA_CPU_SDO_R: length 8.5
  BOTTOM w0.089: 101.98,10.35 99.6,10.35 99.58,10.38 UH2.AM1
  BOTTOM w0.127: 101.98,10.35 103.16,10.35 103.2,10.31 v3(104.23,10.31) 105.56,10.31 106.77,11.52 RH146.2
AUD_PWR_EN: length 161.9
  TOP w0.14: v2(6.14,15.96) 5.54,16.56 5.54,18.44 6.4,19.3 JAUDIO.7 ; v1(65.6,11.93) 65.85,12.18 v2(65.85,12.99)
  IN1 w0.099: v2(65.85,12.99) 65.2,12.99 64.57,12.35 61.37,12.35 59.59,10.57 58.08,10.57 56.01,12.63 53.26,12.63 52.98,12.35 52.98,10.91 55.91,7.98 57.18,7.98 57.47,7.69 57.47,5.87 57.85,5.5 58.5,5.5 v2(58.59,5.59)
  IN2 w0.099: v2(65.85,12.99) 65.85,13.63 66.18,13.97 67.07,13.97 67.41,14.31 67.41,14.96 65.74,16.63 64.51,16.63 60.99,20.15 60.39,20.15 60.16,20.38 60.16,21.17 59.21,22.12 58.25,22.12 54.77,25.61 54.32,25.61 53.02,26.91 50.75,26.91 50.1,26.26 47.57,26.26 45.19,28.64 42.94,28.64 42.24,29.33 39.35,29.33 38.17,30.51 35.77,30.51 35.13,31.14 34.09,31.14 32.67,29.72 29.07,29.72 27.43,28.09 26.9,28.09 26.32,27.51 26.32,26.81 23.61,24.1 22.44,24.1 22.04,23.7 20.32,23.7 16.77,20.15 11.01,20.15 9.79,18.92 8.72,18.92 7.47,17.68 7.47,17.29 v2(6.14,15.96)
  IN5 w0.089: v2(89.43,2.54) 89.2,2.54 87.97,3.77 86.92,3.77 86.41,4.28 75.93,4.28 75.06,5.16
  IN5 w0.099: 75.06,5.16 74.99,5.22 64.86,5.22 63.61,6.47 62.44,6.47 61.92,7 59.02,7 58.73,7.29 58.73,7.32 56.45,9.6 55.82,9.6 55.73,9.51 55.73,6.13 56.36,5.5 58.5,5.5 v2(58.59,5.59)
  BOTTOM w0.089: UH2.BE21 89.89,3.97 89.89,3.61 89.85,3.58 89.85,3.09 89.73,2.97 89.73,2.83 v2(89.43,2.54)
  BOTTOM w0.14: RH569.1 RH568.1 59.89,2.47 58.59,3.77 v2(58.59,5.59)
  BOTTOM w0.254: PR113.1 PR109.2 65.52,12.99 v2(65.85,12.99)
AUX_EN_WOWL: length 112.8
  TOP w0.14: v2(301.41,19.33) 301.52,19.44 UE3.B38 ; v2(337.31,103.32) 337.3,103.31 DN3.3 335.68,103.31 v3(335.19,103.79)
  IN1 w0.099: v2(337.31,103.32) 338.27,102.37 338.27,93.43 331.46,86.62 331.46,74.07 332.56,72.96 332.56,66.99 333.21,66.34 333.21,58.27 329.24,54.3 329.24,48.27 326.77,45.81 326.77,45.3 323.49,42.02 320.65,42.02 318.17,39.54 318.17,24.99 315.49,22.31 308.86,22.31 308.7,22.15 308.7,22.15 305.72,19.17 303.82,19.17 303.19,19.81 301.89,19.81 v2(301.41,19.33)
B+: length 194.9
  TOP w0.508: PR244.1 13.25,5.93 PQ215.3 v2(15.75,5.93)
  IN2 w0.508: v2(34.28,16.5) 32.99,17.79 28.92,17.79 26.84,15.71 26.84,11.11 22.65,6.92 16.74,6.92 v2(15.75,5.93)
  IN6 w1.016: 253.75,22.11 254,22.36 254,24.08 255.8,25.88 259.18,25.88 260.81,27.5 269.15,27.5 271.73,24.93 277.84,24.93 278.51,25.6
  BOTTOM w0.381: v2(64.5,19.28) 64.5,18.98 63.88,18.36 PR107.1
  BOTTOM w1.016: 252.81,20.06 252.81,12.66 243.79,3.64 237.23,3.64 236.08,2.48 216.6,2.48 204.66,14.43 178.86,14.43 176.74,12.31 171.04,12.31 170.69,12.65 140.99,12.65 137.92,9.58
  vias: v1(35.56,14.97) v2(34.28,15.87) v2(34.93,16.51) v2(34.93,15.87) v2(35.56,16.51) v2(35.56,15.87) v2(36.2,19.05) v2(36.2,18.41) v2(36.2,17.78) v2(36.2,17.14) v2(36.2,16.51) v2(36.2,15.87) v2(36.83,19.05) v2(36.83,18.41) v2(36.83,17.78) v2(36.83,17.14) v2(36.83,16.51) v2(36.83,15.87) v2(37.05,21.56) v2(37.47,19.05) v2(37.47,18.41) v2(37.47,17.78) v2(37.47,17.14) v2(37.47,16.51) v2(37.47,15.87) v2(37.68,21.56) v2(38.1,19.05) v2(38.1,18.41) v2(38.1,17.78) v2(38.1,17.14) v2(38.09,16.52) v2(38.09,15.89) v2(38.32,21.56) v2(38.95,21.56) v2(104.22,68.69) v2(104.22,68.06) v2(104.22,67.42) v2(104.22,66.79) v2(104.84,68.69) v2(104.84,68.06) v2(104.84,67.42) v2(104.84,66.79) v2(105.03,56.52) v2(105.35,67.76) v2(105.41,67.06) v2(105.73,56.52) v2(108.18,99.37) v2(108.81,99.37) v2(109.08,43.66) v2(109.45,99.37) v2(109.5,44.14) v2(109.92,43.63) v2(109.98,44.53) v2(110.08,99.37) v2(110.43,44.98) v2(110.43,44.08) v2(110.88,45.43) v2(110.88,44.53) v2(110.88,43.63) v2(111.32,45.88) v2(111.32,44.98) v2(111.32,44.08) v2(111.77,46.33) v2(111.77,45.43) v2(111.77,44.53) v2(112.22,46.78) v2(112.22,45.88) v2(112.22,44.98) v2(112.67,46.33) v2(112.78,47.19) v2(129.26,106.77) v2(129.26,105.66) v2(129.54,106.21) v2(129.88,106.77) v2(129.91,105.66) v2(130.19,106.21) v2(130.54,106.77) v2(130.58,105.67) v2(130.9,106.21) v2(131.22,106.77) v2(131.27,105.67) v2(131.66,106.21) v2(131.98,105.67) v2(168.31,118.07) v2(168.32,117.42) v2(168.33,116.78) v2(168.37,116.11) v2(168.95,118.07) v2(168.95,117.43) v2(168.95,116.8) v2(168.88,115.66) v2(169.25,116.24) v2(169.58,118.07) v2(169.58,117.43) v2(169.58,116.8) v2(169.94,116.24) v2(170.22,118.07) v2(170.22,117.43) v2(170.22,116.8) v2(210.34,48.36) v2(210.92,48.36) v2(236.31,44.1) v2(236.94,44.1) v2(237.58,44.1) v2(238.21,44.1) v2(238.85,44.1) v2(252.82,21.87) v2(252.82,21.17) v2(279.08,26.17) v2(279.72,26.17) v2(316.04,16.01) v2(316.17,15.38) v2(316.55,16.33) v2(316.55,14.87) v2(316.68,15.76) v2(316.99,15.25) v2(317.06,16.71) v2(317.25,16.14) v2(317.18,14.68) v2(317.63,17.66) v2(317.63,17.03) v2(317.56,15.38) v2(318.26,18.36) v2(318.26,17.73) v2(318.26,17.09)
B++: length 12.8
  TOP w0.508: PR415.2 v2(339.66,22.61)
  BOTTOM w0.508: v2(339.66,22.61) 338.46,21.41 337.19,21.41 336.61,20.84 332.68,20.84 329.76,17.92 v2(329.76,17.66)
  vias: v1(320.31,18.3)
B+_0.95V: length 0.8
  TOP w0.14: v1(105.33,58.28) 106.16,58.28
  vias: v2(106.24,60.08) v2(106.24,59.44) v2(106.24,58.81) v2(106.81,59.13) v2(106.81,58.49)
B+_1.05V: length 2.5
  TOP w0.14: PL900.2 215.23,47.32 v1(214.65,46.74)
B+_1V: length 4.5
  TOP w0.508: PC504.1 135.22,7.54 PC503.1 136.35,7.43 v1(137.12,6.65) v2(137.8,5.98)
B+_IN:
  vias: v1(26.48,7.06)
B_DE0: length 2.8
  TOP w0.14: v2(316.55,31.54) 316.18,31.54 v3(315.89,31.25)
  BOTTOM w0.14: UI3.3 317.25,32.14 316.65,31.54 v2(316.55,31.54) 316.14,31.54 RI21.1
B_DE1: length 3.2
  BOTTOM w0.14: RI22.1 315.66,35.73 316.33,35.06 v3(316.33,34.45) 317.14,33.64 UI3.6
B_EQ0: length 4.4
  BOTTOM w0.14: v3(313.93,30.64) 314.33,30.64 314.64,30.32 315.38,30.32 RI17.1 316.49,30.87 317.26,31.64 UI3.2
B_EQ1: length 2.8
  TOP w0.14: v3(317.29,31.67) 316.84,32.11 v2(316.84,32.42)
  BOTTOM w0.14: UI3.4 317.07,32.64 v2(316.84,32.42) 316.16,32.42 RI18.1
B_PWM_EC: length 32.5
  TOP w0.14: v3(302.18,30.06) 302.13,30.11 RE122.2 301.07,31 301.27,31 v2(301.68,31.4) ; UE3.B25 v2(302.93,14.88)
  IN4 w0.091: v2(302.93,14.88) 302.5,15.3 301.65,15.3 301.1,15.85 295.34,15.85 295.34,15.84 294.93,15.84 294.26,16.52 294.26,19.44 295.17,20.35 295.17,21.57 294.9,21.85 294.9,22.23 295.4,22.74 295.4,27.69 296.29,28.58 297.36,28.58 299.62,30.84 301.12,30.84 v2(301.68,31.4)
BAT1_LED#: length 172.1
  TOP w0.14: RE118.1 299.98,24.32 v2(299.42,24.88)
  IN2 w0.099: v2(299.35,6.33) 299.08,6.6 297.08,6.6 296.68,6.2 292.68,6.2 292.34,6.54 289.63,6.54 v2(289.35,6.26) 289.04,5.95 285.69,5.95 284.94,6.7 282.82,6.7 282.07,5.95 273.88,5.95 271.91,7.92 262.53,7.92 262.28,8.18 256.99,8.18 255.94,7.13 252.97,7.13 252.22,7.88 245.84,7.88 245.54,7.58 240.4,7.58 238.52,5.7 227.46,5.7 226.11,7.04 213.47,7.04 210.53,9.98 210.52,9.98 210.43,10.06 200.37,10.06 200.34,10.04 184.75,10.04 184.15,9.44 178.34,9.44 177.7,10.09 175.06,10.09 174.53,10.61 168.91,10.61 v2(167.77,9.47)
  BOTTOM w0.14: v2(299.42,24.88) 299.42,23.33 298.93,22.84 298.93,21.57 300.91,19.59 300.91,18.25 299.55,16.88 299.55,13.25 299.02,12.72 299.02,10.37 299.21,10.18 299.21,6.47 v2(299.35,6.33) ; v2(167.77,9.47) 167.04,8.75 167.04,8.13 166.48,7.57 164.97,7.57 164.4,8.14 163.58,8.14 163.25,7.81 161.1,7.81 160.7,8.21 159.67,8.21 158.77,9.11 JKB.10
