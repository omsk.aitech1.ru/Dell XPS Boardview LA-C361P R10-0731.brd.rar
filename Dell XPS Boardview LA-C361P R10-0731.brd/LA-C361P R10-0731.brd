# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_TBRX_N15_C: length 3.2
  BOTTOM w0.089: UT1.Y22 30.94,35.84 30.94,35.44 31.74,34.64 32.03,34.64 32.31,34.36 32.31,34.3
  BOTTOM w0.152: CT4.1 32.31,33.91 32.31,34.3
PCIE_PTX_TBRX_N16: length 57.9
  IN6 w0.107: v2(79.29,26.22) 79.36,26.15 79.46,26.15 79.62,26.3 79.62,26.6 79.49,26.73 76.1,26.73 75.1,27.73 67.77,27.73 65.2,30.3 61.02,30.3 60.36,30.96 53.7,30.96 52.21,32.45 46.17,32.45 43.03,35.58 34.12,35.58 33.16,34.62 32.5,34.62 32.12,34.24 30.11,34.24 29.45,33.58 29.45,33 29.83,32.62 v2(29.87,32.62)
  BOTTOM w0.089: v2(79.29,26.22) 79.62,25.89 79.62,25.81 79.62,25.81 UH2.A41
  BOTTOM w0.152: CT8.2 29.7,33.04 29.7,32.78 v2(29.87,32.62)
PCIE_PTX_TBRX_N16_C: length 2.7
  BOTTOM w0.089: UT1.T22 29.1,35.84 29.1,35.84 29.11,35.83 29.11,35.28 29.54,34.85 29.54,34.37 29.6,34.31 29.6,34.3
  BOTTOM w0.152: CT8.1 29.85,33.89 29.6,34.13 29.6,34.3
PCIE_PTX_TBRX_P15: length 58.4
  IN6 w0.107: v2(31.9,32.62) 32.07,32.79 32.07,33.52 32.73,34.18 34.18,34.18 35.17,35.17 42.86,35.17 47.07,30.97 49.59,30.97 50.66,32.04 52.04,32.04 53.53,30.55 60.08,30.55 61.02,29.6 65.3,29.6 68.38,26.53 74.61,26.53 75.6,25.53 80.12,25.53 80.38,25.79 80.38,26.48 v2(80.71,26.82)
  BOTTOM w0.089: v2(80.71,26.82) 81.14,26.39 81.14,26.07 80.82,25.75 UH2.A39
  BOTTOM w0.152: CT2.2 32.02,33.04 32.02,32.74 v2(31.9,32.62)
PCIE_PTX_TBRX_P15_C: length 3.2
  BOTTOM w0.089: UT1.Y23 30.71,35.69 30.64,35.76 30.55,35.76 30.48,35.68 30.48,35.33 30.55,35.25 30.81,35.25 31.6,34.46
  BOTTOM w0.152: CT2.1 31.98,33.87 31.98,34.3 31.9,34.38 31.69,34.38 31.6,34.46
PCIE_PTX_TBRX_P16: length 58
  IN6 w0.107: v2(29.24,32.62) 29.24,33.67 30.02,34.44 32.04,34.44 32.41,34.82 33.07,34.82 34.03,35.78 43.12,35.78 46.25,32.65 52.29,32.65 53.78,31.16 60.45,31.16 61.11,30.5 65.29,30.5 67.86,27.93 75.18,27.93 76.18,26.93 79.58,26.93 79.82,26.69 79.82,26.38 v2(79.99,26.22)
  BOTTOM w0.089: v2(79.99,26.22) 79.9,26.13 79.9,25.91 UH2.A40
  BOTTOM w0.152: CT6.2 29.37,33.09 29.37,32.74 v2(29.24,32.62)
PCIE_PTX_TBRX_P16_C: length 2.6
  BOTTOM w0.089: 29.27,34.3 29.27,34.74 28.64,35.38 28.64,35.68 28.72,35.76 28.83,35.76 28.87,35.72 UT1.T23
  BOTTOM w0.152: 29.27,34.3 CT6.1
PCIE_PTX_WLANRX_N1: length 319.5
  IN2 w0.119: v2(332.19,78.11) 332.19,78.31 332.08,78.42 331.8,78.42 331.55,78.16 331.55,77.64 332.98,76.21 332.98,67.1 333.55,66.54 333.55,65.5 339.44,59.6 339.44,46.87 337.94,45.37 337.94,40.53 336.67,39.26 336.67,34.53 336.15,34.01 336.15,32.23 334.94,31.02 326.92,31.02 325.72,29.82 323.06,29.82 320.68,27.44 320.68,25.59 315.88,20.79 304.18,20.79 303.51,20.12 295.82,20.12 295.35,19.65 295,19.65 293.48,18.13 293.28,18.13 292.62,17.47 290.9,17.47 290.74,17.63 289.36,17.63 288.95,17.22 288.05,17.22 286.89,16.06 284.7,16.06 283.43,14.8 279.02,14.8 278.72,15.1 267.75,15.1 266.73,16.12 265.99,16.12 265.95,16.08 265.94,16.08 v2(265.77,15.91)
  IN3 w0.112: v2(265.77,15.91) 265.62,16.06 265.3,16.06 264.24,17.12 261.35,17.12 260.93,16.7 254.47,16.7 251.99,14.22 243.52,14.22 243,14.74 232.3,14.74 230.73,13.17 224.45,13.17 223.47,12.19 211.96,12.19 211.35,12.79 124.58,12.79 121.13,16.24 121.13,17 120.14,17.99 104.43,17.99 102.69,19.73 96.78,19.73 95.25,21.26 95.25,21.51 92.39,24.37 92.39,24.94 91.76,25.57 91.76,25.99 v2(91.62,26.13)
  BOTTOM w0.089: UH2.A16 92.04,25.94 92.04,26.22 91.92,26.34 91.82,26.34 v2(91.62,26.13)
  BOTTOM w0.17: CN20.1 331.12,80.5 331.12,78.65 331.65,78.11 v2(332.19,78.11)
PCIE_PTX_WLANRX_P1: length 319.5
  IN2 w0.119: v2(265.77,16.49) 265.89,16.38 266.84,16.38 267.86,15.36 278.83,15.36 279.12,15.06 283.33,15.06 284.59,16.32 286.79,16.32 287.94,17.48 288.84,17.48 289.26,17.89 290.84,17.89 291,17.73 292.51,17.73 293.17,18.39 293.37,18.39 294.9,19.91 295.24,19.91 295.71,20.38 303.41,20.38 304.07,21.05 315.77,21.05 320.42,25.7 320.42,27.55 322.95,30.08 325.62,30.08 326.81,31.28 334.83,31.28 335.89,32.34 335.89,34.12 336.41,34.63 336.41,39.37 337.68,40.64 337.68,45.47 339.18,46.98 339.18,59.49 333.29,65.39 333.29,66.43 332.72,67 332.72,76.1 331.29,77.53 331.29,78.06 331.29,78.27 331.69,78.68 331.91,78.68 332.03,78.68 v2(332.23,78.88)
  IN3 w0.112: v2(265.77,16.49) 265.59,16.3 265.41,16.3 264.34,17.37 261.24,17.37 260.83,16.95 254.37,16.95 251.88,14.47 243.62,14.47 243.1,14.99 232.2,14.99 230.63,13.42 224.34,13.42 223.37,12.44 212.06,12.44 211.46,13.04 124.68,13.04 121.37,16.35 121.37,17.1 120.24,18.23 104.53,18.23 102.79,19.98 96.88,19.98 95.49,21.36 95.49,21.61 92.63,24.47 92.63,25.04 92,25.67 92,26.1 92.01,26.1 92.01,26.21 92.15,26.35 92.34,26.35 92.5,26.2 v2(92.5,26.08)
  BOTTOM w0.089: v2(92.5,26.08) 92.5,26 91.84,25.34 UH2.B16
  BOTTOM w0.17: CN21.1 331.8,80.65 331.55,80.4 331.55,78.83 331.75,78.62 331.98,78.62 v2(332.23,78.88)
PCIE_PTX_WLANRX_RE_N1: length 11.9
  BOTTOM w0.17: JNGFF1.29 337.55,85.44 336.76,86.24 332.97,86.24 330.96,84.24 CN20.2
PCIE_PTX_WLANRX_RE_P1: length 11.9
  BOTTOM w0.17: JNGFF1.27 337.05,84.78 337.12,84.84 337.12,85.27 336.58,85.81 333.15,85.81 331.39,84.06 331.39,82.13 331.47,82.05 331.47,81.29 331.56,81.2 331.64,81.12 331.94,81.12 332.11,81.29 CN21.2
PCIE_WAKE#: length 157.6
  TOP w0.14: v2(300.15,3.43) 300.55,3.82 RE19.1 300.86,3.34 301.25,2.95 302.1,2.95 302.69,3.54 RE120.2 ; UE3.B8 v2(298.52,11.47) ; v2(271.89,9.29) 271.89,8.94 v3(271.58,8.64) 271.02,8.07 268.68,8.07 RD59.2
  IN3 w0.091: v2(298.52,11.47) 298.52,10.45 299.16,9.81 299.16,7.86 299.76,7.26 299.76,5.06 300.15,4.67 v2(300.15,3.43)
  IN6 w0.099: v2(336.45,87.51) 336.09,87.51 331.14,82.55 331.14,78.63 330.75,78.25 330.75,76.11 329.82,75.18 329.82,69.63 330.23,69.22 330.23,60.66 328.58,59.01 328.58,55.1 327.08,53.6 327.08,52.21 325.55,50.69 325.55,49.45 326.37,48.64 326.37,46.2 322.76,42.59 322.76,37.7 322.31,37.26 322.31,36.15 321.08,34.92 321.08,30.33 317.64,26.89 317.64,25.59 317.16,25.11 317.16,20.82 313.18,16.85 313.18,16.22 311.66,14.69 307.63,14.69 307.1,14.16 304.9,14.16 303.21,12.47 301.45,12.47 301.22,12.7 299.33,12.7 298.97,12.34 298.97,11.92 v2(298.52,11.47) 297.99,12 297.99,12.4 297.2,13.19 290.47,13.19 289.73,13.94 289.26,13.94 288.75,14.45 287.12,14.45 286.14,13.47 286.14,12.47 285.6,11.92 284.36,11.92 284.22,12.06 282.33,12.06 281.34,11.06 275.44,11.06 273.67,9.29 v2(271.89,9.29)
  BOTTOM w0.14: JNGFF1.47 342.05,84.77 342.2,84.92 342.2,87.44 341.44,88.2 337.14,88.2 v2(336.45,87.51)
PD_EE_CLK: length 29.2
  TOP w0.14: v2(16.89,25.41) 16.19,25.41 15.86,25.09 14.63,25.09 v1(14.53,24.98)
  IN3 w0.091: v2(16.89,25.41) 16.56,25.74 16.56,36.2 15.56,37.2 15.56,40.87 15.16,41.26 15.16,42.08 14.57,42.67 11.99,42.67 10.99,41.67 10.73,41.67 v2(10.3,41.24)
  BOTTOM w0.081: v2(10.3,41.24) 10.26,41.2 10.26,40.46 UT4.A3
  BOTTOM w0.14: v2(16.89,25.41) 16.89,25.27 17.13,25.03 RT210.2 17.65,25.07 UT5.6
PD_EE_CS#: length 15.3
  IN3 w0.091: v2(10.9,41.27) 10.91,41.26 11.29,41.26 11.67,41.64 12.43,41.64 13,41.07 14.81,41.07 15.17,40.71 15.17,36.74 v2(15.65,36.27)
  BOTTOM w0.081: UT4.B3 10.55,40.17 10.55,40.93 v2(10.9,41.27) 10.9,41.33 10.88,41.35
  BOTTOM w0.14: UT5.1 15.11,34.97 15.03,35.06 RT213.2 15.46,36.08 v2(15.65,36.27) ; 10.88,41.35 10.88,41.9 10.64,42.14 10.64,42.29 RT168.2
PD_EE_DI: length 26.2
  IN3 w0.091: v2(10.32,39.42) 10.85,38.89 12.69,38.89 13.34,39.54 13.7,39.54 13.98,39.26 14.34,39.26 14.59,39.01 14.59,36.17 15.04,35.72 15.04,35.42 15.97,34.49 15.97,27.99 v2(15.77,27.8)
  BOTTOM w0.081: UT4.B4 9.82,39.92 10.32,39.42 v2(10.32,39.42)
  BOTTOM w0.14: v2(15.77,27.8) 16.72,27.8 16.87,27.64 17.3,27.64 17.48,27.82 17.95,27.82 18.29,27.48 18.29,25.65 18.87,25.07 RT211.2 ; RT211.2 19.18,25.5 18.92,25.76 UT5.5 ; RT211.2 19.4,25.07 19.44,25.11 19.87,25.11 20,24.98 v3(20.17,24.98)
PD_EE_DO: length 16.1
  IN3 w0.091: v2(9.69,41.27) 10.93,40.03 12.85,40.03 13.7,40.88 14.73,40.88 14.98,40.63 14.98,36.57 15.25,36.31 15.25,36.06 v2(15.65,35.66)
  BOTTOM w0.081: UT4.A4 9.8,41.16 v2(9.69,41.27) 9.77,41.35
  BOTTOM w0.14: v2(15.65,35.66) RT212.2 UT5.2 ; 9.77,41.35 9.78,41.36 v3(9.78,41.79) RT169.2
PD_EE_WP#: length 7.4
  BOTTOM w0.14: UT5.3 17.65,33.18 17.3,32.83 17.3,32.29 17.48,32.11 19.41,32.11 20.69,33.4 v1(20.69,33.98) 20.19,34.48 RT170.2
PD_HOLD#: length 7.3
  BOTTOM w0.14: UT5.7 v3(16.38,24.39) 13.84,24.39 12.57,25.66 RT171.2
PD_I2C_ALERT#: length 348.3
  TOP w0.14: UE3.A42 v2(298.27,21.55) ; RE99.1 299.09,25.26 v2(298.68,24.85)
  IN2 w0.099: v2(299.9,27.39) 299.9,27.82 299.66,28.06 297.62,28.06 296.88,27.32 295.64,27.32 293.94,25.61 293.14,25.61 290.81,23.28 290.81,22.7 290.21,22.1 280.72,22.1 279.23,20.6 278.52,20.6 278.14,20.22 275.21,20.22 274.86,20.57 268.36,20.57 267.28,19.49 264.44,19.49 v2(264.17,19.76) 264,19.93 263.12,19.93 262.47,19.28 258.11,19.28 257.42,18.58 254.9,18.58 254.28,17.96 176.06,17.96 175.58,18.44 173.23,18.44 173.02,18.65 158.91,18.65 157.76,19.8 157.76,24.65 157.15,25.26 155.58,25.26 154.48,26.36 146.02,26.36 139.2,33.18 116.26,33.18 111.21,38.23 100.58,38.23 97.4,35.05 88.26,35.05 84.6,31.39 80.6,31.39 79.64,30.44 74.32,30.44 73.61,29.72 71.04,29.72 70.09,30.68 53.78,30.68 52.76,31.7 50.7,31.7 49.94,30.94 47.82,30.94 44.74,34.01 41.02,34.01 40.65,34.38 33.77,34.38 33.11,35.04 v2(32.01,35.04)
  IN3 w0.091: v2(31.02,28.49) 31.02,27.98 30.84,27.8 28.88,27.8 28.32,27.24 28.32,26.94 27.17,25.79 22.08,25.79 21.76,26.1 18.17,26.1 17.07,25.01 15.76,25.01 15.36,25.41 15.36,26.47 16.18,27.28 16.18,34.56 15.24,35.5 15.24,35.8 14.78,36.25 14.78,39.09 14.42,39.46 14.06,39.46 13.67,39.84 8.94,39.84 8.59,39.49 v2(8.59,39.38)
  IN4 w0.091: v2(299.9,27.39) 299.59,27.39 299.46,27.25 299.46,26.87 298.89,26.31 298.89,25.06 v2(298.68,24.85) 298.68,21.95 v2(298.27,21.55)
  IN5 w0.089: v2(32.01,35.04) 32.34,35.04 33.08,34.3
  IN5 w0.099: v2(31.02,28.49) 33.35,30.82 33.35,31.43 33.96,32.04 33.96,33.42 33.08,34.3
  BOTTOM w0.081: v2(8.59,39.38) 8.59,39.7 UT4.B6
PD_SENSEN: length 43.5
  TOP w0.14: v1(12.69,5.23) 12.47,5.44 v2(11.34,5.44)
  TOP w0.254: PR218.2 11.34,4.96 v2(11.34,5.44)
  IN3 w0.091: v2(11.34,5.44) 10.94,5.04 10.49,5.04 7.16,8.37 7.16,18.56 6.76,18.97 6.76,24.89 4.12,27.53 4.12,38.68 6.39,40.95 v2(6.66,40.95)
  BOTTOM w0.081: UT4.A10 6.8,40.81 v2(6.66,40.95)
PD_SENSEP: length 41.4
  TOP w0.14: v2(10.76,5.46) 10.64,5.46 v1(10.02,6.08)
  TOP w0.254: v2(10.76,5.46) 10.76,4.95 PR221.2
  IN3 w0.091: v2(7.3,38.81) 5.76,38.81 4.68,37.72 4.68,27.74 7.42,25 7.42,20.89 7.44,20.87 7.44,20.86 8.52,19.79 8.52,18.57 8.35,18.4 8.35,17.74 7.89,17.28 7.89,11.64 8.55,10.98 8.55,8.51 10.76,6.3 v2(10.76,5.46)
  BOTTOM w0.081: v2(7.3,38.81) 7.06,39.05 7.06,39.52 6.8,39.78 UT4.B10
PEG_GTX_C_HRX_N0: length 27.3
  TOP w0.152: CV532.2 197.11,70.91 197.11,71.09 196.98,71.22 196.42,71.22 190.96,65.76 188.16,65.76 186.93,64.52 186.93,63.9 187.13,63.7 v2(187.13,63.7)
  IN1 w0.089: 179.95,64.53 177.82,64.53 177.35,65 175.84,65 175.77,65.07 175.77,65.2 v2(175.81,65.24)
  IN1 w0.107: 179.95,64.53 179.99,64.53 180,64.54 186.56,64.54 186.84,64.26 186.84,63.88 187.02,63.7 v2(187.13,63.7)
  BOTTOM w0.076: UH1.E10 175.48,65.38 175.63,65.24 v2(175.81,65.24)
PEG_GTX_C_HRX_N1: length 28.9
  TOP w0.152: v2(188.95,63.74) 188.82,63.87 188.82,64.29 189.07,64.53 189.13,64.59 191.45,64.59 196.75,69.89 198.58,69.89 CV534.2
  IN1 w0.089: 179.95,64.98 179.94,64.98 179.93,64.99 178,64.99 177.67,65.31 176.29,65.31 176,65.6 176,65.83 v2(175.81,66.02)
  IN1 w0.107: 179.95,64.98 186.95,64.98 187.67,64.26 187.67,63.45 188,63.12 188.52,63.12 188.76,63.36 188.76,63.55 v2(188.95,63.74)
  BOTTOM w0.076: v2(175.81,66.02) 175.48,66.35 UH1.E11
PEG_GTX_C_HRX_N2: length 28.1
  TOP w0.152: CV536.2 198.97,72.67 198.97,72.48 198.87,72.37 198.35,72.37 198.17,72.55 195.7,72.55 v4(193.96,70.82) 190.62,67.47 188.66,67.47 188.48,67.65 v2(188.48,67.83)
  IN1 w0.089: 179.22,66.16 179.21,66.16 179.2,66.15 179.14,66.15 179.13,66.14 177.76,66.14 177.32,66.58 176.22,66.58 176.17,66.64 176.17,66.81 176.04,66.94 175.93,66.94 v2(175.81,66.81)
  IN1 w0.107: v2(188.48,67.83) 188.19,67.83 187.98,68.03 187.39,68.03 185.32,65.96 179.59,65.96 179.39,66.16 179.22,66.16
  BOTTOM w0.076: v2(175.81,66.81) 175.63,66.81 175.48,66.96 UH1.E12
PEG_GTX_C_HRX_N3: length 26.8
  TOP w0.152: v2(186.63,69.58) 186.63,69.4 186.97,69.06 190.62,69.06 195.3,73.75 195.87,73.75 196.06,73.93 CV538.2
  IN1 w0.089: v2(175.81,67.6) 175.97,67.43 175.97,67.26 176.26,66.98 177.57,66.98 178,66.55 179.66,66.55 179.67,66.54 179.73,66.54 179.74,66.53 179.84,66.53
  IN1 w0.107: 179.84,66.53 184.91,66.53 186.92,68.54 186.92,69.05 186.63,69.34 v2(186.63,69.58)
  BOTTOM w0.076: UH1.E13 175.48,67.92 v2(175.81,67.6)
PEG_GTX_C_HRX_N4: length 29.4
  TOP w0.152: v2(187.63,70.53) 187.63,70.32 187.82,70.13 190.2,70.13 195,74.93 197.99,74.93 198.2,74.72 198.51,74.72 CV540.2
  IN1 w0.089: v2(175.16,68.39) 175.08,68.46 174.95,68.46 174.83,68.34 174.83,68.11 174.96,67.98 175.31,67.98 175.48,68.15 177.33,68.15 177.73,67.75 179.36,67.75 179.5,67.61 179.57,67.61
  IN1 w0.107: v2(187.63,70.53) 187.62,70.52 187.24,70.52 187.11,70.66 186.69,70.66 186.3,70.27 184.9,70.27 182.25,67.61 179.57,67.61
  BOTTOM w0.076: v2(175.16,68.39) 175.48,68.71 UH1.E14
PEG_GTX_C_HRX_N5: length 26.8
  TOP w0.152: v2(186.34,71.96) 186.34,71.78 186.61,71.5 189.93,71.5 194.4,75.97 195.05,75.97 195.55,76.47 CV542.2
  IN1 w0.089: v2(175.81,69.17) 175.96,69.01 175.96,68.84 176.19,68.61 177.46,68.61 177.84,68.23 179.87,68.23 179.88,68.22 179.9,68.22
  IN1 w0.107: 179.9,68.22 182.17,68.22 184.68,70.74 186.12,70.74 186.55,71.17 186.55,71.5 186.34,71.71 v2(186.34,71.96)
  BOTTOM w0.076: v2(175.81,69.17) 175.48,69.5 UH1.E15
PEG_GTX_C_HRX_N6: length 29.2
  TOP w0.152: v2(187.67,73.29) 187.62,73.24 187.62,72.97 188.17,72.41 189.25,72.41 193.86,77.02 194.54,77.02 194.9,77.38 197.99,77.38 198.37,77 198.74,77 198.86,77.12 CV544.2
  IN1 w0.089: v2(175.81,69.96) 175.74,69.9 175.74,69.8 175.82,69.72 177.58,69.72 177.96,69.34 179.87,69.34 179.88,69.35 179.9,69.35
  IN1 w0.107: 179.9,69.35 182.08,69.35 186.26,73.53 186.97,73.53 187.38,73.12 187.38,73.12 187.39,73.11 187.49,73.11 v2(187.67,73.29)
  BOTTOM w0.076: UH1.E16 175.48,70.11 175.62,69.96 v2(175.81,69.96)
PEG_GTX_C_HRX_N7: length 26.5
  TOP w0.152: v2(188.68,74.34) 188.89,74.34 189.11,74.13 189.68,74.13 193.3,77.75 194.26,77.75 194.66,78.15 196.67,78.15 CV546.2
  IN1 w0.089: 179.9,69.81 178.47,69.81 178.18,70.09 176.21,70.09 175.94,70.36 175.94,70.61 v2(175.81,70.75)
  IN1 w0.107: v2(188.68,74.34) 188.68,74.61 188.44,74.85 187.87,74.85 187.38,74.37 186.48,74.37 181.92,69.81 179.9,69.81
  BOTTOM w0.076: UH1.E17 175.48,71.07 v2(175.81,70.75)
PEG_GTX_C_HRX_N8: length 29.8
  TOP w0.152: v2(187,76.64) 187,76.56 187.41,76.15 189.5,76.15 192.5,79.14 193.51,79.14 193.88,79.51 198.72,79.51 CV548.2
  IN1 w0.089: v2(175.16,71.54) 175.56,71.13 177.24,71.13 177.63,70.74 179.86,70.74 179.87,70.73 179.9,70.73
  IN1 w0.107: 179.9,70.73 181.97,70.73 186.65,75.41 187.06,75.41 187.39,75.74 187.39,76.04 187,76.44 v2(187,76.64)
  BOTTOM w0.076: UH1.F18 174.83,71.86 v2(175.16,71.54)
PEG_GTX_C_HRX_N9: length 27.3
  TOP w0.152: v2(188.09,77.74) 188.09,77.48 188.35,77.22 188.78,77.22 191.81,80.26 192.85,80.26 193.23,80.64 v4(194.79,80.64) 196.93,80.64 197.07,80.78 197.07,80.93 CV551.2
  IN1 w0.089: v2(175.81,72.32) 175.81,72.18 175.89,72.09 176.03,72.09 176.29,71.84 176.71,71.84 176.81,71.94 177.71,71.94 178.08,71.57 178.98,71.57 179.12,71.71 179.91,71.71 179.92,71.72 179.94,71.72
  IN1 w0.107: v2(188.09,77.74) 188.02,77.67 187.76,77.67 187.52,77.91 187.06,77.91 180.87,71.72 179.94,71.72
  BOTTOM w0.076: UH1.D19 175.88,72.72 175.77,72.6 175.77,72.36 v2(175.81,72.32)
PEG_GTX_C_HRX_N10: length 31
  TOP w0.152: CV557.2 196.86,84.88 191.18,84.88 188.23,81.93 188.23,79.02 188.72,78.53 v2(188.72,78.4)
  IN1 w0.089: v2(175.16,73.11) 175.29,73.11 175.72,72.69 177.39,72.69 177.7,72.38 179.87,72.38 179.88,72.37 179.9,72.37
  IN1 w0.107: 179.9,72.37 180.78,72.37 187.22,78.81 188.43,78.81 188.72,78.52 v2(188.72,78.4)
  BOTTOM w0.076: UH1.F20 174.83,73.44 v2(175.16,73.11)
PEG_GTX_C_HRX_N11: length 28.5
  TOP w0.152: CV559.2 197.09,82.58 197.09,82.76 196.98,82.88 191.64,82.88 189.74,80.97 189.74,80.2 190.06,79.88 v2(190.24,79.88)
  IN1 w0.089: v2(176.46,73.9) 176.39,73.96 176.25,73.96 176.17,73.88 176.17,73.62 176.33,73.47 178.35,73.47 178.63,73.19 179.77,73.19 179.82,73.24 179.9,73.24
  IN1 w0.107: v2(190.24,79.88) 189.92,79.88 189.68,80.12 187.29,80.12 180.41,73.24 179.9,73.24
  BOTTOM w0.076: UH1.D21 176.33,74.29 176.5,74.12 176.5,73.94 v2(176.46,73.9)
PEG_GTX_C_HRX_N12: length 28.7
  TOP w0.152: CV561.2 198.4,81.25 198.05,81.25 197.78,81.52 192.44,81.52 192.18,81.25 192.18,80.88 v2(192.24,80.82)
  IN1 w0.089: v2(175.16,74.69) 175.52,74.32 176.06,74.32 176.12,74.26 177.26,74.26 177.55,73.97 179.9,73.97
  IN1 w0.107: 179.9,73.97 180.55,73.97 187.16,80.58 190.7,80.58 191.2,80.07 191.81,80.07 192.09,80.35 192.09,80.67 v2(192.24,80.82)
  BOTTOM w0.076: v2(175.16,74.69) 174.83,75.01 UH1.F22
PEG_GTX_C_HRX_N13: length 28.4
  TOP w0.152: CV563.2 196.67,86.35 192.43,86.35 192.16,86.62 190.2,86.62 189.74,86.16 189.74,85.77 v2(189.61,85.64)
  IN1 w0.089: v2(176.46,75.47) 176.33,75.47 176.19,75.33 176.19,75.17 176.32,75.04 178.08,75.04 178.43,74.69 178.89,74.69 178.89,74.69 178.92,74.69
  IN1 w0.107: 178.92,74.69 180.08,74.69 189.82,84.43 189.82,85.44 v2(189.61,85.64)
  BOTTOM w0.076: UH1.D23 176.13,75.8 v2(176.46,75.47)
PEG_GTX_C_HRX_N14: length 29.8
  TOP w0.152: CV565.2 196.82,88.27 196.02,88.27 195.52,87.78 194.32,87.78 194.18,87.92 194.18,88.19 v2(194.3,88.31)
  IN1 w0.107: v2(194.3,88.31) 194.12,88.13 194.12,87.49 193.62,86.99 190.25,86.99 188.75,85.49 188.75,83.99 180.64,75.88 175.54,75.88 v2(175.16,76.26)
  BOTTOM w0.076: v2(175.16,76.26) 175.16,76.33 UH1.F24
PEG_GTX_C_HRX_N15: length 29.9
  TOP w0.152: v2(194.26,89.79) 194.15,89.67 194.15,89.45 194.34,89.26 194.8,89.26 195.29,89.76 196.84,89.76 196.98,89.9 CV567.2
  IN1 w0.107: v2(176.46,77.05) 176.35,77.05 176.19,77.21 176.19,77.37 176.34,77.53 177.34,77.53 177.6,77.26 181.13,77.26 187.86,83.99 187.86,85.95 190.79,88.88 193.79,88.88 194.07,89.17 194.07,89.59 v2(194.26,89.79)
  BOTTOM w0.076: UH1.D25 176.1,77.41 176.1,77.18 176.23,77.05 v2(176.46,77.05)
PEG_GTX_C_HRX_P0: length 27.3
  TOP w0.152: v2(186.48,63.69) 186.6,63.81 186.6,64.66 187.77,65.83 188.03,66.09 190.82,66.09 196.28,71.55 196.86,71.55 CV531.2
  IN1 w0.089: v2(175.16,65.24) 175.29,65.24 175.72,64.81 177.27,64.81 177.74,64.34 179.86,64.34 179.87,64.33 179.93,64.33 179.94,64.33 179.95,64.33
  IN1 w0.107: v2(186.48,63.69) 186.64,63.85 186.64,64.17 186.48,64.33 180.08,64.33 180.07,64.33 179.95,64.33
  BOTTOM w0.076: v2(175.16,65.24) 174.83,65.56 UH1.F10
PEG_GTX_C_HRX_P1: length 28.9
  TOP w0.152: CV533.2 198.58,70.22 196.62,70.22 191.31,64.92 188.99,64.92 188.49,64.42 188.49,63.87 v2(188.37,63.74)
  IN1 w0.089: v2(176.46,66.02) 176.37,66.02 176.19,65.85 176.19,65.68 176.37,65.5 177.75,65.5 178.07,65.18 179.91,65.18 179.92,65.19 179.95,65.19
  IN1 w0.107: 179.95,65.19 187.03,65.19 187.87,64.35 187.87,63.53 188.09,63.32 188.44,63.32 188.56,63.44 188.56,63.55 v2(188.37,63.74)
  BOTTOM w0.076: v2(176.46,66.02) 176.13,66.35 UH1.D11
PEG_GTX_C_HRX_P2: length 28.2
  TOP w0.152: CV535.2 198.71,72.04 198.21,72.04 198.03,72.22 195.84,72.22 190.76,67.14 188.53,67.14 188.25,67.42 v2(188.07,67.42)
  IN1 w0.089: v2(175.16,66.81) 175.57,66.4 177.24,66.4 177.69,65.96 179.22,65.96
  IN1 w0.107: v2(188.07,67.42) 188.07,67.66 187.9,67.83 187.47,67.83 185.4,65.76 179.51,65.76 179.31,65.96 179.22,65.96
  BOTTOM w0.076: v2(175.16,66.81) 174.83,67.14 UH1.F12
PEG_GTX_C_HRX_P3: length 26.8
  TOP w0.152: CV537.2 196.39,73.6 196.2,73.6 196.01,73.41 195.44,73.41 190.76,68.73 186.83,68.73 186.39,69.17 v2(186.22,69.17)
  IN1 w0.089: 179.84,66.73 178.08,66.73 177.65,67.16 176.34,67.16 176.16,67.34 176.16,67.52 176.24,67.6 v2(176.46,67.6)
  IN1 w0.107: 179.84,66.73 184.83,66.73 186.72,68.62 186.72,68.96 186.51,69.17 v2(186.22,69.17)
  BOTTOM w0.076: v2(176.46,67.6) 176.28,67.6 176.13,67.74 UH1.D13
PEG_GTX_C_HRX_P4: length 29.4
  TOP w0.152: CV539.2 198.65,74.4 198.64,74.39 198.06,74.39 197.86,74.6 195.14,74.6 190.34,69.8 187.68,69.8 187.37,70.11 v2(187.21,70.11)
  IN1 w0.089: 179.57,67.41 179.56,67.41 179.55,67.42 179.49,67.42 179.48,67.43 179.43,67.43 179.29,67.57 177.65,67.57 177.26,67.96 175.56,67.96 175.39,67.8 174.88,67.8 174.65,68.03 174.65,68.2 174.47,68.37 v2(174.45,68.37)
  IN1 w0.107: 179.57,67.41 182.33,67.41 184.98,70.06 186.38,70.06 186.78,70.46 187.02,70.46 187.21,70.26 v2(187.21,70.11)
  BOTTOM w0.076: v2(174.45,68.37) 174.83,68.75 UH1.F14
PEG_GTX_C_HRX_P5: length 26.8
  TOP w0.152: v2(185.92,71.54) 186.1,71.54 186.48,71.17 190.07,71.17 194.54,75.64 195.18,75.64 195.69,76.14 196.39,76.14 CV541.2
  IN1 w0.089: 179.9,68.43 179.88,68.43 179.87,68.42 177.92,68.42 177.54,68.79 176.27,68.79 176.15,68.92 176.15,69.06 176.26,69.17 v2(176.46,69.17)
  IN1 w0.107: 179.9,68.43 182.08,68.43 184.6,70.94 186.04,70.94 186.35,71.25 186.35,71.41 186.22,71.54 v2(185.92,71.54)
  BOTTOM w0.076: UH1.D15 176.13,69.32 176.28,69.17 v2(176.46,69.17)
PEG_GTX_C_HRX_P6: length 29.3
  TOP w0.152: v2(187.18,72.76) 187.36,72.76 188.04,72.08 189.38,72.08 193.99,76.69 194.68,76.69 195.03,77.05 197.86,77.05 198.23,76.67 198.65,76.67 CV543.2
  IN1 w0.089: 179.9,69.15 179.88,69.15 179.87,69.16 177.88,69.16 177.51,69.54 175.58,69.54 v2(175.16,69.96)
  IN1 w0.107: v2(187.18,72.76) 187.18,73.03 186.88,73.33 186.34,73.33 182.17,69.15 179.9,69.15
  BOTTOM w0.076: UH1.F16 174.83,70.29 v2(175.16,69.96)
PEG_GTX_C_HRX_P7: length 26.5
  TOP w0.152: v2(189.12,74.78) 189.12,74.58 189.24,74.46 189.54,74.46 193.16,78.08 194.12,78.08 194.52,78.48 196.67,78.48 CV545.2
  IN1 w0.089: 179.9,70.01 179.89,70.01 179.88,70 179.82,70 179.81,69.99 178.55,69.99 178.26,70.28 176.29,70.28 176.13,70.44 176.13,70.58 176.29,70.75 v2(176.46,70.75)
  IN1 w0.107: v2(189.12,74.78) 189.05,74.71 188.86,74.71 188.52,75.05 187.78,75.05 187.3,74.57 186.4,74.57 181.84,70.01 179.9,70.01
  BOTTOM w0.076: v2(176.46,70.75) 176.28,70.75 176.13,70.89 UH1.D17
PEG_GTX_C_HRX_P8: length 29.7
  TOP w0.152: CV547.2 199,78.9 199,79.07 198.88,79.18 194.02,79.18 193.65,78.81 192.63,78.81 189.64,75.82 187.28,75.82 186.9,76.2 v2(186.54,76.2)
  IN1 w0.089: 179.9,70.93 179.87,70.93 179.86,70.93 177.7,70.93 177.32,71.31 175.88,71.31 175.81,71.38 v2(175.81,71.54)
  IN1 w0.107: v2(186.54,76.2) 186.58,76.23 186.91,76.23 187.19,75.96 187.19,75.82 186.97,75.61 186.56,75.61 181.89,70.93 179.9,70.93
  BOTTOM w0.076: v2(175.81,71.54) 175.63,71.54 175.48,71.68 UH1.E18
PEG_GTX_C_HRX_P9: length 27.4
  TOP w0.152: CV550.2 196.79,80.31 193.37,80.31 192.99,79.93 191.95,79.93 188.91,76.89 188.22,76.89 187.83,77.28 v2(187.62,77.28)
  IN1 w0.089: v2(175.16,72.32) 175.56,71.92 175.94,71.92 176.21,71.65 176.79,71.65 176.89,71.76 177.63,71.76 178.01,71.38 179.06,71.38 179.2,71.52 179.91,71.52 179.92,71.51 179.94,71.51
  IN1 w0.107: 179.94,71.51 180.95,71.51 187.14,77.71 187.43,77.71 187.62,77.52 v2(187.62,77.28)
  BOTTOM w0.076: v2(175.16,72.32) 175.48,72.65 UH1.E19
PEG_GTX_C_HRX_P10: length 30.9
  TOP w0.152: CV552.2 197.11,84.24 197.11,84.45 197,84.55 v4(194.44,84.55) 191.32,84.55 188.56,81.79 188.56,79.16 188.93,78.79 189.13,78.79 v2(189.23,78.89)
  IN1 w0.089: v2(175.81,73.11) 175.89,73.2 176,73.2 176.07,73.12 176.07,72.92 176.12,72.87 177.47,72.87 177.78,72.56 179.87,72.56 179.88,72.57 179.9,72.57
  IN1 w0.107: 179.9,72.57 180.7,72.57 187.14,79.02 188.52,79.02 188.72,78.81 189.15,78.81 v2(189.23,78.89)
  BOTTOM w0.076: v2(175.81,73.11) 175.59,73.11 175.5,73.2 175.5,73.48 UH1.E20
PEG_GTX_C_HRX_P11: length 28.5
  TOP w0.152: v2(189.82,79.47) 189.82,79.65 189.41,80.06 189.41,81.11 191.51,83.21 196.83,83.21 CV558.2
  IN1 w0.089: 179.9,73.03 179.89,73.03 179.85,72.99 179.69,72.99 179.68,73 178.55,73 178.27,73.28 176.25,73.28 175.99,73.54 175.99,73.72 v2(175.81,73.9)
  IN1 w0.107: 179.9,73.03 179.9,73.03 180.49,73.03 187.38,79.92 189.59,79.92 189.82,79.69 v2(189.82,79.47)
  BOTTOM w0.076: v2(175.81,73.9) 175.48,74.22 UH1.E21
PEG_GTX_C_HRX_P12: length 28.6
  TOP w0.152: CV560.2 198.5,81.58 198.19,81.58 197.92,81.85 192.31,81.85 191.85,81.39 191.85,81.01 v2(191.66,80.82)
  IN1 w0.089: 179.9,74.17 179.89,74.17 179.88,74.16 179.82,74.16 179.81,74.15 177.63,74.15 177.33,74.45 176.24,74.45 176.18,74.51 176.18,74.67 176.07,74.77 175.89,74.77 v2(175.81,74.69)
  IN1 w0.107: 179.9,74.17 180.47,74.17 187.08,80.78 190.78,80.78 191.29,80.27 191.72,80.27 191.89,80.43 191.89,80.59 v2(191.66,80.82)
  BOTTOM w0.076: UH1.E22 175.72,75.08 175.86,74.94 175.86,74.74 v2(175.81,74.69)
PEG_GTX_C_HRX_P13: length 28.4
  TOP w0.152: CV562.2 196.67,86.02 192.29,86.02 192.02,86.29 190.34,86.29 190.07,86.03 190.07,85.77 v2(190.2,85.64)
  IN1 w0.089: 178.92,74.49 178.89,74.49 178.88,74.5 178.35,74.5 178,74.86 176.24,74.86 176,75.1 176,75.28 v2(175.81,75.47)
  IN1 w0.107: v2(190.2,85.64) 190.02,85.46 190.02,84.35 180.16,74.49 178.92,74.49
  BOTTOM w0.076: UH1.E23 175.48,75.8 v2(175.81,75.47)
PEG_GTX_C_HRX_P14: length 29.7
  TOP w0.152: v2(193.71,88.31) 193.85,88.17 193.85,87.78 194.19,87.45 195.66,87.45 v4(195.9,87.69) 196.15,87.94 196.76,87.94 196.95,87.75 CV564.2
  IN1 w0.107: v2(175.81,76.26) 175.98,76.08 180.56,76.08 188.55,84.07 188.55,85.58 190.16,87.19 193.54,87.19 193.92,87.58 193.92,88.1 v2(193.71,88.31)
  BOTTOM w0.076: v2(175.81,76.26) 175.9,76.35 175.9,76.5 175.74,76.65 UH1.E24
PEG_GTX_C_HRX_P15: length 29.9
  TOP w0.152: CV566.2 196.85,89.43 195.43,89.43 194.93,88.93 194.2,88.93 193.82,89.32 193.82,89.65 v2(193.68,89.79)
  IN1 w0.107: v2(175.77,77.05) 175.98,77.27 175.98,77.46 176.26,77.73 177.42,77.73 177.69,77.47 181.04,77.47 187.66,84.08 187.66,86.03 190.71,89.09 193.7,89.09 193.87,89.25 193.87,89.59 v2(193.68,89.79)
  BOTTOM w0.076: UH1.E25 175.77,77.16 v2(175.77,77.05)
PEG_GTX_HRX_N0: length 9.4
  TOP w0.089: v2(203.87,74.29) 203.68,74.1 203.68,73.91 203.68,73.69 203.6,73.6 203.6,73.55 203.6,73.1 203.56,73.07 203.56,73.02 203.51,72.97 203.51,72.92 203.5,72.91
  TOP w0.152: 203.5,72.91 203.24,72.65 202.04,72.65 201.42,72.03 201.42,71.47 200.85,70.9 198.48,70.9 198.34,71.04 197.82,71.04 CV532.1
  BOTTOM w0.089: UV1.AJ14 203.51,74.65 v2(203.87,74.29)
PEG_GTX_HRX_N1: length 9.2
  TOP w0.152: v2(205.5,74.25) 205.49,74.25 205.41,74.17 205.41,73.75 203.74,72.08 202.73,72.08 202.36,71.72 202.36,71.04 201.21,69.89 199.72,69.89 CV534.1
  BOTTOM w0.089: v2(205.5,74.25) UV1.AG14
PEG_GTX_HRX_N2: length 6.1
  TOP w0.152: CV536.1 199.73,72.5 200.12,72.5 200.51,72.89 200.51,73.51 202.44,75.45 202.92,75.45 203.03,75.56 v2(203.03,75.74)
  BOTTOM w0.089: v2(203.03,75.74) 203.32,75.45 UV1.AJ15
PEG_GTX_HRX_N3: length 7.1
  TOP w0.152: v2(202.18,76.69) 202.18,76.56 202.08,76.46 201.76,76.46 200.69,75.39 200.69,74.62 199.72,73.66 197.81,73.66 CV538.1
  BOTTOM w0.089: UV1.AK16 202.57,76.3 v2(202.18,76.69)
PEG_GTX_HRX_N4: length 6.8
  TOP w0.089: v2(203.85,76.75) 203.68,76.92 203.68,77.04 203.32,77.4 201.98,77.4 200.01,75.43 200.01,74.93 199.85,74.76 199.75,74.76 CV540.1
  BOTTOM w0.089: v2(203.85,76.75) UV1.AJ17
PEG_GTX_HRX_N5: length 10.8
  TOP w0.089: v2(205.5,76.75) 205.36,76.89 205.36,77.76 204.95,78.16 204.18,78.16 203.94,77.92 201.73,77.92 199.73,75.92 198.73,75.92 198.69,75.95 198.61,75.95 198.58,75.98 198.57,75.98
  TOP w0.152: 198.57,75.98 198.32,75.98 198.11,76.2 197.81,76.2 CV542.1
  BOTTOM w0.089: v2(205.5,76.75) UV1.AG17
PEG_GTX_HRX_N6: length 5.1
  TOP w0.089: v2(203.06,78.31) 202.77,78.31 202.32,78.76 201.87,78.76 200.31,77.2 199.6,77.2 CV544.1
  BOTTOM w0.089: v2(203.06,78.31) 203.42,77.95 UV1.AJ18
PEG_GTX_HRX_N7: length 6
  TOP w0.152: CV546.1 197.76,78.09 198.19,78.09 198.44,77.83 200.65,77.83 201.98,79.16 v2(202.21,79.16)
  BOTTOM w0.089: UV1.AK19 202.57,78.8 v2(202.21,79.16)
PEG_GTX_HRX_N8: length 5.9
  TOP w0.089: v2(203.93,79.25) 203.73,79.25 203.17,79.8 200.61,79.8 200.04,79.23 199.58,79.23 199.44,79.37 CV548.1
  BOTTOM w0.089: UV1.AJ20 203.53,79.65 v2(203.93,79.25)
PEG_GTX_HRX_N9: length 9.5
  TOP w0.089: 198.57,80.44 198.6,80.41 199.78,80.41 200,80.2 204.86,80.2 205.38,79.68 205.38,79.37 v2(205.5,79.25)
  TOP w0.152: CV551.1 197.88,80.69 198.19,80.69 198.45,80.44 198.57,80.44
  BOTTOM w0.089: v2(205.5,79.25) UV1.AG20
PEG_GTX_HRX_N10: length 8.6
  TOP w0.089: 198.89,84.55 198.91,84.54 198.91,84.49 198.96,84.44 198.96,84.4 198.98,84.37 198.98,84.02 v4(200.1,82.91) 200.61,82.4 202.37,82.4 202.77,82 202.77,81.23 v2(203.03,80.97)
  TOP w0.152: 198.89,84.55 198.47,84.98 CV557.1
  BOTTOM w0.089: UV1.AJ21 203.45,80.55 v2(203.03,80.97)
PEG_GTX_HRX_N11: length 6
  TOP w0.152: v2(202.16,81.74) 201.75,81.34 v4(200.72,81.34) 200.45,81.34 200.15,81.64 199.23,82.56 197.66,82.56 CV559.1
  BOTTOM w0.089: v2(202.16,81.74) 202.6,81.3 UV1.AK22
PEG_GTX_HRX_N12: length 6.5
  TOP w0.089: CV561.1 199.57,81.17 199.73,81.17 200.32,80.59 200.78,80.59 200.99,80.37 203.28,80.37 203.73,80.83 v2(203.73,81.63)
  BOTTOM w0.089: v2(203.73,81.63) 203.73,81.98 203.56,82.15 UV1.AJ23
PEG_GTX_HRX_N13: length 11.2
  TOP w0.089: 198.57,86.19 199.71,85.06 199.71,84.15 200.97,82.89 203.15,82.89 203.42,82.62 204.86,82.62 205.38,82.1 205.38,81.86 v2(205.5,81.75)
  TOP w0.152: CV563.1 197.81,86.36 198.29,86.36 198.32,86.33 198.4,86.33 198.43,86.29 198.47,86.29 198.57,86.19
  BOTTOM w0.089: v2(205.5,81.75) UV1.AG23
PEG_GTX_HRX_N14: length 9.3
  TOP w0.089: v2(203.02,83.38) 202.61,83.79 201.97,83.79 201.83,83.93 201.03,83.93 200.52,84.44 200.52,85.33 199.17,86.68 198.86,86.99
  TOP w0.152: 198.86,86.99 198.86,88.01 198.47,88.41 CV565.1
  BOTTOM w0.089: v2(203.02,83.38) UV1.AJ24
PEG_GTX_HRX_N15: length 9.3
  TOP w0.089: 198.57,89.91 198.73,89.91 199.05,89.59 199.43,89.21 199.43,87.38 199.9,86.9 200.64,86.17 v4(200.72,86.09) 201.12,85.68 201.69,85.68 202.18,85.19 v2(202.18,84.27)
  TOP w0.152: CV567.1 197.84,89.91 198.57,89.91
  BOTTOM w0.089: UV1.AK25 202.6,83.85 v2(202.18,84.27)
PEG_GTX_HRX_P0: length 9.4
  TOP w0.089: 203.27,73.15 203.33,73.22 203.33,73.66 203.33,73.66 203.33,73.71 203.42,73.8 203.42,73.91 203.42,74.1 203.29,74.22 v2(203.02,74.22)
  TOP w0.152: CV531.1 197.81,71.37 198.47,71.37 198.61,71.23 v4(200.22,71.23) 200.71,71.23 201.09,71.61 201.09,72.17 201.91,72.98 203.1,72.98 203.27,73.15
  BOTTOM w0.089: UV1.AK14 202.6,74.65 202.6,74.27 202.74,74.13 202.93,74.13 v2(203.02,74.22)
PEG_GTX_HRX_P1: length 9.2
  TOP w0.152: CV533.1 199.72,70.22 201.08,70.22 v4(201.61,70.76) 202.03,71.18 202.03,71.85 202.59,72.41 203.61,72.41 205.08,73.89 205.08,74.33 204.99,74.42 204.85,74.42 v2(204.69,74.25)
  BOTTOM w0.089: UV1.AH14 204.3,74.64 v2(204.69,74.25)
PEG_GTX_HRX_P2: length 6.1
  TOP w0.152: CV535.1 199.71,72.17 200.25,72.17 200.84,72.75 v4(200.84,73) 200.84,73.38 202.58,75.12 202.86,75.12 v2(203.03,74.94)
  BOTTOM w0.089: UV1.AK15 202.6,75.37 v2(203.03,74.94)
PEG_GTX_HRX_P3: length 7.1
  TOP w0.152: CV537.1 197.82,73.33 199.86,73.33 201.02,74.48 v4(201.02,74.9) 201.02,75.26 201.89,76.13 202.07,76.13 202.18,76.02 v2(202.18,75.9)
  BOTTOM w0.089: UV1.AL16 201.8,76.27 202.17,75.9 v2(202.18,75.9)
PEG_GTX_HRX_P4: length 6.8
  TOP w0.089: CV539.1 199.75,74.49 199.96,74.49 200.28,74.82 200.28,75.32 202.09,77.14 203.21,77.14 203.42,76.93 203.42,76.74 203.3,76.63 203.12,76.63 v2(203,76.75)
  BOTTOM w0.089: v2(203,76.75) UV1.AK17
PEG_GTX_HRX_P5: length 10.8
  TOP w0.089: v2(204.7,76.75) 204.82,76.63 205,76.63 205.09,76.72 205.09,77.65 204.84,77.9 204.29,77.9 204.05,77.66 201.84,77.66 v4(200.64,76.45) 199.84,75.65 198.57,75.65
  TOP w0.152: CV541.1 197.82,75.87 197.97,75.87 198.19,75.65 198.57,75.65
  BOTTOM w0.089: v2(204.7,76.75) UV1.AH17
PEG_GTX_HRX_P6: length 5.1
  TOP w0.089: v2(202.21,78.31) 202.21,78.46 202.13,78.53 201.98,78.53 201.26,77.81 v4(201.23,77.78) 201.22,77.77 200.38,76.93 199.33,76.93 199.23,76.83 199.23,76.69 CV543.1
  BOTTOM w0.089: v2(202.21,78.31) 202.28,78.38 202.44,78.38 202.6,78.22 UV1.AK18
PEG_GTX_HRX_P7: length 6
  TOP w0.152: CV545.1 197.87,78.42 198.32,78.42 198.58,78.16 200.61,78.16 200.7,78.25 200.7,78.37 200.66,78.41 200.66,78.52 200.79,78.65 201.1,78.65 201.18,78.73 201.18,78.8 201.03,78.95 201.03,79.16 201.17,79.29 201.26,79.29 v2(201.4,79.16)
  BOTTOM w0.089: UV1.AL19 201.8,78.97 201.61,79.16 v2(201.4,79.16)
PEG_GTX_HRX_P8: length 5.9
  TOP w0.089: v2(203.08,79.25) 203.13,79.31 203.29,79.31 203.39,79.21 203.39,79.04 203.24,78.89 202.87,78.89 202.59,79.17 202.59,79.41 202.46,79.54 200.72,79.54 200.15,78.96 199.65,78.96 CV547.1
  BOTTOM w0.089: v2(203.08,79.25) 202.68,79.65 UV1.AK20
PEG_GTX_HRX_P9: length 9.4
  TOP w0.089: 198.57,80.11 199.68,80.11 199.81,79.98 v4(200.27,79.98) 204.73,79.98 205.09,79.62 205.09,79.18 205,79.09 204.86,79.09 v2(204.7,79.25)
  TOP w0.152: CV550.1 197.75,80.36 198.05,80.36 198.31,80.11 198.57,80.11
  BOTTOM w0.089: v2(204.7,79.25) UV1.AH20
PEG_GTX_HRX_P10: length 8.6
  TOP w0.089: 198.57,84.41 198.72,84.26 198.72,83.91 199.91,82.72 200.41,82.22 202.27,82.22 202.59,81.9 202.59,81.15 202.41,80.97 v2(202.18,80.97)
  TOP w0.152: 198.57,84.41 198.33,84.65 198.1,84.65 CV552.1
  BOTTOM w0.089: v2(202.18,80.97) 202.6,80.55 UV1.AK21
PEG_GTX_HRX_P11: length 5.9
  TOP w0.152: v2(201.36,81.74) 201.36,81.93 201.31,81.97 201.05,81.97 200.95,81.87 200.95,81.67 200.89,81.61 200.6,81.61 199.31,82.89 v4(198.38,82.89) 197.61,82.89 197.42,83.08 197.42,83.21 CV558.1
  BOTTOM w0.089: v2(201.36,81.74) 201.8,81.3 UV1.AL22
PEG_GTX_HRX_P12: length 6.6
  TOP w0.089: v2(203.14,81.61) 203.52,81.23 203.52,80.92 203.17,80.58 201.17,80.58 200.89,80.86 200.43,80.86 199.84,81.44 199.49,81.44 199.31,81.62 CV560.1
  BOTTOM w0.089: v2(203.14,81.61) UV1.AK23
PEG_GTX_HRX_P13: length 11.2
  TOP w0.089: v2(204.7,81.75) 204.83,81.62 204.98,81.62 205.09,81.73 205.09,82.02 204.75,82.36 203.31,82.36 203.04,82.62 200.86,82.62 199.44,84.04 v4(199.44,84.65) 199.44,84.95 198.57,85.82
  TOP w0.152: 198.57,85.82 198.49,85.9 198.45,85.9 198.39,85.95 198.34,85.95 198.27,86.03 197.82,86.03 CV562.1
  BOTTOM w0.089: v2(204.7,81.75) UV1.AH23
PEG_GTX_HRX_P14: length 9.3
  TOP w0.089: v2(202.23,83.38) 202.31,83.3 202.31,83.17 202.21,83.07 201.91,83.07 201.8,83.17 201.8,83.57 201.71,83.66 200.92,83.66 200.25,84.33 200.25,85.22 v4(198.98,86.49) 198.78,86.69 198.74,86.69 198.57,86.86
  TOP w0.152: CV564.1 198.1,88.08 198.33,88.08 198.53,87.87 198.53,86.97 198.57,86.94 198.57,86.86 198.57,86.86
  BOTTOM w0.089: UV1.AK24 202.6,83.01 v2(202.23,83.38)
PEG_GTX_HRX_P15: length 9.3
  TOP w0.089: 198.57,89.58 198.68,89.58 199.16,89.1 199.16,87.27 200.32,86.1 200.45,85.98 200.53,85.9 201.01,85.42 201.58,85.42 201.88,85.12 201.88,84.48 201.65,84.25 201.47,84.25 v2(201.4,84.31)
  TOP w0.152: 198.57,89.58 197.84,89.58 CV566.1
  BOTTOM w0.089: v2(201.4,84.31) 201.8,83.91 UV1.AL25
PEG_HTX_C_GRX_N0: length 13.8
  BOTTOM w0.102: 198.51,72.11 198.6,72.21 198.6,72.42 198.8,72.63 198.8,73.16 199.21,73.56 199.77,73.56 200.05,73.29 200.38,73.29 200.72,72.95 UV1.AM12
  BOTTOM w0.152: CH36.2 192.1,65.92 193.46,65.92 194.64,67.1 194.64,68 v4(195.96,69.32) 197.31,70.67 197.31,70.91 198.34,71.94 198.51,72.11
PEG_HTX_C_GRX_N1: length 12.2
  BOTTOM w0.114: 198.58,73.32 199.17,73.91 199.8,73.91 200.11,74.21 200.33,74.21 200.77,74.65 UV1.AM14
  BOTTOM w0.152: CH34.2 192.82,67.05 193.43,67.05 v4(193.75,67.37) 194.03,67.65 194.03,68.28 194.11,68.36 194.34,68.6 194.66,68.91 194.78,69.03 198.01,72.26 198.01,72.74 198.58,73.32
PEG_HTX_C_GRX_N2: length 10.5
  BOTTOM w0.152: CH32.2 192.1,69.1 v4(192.69,69.1) 192.98,69.1 196.72,72.84 196.72,73.08 198.85,75.21 199.16,75.21 UV1.AP15
PEG_HTX_C_GRX_N3: length 11.3
  BOTTOM w0.089: 198.75,75.77 198.77,75.78 198.77,75.83 198.83,75.89 199.47,75.89 199.82,75.54 199.82,75.33 200.05,75.1 200.65,75.1 UV1.AM15
  BOTTOM w0.152: CH30.2 192.93,70.61 193.59,70.61 194.67,71.68 v4(197.52,74.54) 198.57,75.58 198.75,75.77
PEG_HTX_C_GRX_N4: length 12.5
  BOTTOM w0.114: 198.51,76.83 198.52,76.83 198.54,76.82 198.64,76.82 198.65,76.8 199.57,76.8 199.8,77.03 199.8,77.23 200.09,77.51 200.64,77.51 UV1.AM17
  BOTTOM w0.152: CH28.2 191.52,72.04 v4(192.39,72.04) 193.41,72.04 198.2,76.83 198.51,76.83
PEG_HTX_C_GRX_N5: length 8.7
  BOTTOM w0.152: UV1.AP18 199.13,77.68 197.92,77.68 v4(194.06,73.82) 193.73,73.49 192.91,73.49 CH26.2
PEG_HTX_C_GRX_N6: length 11.7
  BOTTOM w0.089: UV1.AM18 200.73,77.95 200.28,78.4 200.05,78.4 199.88,78.57 199.13,78.57 198.99,78.44 198.56,78.44 198.53,78.47 198.51,78.47
  BOTTOM w0.152: 198.51,78.47 197.43,78.47 193.81,74.85 v4(192.58,74.85) 191.49,74.85 CH24.2
PEG_HTX_C_GRX_N7: length 10.5
  BOTTOM w0.114: 198.73,78.94 198.82,79.03 199.37,79.03 199.44,78.96 199.44,78.84 199.5,78.78 199.75,78.78 199.85,78.87 199.85,79 199.78,79.07 199.78,79.19 199.86,79.27 199.98,79.27 200.08,79.18 200.53,79.18 UV1.AM20
  BOTTOM w0.152: 198.73,78.94 v4(197.38,78.94) 197.1,78.94 194.44,76.27 192.9,76.27 CH22.2
PEG_HTX_C_GRX_N8: length 6.8
  BOTTOM w0.152: UV1.AP21 199.03,80.08 196.46,80.08 v4(195.8,79.43) 194.91,78.53 193.65,78.53 CH20.2
PEG_HTX_C_GRX_N9: length 7.2
  BOTTOM w0.114: UV1.AM21 200.57,80.88 200.05,80.88 199.77,81.16 199.47,81.16 199.43,81.2
  BOTTOM w0.152: 199.43,81.2 199.09,81.2 198.76,80.87 195.86,80.87 195.24,80.25 CH18.2
PEG_HTX_C_GRX_N10: length 7.9
  BOTTOM w0.114: UV1.AM23 200.57,81.72 200.04,81.72 199.8,81.48 198.73,81.48 198.64,81.38 198.54,81.38 198.52,81.37
  BOTTOM w0.152: 198.52,81.37 v4(195.95,81.37) 194.96,81.37 194.84,81.25 193.65,81.25 CH16.2
PEG_HTX_C_GRX_N11: length 4
  BOTTOM w0.152: UV1.AP24 199.14,82.69 196.65,82.69 196.45,82.88 195.97,82.88 CH14.2
PEG_HTX_C_GRX_N12: length 8.5
  BOTTOM w0.114: 198.59,83.24 198.67,83.32 199.67,83.32 199.82,83.17 199.82,82.8 200.03,82.6 200.65,82.6 UV1.AM24
  BOTTOM w0.152: CH12.2 193.75,83.77 196.47,83.77 196.99,83.24 198.59,83.24
PEG_HTX_C_GRX_N13: length 6.3
  BOTTOM w0.114: UV1.AM26 200.66,84.99 200.06,84.99 199.82,84.74 199.82,84.51 199.6,84.29 198.76,84.29 198.75,84.29 198.74,84.29 198.73,84.29
  BOTTOM w0.152: 198.73,84.29 198.57,84.45 197.83,84.45 197.57,84.71 197.04,85.24 195.96,85.24 CH10.2
PEG_HTX_C_GRX_N14: length 6.7
  BOTTOM w0.152: UV1.AP27 199.16,85.21 199.01,85.21 197.85,86.37 196.37,86.37 196.2,86.53 v4(194.34,86.53) 193.78,86.53 CH8.2
PEG_HTX_C_GRX_N15: length 6.3
  BOTTOM w0.114: UV1.AM27 200.71,85.45 200.2,85.96 200.03,85.96 198.98,87.01 198.98,87.03 198.92,87.09 198.92,87.12 198.9,87.14
  BOTTOM w0.152: CH6.2 v4(196.61,87.96) 196.88,87.96 197.46,87.37 198.67,87.37 198.9,87.14
PEG_HTX_C_GRX_P0: length 13.8
  BOTTOM w0.102: UV1.AN12 200.2,72.73 200.08,72.6 199.92,72.6 199.78,72.74 199.78,73.27 199.69,73.36 199.3,73.36 199.03,73.09 199.03,72.59 198.83,72.39 198.83,71.97 198.74,71.88
  BOTTOM w0.152: 198.74,71.88 197.64,70.78 197.64,70.53 194.97,67.86 194.97,66.97 193.6,65.59 v4(192.84,65.59) 192.1,65.59 CH35.2
PEG_HTX_C_GRX_P1: length 12.2
  BOTTOM w0.114: UV1.AN14 200.2,74.79 200.09,74.9 199.85,74.9 199.75,74.8 199.75,74.63 199.87,74.51 199.87,74.39 199.68,74.2 199.05,74.2 198.48,73.63 198.45,73.63 198.39,73.56 198.36,73.56 198.35,73.55
  BOTTOM w0.152: 198.35,73.55 197.77,72.98 197.68,72.88 197.68,72.4 v4(197.2,71.92) 194.55,69.27 194.43,69.15 194.21,68.93 194.11,68.83 194.11,68.83 193.95,68.67 193.7,68.42 193.7,67.79 193.3,67.38 192.77,67.38 192.65,67.51 CH33.2
PEG_HTX_C_GRX_P2: length 10.5
  BOTTOM w0.152: CH31.2 192.1,68.77 193.11,68.77 v4(194.42,70.08) 197.05,72.71 197.05,72.95 198.99,74.88 199.16,74.88 UV1.AP14
PEG_HTX_C_GRX_P3: length 11.3
  BOTTOM w0.089: UV1.AN15 200.37,75.28 200.51,75.28 200.61,75.39 200.61,75.71 200.47,75.85 199.82,75.85 199.51,76.16 198.72,76.16 198.63,76.06 198.63,76.06 198.57,76.01 198.53,76.01 198.52,76
  BOTTOM w0.152: 198.52,76 197.29,74.77 v4(194.43,71.91) 193.46,70.94 192.93,70.94 CH29.2
PEG_HTX_C_GRX_P4: length 12.5
  BOTTOM w0.114: 198.51,76.5 199.69,76.5 199.89,76.7 200.53,76.7 200.67,76.84 200.67,77.06 200.52,77.22 200.27,77.22 UV1.AN17
  BOTTOM w0.152: 198.51,76.5 198.34,76.5 195.8,73.96 ; CH27.2 191.47,71.71 193.55,71.71 195.8,73.96 ; 195.8,73.96 v4(195.8,73.97)
PEG_HTX_C_GRX_P5: length 8.7
  BOTTOM w0.152: UV1.AP17 199.2,77.35 198.06,77.35 v4(197.43,76.72) 193.86,73.16 192.94,73.16 CH25.2
PEG_HTX_C_GRX_P6: length 11.7
  BOTTOM w0.089: UV1.AN18 200.2,77.78 200.12,77.7 199.8,77.7 199.73,77.77 199.73,77.99 199.91,78.16 199.91,78.28 199.82,78.37 199.2,78.37 199,78.17 198.55,78.17 198.52,78.14 198.51,78.14
  BOTTOM w0.152: CH23.2 191.49,74.52 193.94,74.52 v4(195.57,76.15) 197.56,78.14 198.51,78.14
PEG_HTX_C_GRX_P7: length 10.5
  BOTTOM w0.114: 198.51,79.27 198.53,79.25 199.51,79.25 199.77,79.51 199.77,79.53 199.77,79.88 199.9,80 200.47,80 200.61,79.87 200.61,79.67 200.47,79.54 200.31,79.54 UV1.AN20
  BOTTOM w0.152: CH21.2 192.95,76.6 v4(193.66,76.6) 194.3,76.6 196.97,79.27 198.51,79.27
PEG_HTX_C_GRX_P8: length 6.8
  BOTTOM w0.152: CH19.2 193.9,78.2 v4(194.41,78.2) 195.04,78.2 196.59,79.75 199.3,79.75 UV1.AP20
PEG_HTX_C_GRX_P9: length 7.2
  BOTTOM w0.114: UV1.AN21 200.2,80.29 200.12,80.21 199.85,80.21 199.77,80.29 199.77,80.55 199.87,80.65 199.87,80.75 199.75,80.87 199.43,80.87
  BOTTOM w0.152: 199.43,80.87 199.22,80.87 198.89,80.54 v4(197.31,80.54) 196,80.54 195.38,79.92 195.07,79.92 CH17.2
PEG_HTX_C_GRX_P10: length 7.9
  BOTTOM w0.114: UV1.AN23 200.2,82.31 200.11,82.39 199.82,82.39 199.75,82.32 199.75,82.15 199.85,82.05 199.85,81.94 199.68,81.77 198.61,81.77 198.53,81.7 198.51,81.7
  BOTTOM w0.152: 198.51,81.7 194.82,81.7 194.7,81.58 v4(194.3,81.58) 193.61,81.58 193.5,81.7 CH15.2
PEG_HTX_C_GRX_P11: length 4
  BOTTOM w0.152: CH13.2 196.03,82.55 196.32,82.55 196.51,82.36 v4(197.23,82.36) 199.19,82.36 UV1.AP23
PEG_HTX_C_GRX_P12: length 8.5
  BOTTOM w0.114: UV1.AN24 200.31,82.84 200.52,82.84 200.65,82.97 200.65,83.28 200.52,83.41 199.92,83.41 199.77,83.55 198.62,83.55 198.59,83.57
  BOTTOM w0.152: CH11.2 193.8,84.1 v4(194.3,84.1) 196.61,84.1 197.13,83.57 198.59,83.57
PEG_HTX_C_GRX_P13: length 6.4
  BOTTOM w0.114: UV1.AN26 200.56,84.65 200.69,84.52 200.69,84.31 200.56,84.18 199.91,84.18 199.72,84 198.88,84 198.86,83.98 198.6,83.98 198.53,84.05 198.51,84.05 198.49,84.06
  BOTTOM w0.152: 198.49,84.06 198.44,84.12 197.69,84.12 v4(197.33,84.48) 196.9,84.91 196.04,84.91 CH9.2
PEG_HTX_C_GRX_P14: length 6.7
  BOTTOM w0.152: CH7.2 193.78,86.2 196.07,86.2 196.23,86.04 v4(196.95,86.04) 197.72,86.04 198.87,84.88 199.17,84.88 UV1.AP26
PEG_HTX_C_GRX_P15: length 6.3
  BOTTOM w0.114: 198.67,86.91 198.69,86.89 199.86,85.72 199.86,85.62 199.75,85.51 199.75,85.31 199.87,85.19 200.12,85.19 200.2,85.27 UV1.AN27
  BOTTOM w0.152: 198.67,86.91 198.54,87.04 v4(197.8,87.04) 197.32,87.04 196.94,87.42 196.74,87.63 196.28,87.63 CH5.2
PEG_HTX_GRX_N0: length 15.8
  BOTTOM w0.076: 181.1,64.87 181.09,64.88 181.04,64.88 180.82,65.1 178.88,65.1 178.8,65.17 178.59,65.17 178.58,65.16 178.42,65.32 177.19,65.32 177.06,65.44 177.06,65.59 177.14,65.67 177.39,65.67 UH1.B10
  BOTTOM w0.152: 181.1,64.87 181.31,64.66 181.31,64.66 181.47,64.5 v4(187.76,64.5) 188.98,64.5 189.04,64.56 190.38,65.9 190.93,65.9 CH36.1
PEG_HTX_GRX_N1: length 16.4
  BOTTOM w0.076: 180.63,65.59 179.17,65.59 178.79,65.97 178.4,65.97 178.35,65.92 177.75,65.92 177.57,66.1 177.57,66.27 UH1.B11
  BOTTOM w0.152: CH34.1 191.78,67.15 190.49,67.15 188.33,64.99 v4(182.77,64.99) 182.07,64.99 181.69,65.38 181.62,65.45 181.47,65.59 180.63,65.59
PEG_HTX_GRX_N2: length 16.4
  BOTTOM w0.076: UH1.B12 177.39,67.24 177.14,67.24 177.07,67.17 177.07,67.01 177.17,66.91 178.3,66.91 178.43,66.78 179.46,66.78
  BOTTOM w0.152: 179.46,66.78 179.5,66.75 182.11,66.75 182.68,66.18 187.47,66.18 v4(189.44,68.14) 190.39,69.1 190.96,69.1 CH32.1
PEG_HTX_GRX_N3: length 17
  BOTTOM w0.076: UH1.B13 177.5,67.99 177.58,67.91 177.58,67.71 177.78,67.52 178.44,67.52 178.5,67.57 178.94,67.57 179.22,67.29 179.9,67.29 179.93,67.26 179.95,67.26
  BOTTOM w0.152: 179.95,67.26 182.31,67.26 182.83,66.73 v4(183.97,66.73) 186.69,66.73 190.56,70.61 191.78,70.61 CH30.1
PEG_HTX_GRX_N4: length 16.5
  BOTTOM w0.076: UH1.B14 177.39,68.82 177.15,68.82 177.08,68.74 177.08,68.6 177.19,68.49 178.31,68.49 178.41,68.39 179.9,68.39
  BOTTOM w0.152: CH28.1 190.32,72.04 189.54,72.04 188.74,71.24 188.74,70.86 v4(187.37,69.5) 185.74,67.86 184.03,67.86 183.5,68.39 179.9,68.39
PEG_HTX_GRX_N5: length 19.6
  IN3 w0.099: v2(185.21,68.38) 185.49,68.38 185.66,68.21 186.49,68.21 190.2,71.92 190.2,73.11 189.9,73.4 v2(189.9,73.68)
  BOTTOM w0.076: 179.89,68.87 179.87,68.87 179.83,68.91 179.31,68.91 179.07,69.15 178.51,69.15 178.45,69.08 178.44,69.09 178.42,69.09 178.41,69.08 177.81,69.08 177.56,69.33 177.56,69.48 177.47,69.57 UH1.B15
  BOTTOM w0.152: v2(185.21,68.38) 185.21,68.51 184.85,68.87 179.89,68.87 ; CH26.1 191.78,73.48 191,73.48 190.84,73.33 190.08,73.33 189.9,73.5 v2(189.9,73.68)
PEG_HTX_GRX_N6: length 16.4
  BOTTOM w0.076: 179.94,70.04 179.92,70.06 179.87,70.06 179.82,70.1 179.58,70.1 179.54,70.06 178.94,70.06 178.8,69.92 178.49,69.92 178.35,70.06 177.21,70.06 177.1,70.17 177.1,70.33 177.17,70.39 177.39,70.39 UH1.B16
  BOTTOM w0.152: CH24.1 190.31,74.81 189.84,74.81 v4(187.19,72.16) 186.05,71.01 185.5,71.01 184.51,70.02 179.95,70.02 179.94,70.04
PEG_HTX_GRX_N7: length 17.6
  BOTTOM w0.076: 179.91,70.48 179.9,70.48 179.87,70.51 179.78,70.51 179.74,70.54 179.11,70.54 178.89,70.77 178.55,70.77 178.44,70.66 177.86,70.66 177.59,70.94 177.59,71.03 177.47,71.14 UH1.B17
  BOTTOM w0.152: 179.91,70.48 184.21,70.48 190.03,76.3 v4(190.97,76.3) 191.78,76.3 CH22.1
PEG_HTX_GRX_N8: length 19.7
  BOTTOM w0.076: UH1.C18 177.06,72.21 177.55,72.21 177.76,71.99 177.76,71.75 177.88,71.63 178.47,71.63 178.56,71.55 178.92,71.55 179.01,71.64 179.76,71.64 179.79,71.67 179.81,71.67
  BOTTOM w0.152: CH20.1 192.66,78.43 190.53,78.43 v4(188.74,76.64) 183.72,71.62 180.9,71.62 180.85,71.67 179.81,71.67
PEG_HTX_GRX_N9: length 20.2
  BOTTOM w0.076: 179.85,72.42 179.77,72.35 179.4,72.35 179.2,72.55 178.47,72.55 178.32,72.4 177.96,72.4 177.76,72.6 177.76,72.7 177.85,72.79 178,72.79 UH1.A19
  BOTTOM w0.152: 179.85,72.42 183.39,72.42 v4(189.78,78.81) 190.92,79.96 193.64,79.96 CH18.1
PEG_HTX_GRX_N10: length 20.1
  BOTTOM w0.076: UH1.C20 176.94,73.35 176.94,73.25 177.16,73.03 178.2,73.03 178.29,72.94 178.95,72.94 179.04,73.04 179.22,73.04 179.3,72.97
  BOTTOM w0.152: 179.3,72.97 v4(180.95,72.97) 182.18,72.97 182.7,73.49 183.2,73.49 191.09,81.38 192.63,81.38 CH16.1
PEG_HTX_GRX_N11: length 21.9
  BOTTOM w0.076: 180.4,74.13 180.4,74.13 180.35,74.13 180.18,74.29 179.67,74.29 179.58,74.2 178.46,74.2 178.25,74 177.87,74 177.77,74.1 177.77,74.32 177.84,74.39 177.98,74.39 UH1.A21
  BOTTOM w0.152: CH14.1 194.86,82.85 190.85,82.85 v4(188.43,80.44) 182.72,74.72 182.22,74.72 181.62,74.13 180.4,74.13
PEG_HTX_GRX_N12: length 20.4
  BOTTOM w0.076: UH1.C22 176.94,74.92 176.94,74.82 177.17,74.59 178.41,74.59 178.56,74.45 179.2,74.45 179.41,74.65 181.06,74.65
  BOTTOM w0.152: CH12.1 192.65,83.78 191.13,83.78 v4(185.03,77.68) 182.68,75.33 182.01,75.33 181.33,74.65 181.06,74.65
PEG_HTX_GRX_N13: length 22.2
  BOTTOM w0.076: UH1.A23 178.03,75.92 177.86,75.92 177.78,75.83 177.78,75.68 177.9,75.55 178.32,75.55 178.53,75.77 179.39,75.77 179.56,75.6 179.74,75.6 179.78,75.64 179.86,75.64 179.89,75.68 179.9,75.68
  BOTTOM w0.152: 179.9,75.68 180.53,75.68 181.45,76.59 182.36,76.59 v4(185.82,80.05) 190.97,85.2 194.86,85.2 CH10.1
PEG_HTX_GRX_N14: length 22.1
  BOTTOM w0.076: 179.9,76.33 179.88,76.33 179.85,76.29 179.09,76.29 179.06,76.26 178.45,76.26 178.35,76.36 177.92,76.36 177.75,76.53 177.75,76.73 177.55,76.93 177.06,76.93 UH1.C24
  BOTTOM w0.152: CH8.1 192.66,86.56 191.71,86.56 191.57,86.42 189.26,86.42 188.52,85.68 188.52,83.88 v4(186.65,82.01) 182.08,77.44 181.13,77.44 180.02,76.33 179.9,76.33
PEG_HTX_GRX_N15: length 23.6
  BOTTOM w0.076: UH1.A25 177.99,77.53 177.88,77.53 177.79,77.44 177.79,77.27 177.93,77.13 178.32,77.13 178.49,77.3 179.73,77.3 179.76,77.33 179.76,77.34
  BOTTOM w0.152: CH6.1 194.86,87.68 191.58,87.68 191.14,87.23 188.73,87.23 187.5,86.01 v4(187.5,85.2) 187.5,83.98 181.76,78.24 180.66,78.24 179.76,77.34
PEG_HTX_GRX_P0: length 15.9
  BOTTOM w0.076: UH1.C10 176.89,65.52 176.89,65.36 177.12,65.13 178.24,65.13 178.47,64.91 178.68,64.91 178.69,64.92 178.77,64.84 180.72,64.84 180.86,64.7 180.86,64.65 180.87,64.64
  BOTTOM w0.152: CH35.1 190.98,65.57 190.51,65.57 189.12,64.17 v4(184.91,64.17) 181.33,64.17 181.18,64.33 180.87,64.64
PEG_HTX_GRX_P1: length 16.4
  BOTTOM w0.076: 180.63,65.92 180.62,65.92 180.59,65.88 180.51,65.88 180.47,65.85 179.27,65.85 178.92,66.2 178.27,66.2 178.17,66.1 177.84,66.1 177.75,66.19 177.75,66.34 177.86,66.46 178.04,66.46 UH1.A11
  BOTTOM w0.152: 180.63,65.92 181.61,65.92 181.79,65.75 181.92,65.61 182.21,65.32 188.19,65.32 188.24,65.37 v4(189.12,66.25) 190.35,67.48 191.78,67.48 CH33.1
PEG_HTX_GRX_P2: length 16.4
  BOTTOM w0.076: UH1.C12 176.89,67.1 176.89,66.94 177.1,66.73 178.22,66.73 178.43,66.53 179.2,66.53 179.23,66.5 179.28,66.5
  BOTTOM w0.152: 179.28,66.5 179.36,66.42 181.97,66.42 182.54,65.85 v4(186.09,65.85) 187.6,65.85 190.52,68.77 190.96,68.77 CH31.1
PEG_HTX_GRX_P3: length 17
  BOTTOM w0.076: UH1.A13 177.99,68.08 177.85,68.08 177.76,67.99 177.76,67.81 177.88,67.7 178.27,67.7 178.39,67.83 179.04,67.83 179.32,67.55 179.9,67.55 179.93,67.59 179.95,67.59
  BOTTOM w0.152: 179.95,67.59 182.45,67.59 182.97,67.06 186.55,67.06 v4(189.81,70.32) 190.42,70.94 191.78,70.94 CH29.1
PEG_HTX_GRX_P4: length 16.5
  BOTTOM w0.076: UH1.C14 176.88,68.68 176.88,68.53 177.12,68.3 178.21,68.3 178.37,68.13 179.74,68.13 179.78,68.09 179.86,68.09 179.89,68.06 179.9,68.06
  BOTTOM w0.152: CH27.1 190.37,71.71 189.67,71.71 189.07,71.11 189.07,70.73 185.87,67.53 183.89,67.53 183.37,68.06 v4(180.81,68.06) 179.9,68.06
PEG_HTX_GRX_P5: length 19.6
  IN3 w0.099: v2(185.62,68.79) 185.62,68.51 185.74,68.4 186.41,68.4 190.01,72 190.01,73.03 189.77,73.27 v2(189.49,73.27)
  BOTTOM w0.076: UH1.A15 178,69.64 177.81,69.64 177.74,69.57 177.74,69.43 177.91,69.26 178.27,69.26 178.41,69.4 179.17,69.4 179.41,69.16 179.83,69.16 179.87,69.2 179.89,69.2
  BOTTOM w0.152: CH25.1 191.78,73.15 191.13,73.15 190.98,73 189.94,73 189.67,73.27 v2(189.49,73.27) ; v2(185.62,68.79) 185.39,68.79 184.99,69.2 179.89,69.2
PEG_HTX_GRX_P6: length 16.4
  BOTTOM w0.076: 179.7,69.81 179.05,69.81 178.91,69.67 178.44,69.67 178.23,69.88 177.13,69.88 176.91,70.1 176.91,70.22 UH1.C16
  BOTTOM w0.152: CH23.1 190.39,74.48 189.98,74.48 186.18,70.68 185.63,70.68 184.64,69.69 182.11,69.69 v4(182.09,69.68) 182.08,69.69 179.82,69.69 179.7,69.81
