# Allegro board LA-C361P R10-0731.brd (continued)
## Nets (continued)
FBB_CMD11: UV1.A14 UV9.H5
FBB_CMD12: UV1.D14 UV9.G3
FBB_CMD13: RV418.1 UV1.A15 UV9.J2
FBB_CMD14: RV410.1 UV1.B15 UV9.J3
FBB_CMD15: UV1.C17 UV9.L3
FBB_CMD16: UV1.D18 UV10.G12
FBB_CMD17: UV1.E18 UV10.H10
FBB_CMD18: UV1.F18 UV10.H11
FBB_CMD19: UV1.A20 UV10.K11
FBB_CMD20: UV1.B20 UV10.K10
FBB_CMD21: UV1.C18 UV10.L12
FBB_CMD22: UV1.B18 UV10.K4
FBB_CMD23: UV1.G18 UV10.K5
FBB_CMD24: UV1.G17 UV10.J4
FBB_CMD25: UV1.F17 UV10.J5
FBB_CMD26: UV1.D16 UV10.H4
FBB_CMD27: UV1.A18 UV10.H5
FBB_CMD28: UV1.D17 UV10.G3
FBB_CMD29: RV414.1 UV1.A17 UV10.J2
FBB_CMD30: RV409.1 UV1.B17 UV10.J3
FBB_CMD31: UV1.E17 UV10.L3
FBB_D0: UV1.G9 UV9.A4
FBB_D1: UV1.E9 UV9.A2
FBB_D2: UV1.G8 UV9.B4
FBB_D3: UV1.F9 UV9.B2
FBB_D4: UV1.F11 UV9.E4
FBB_D5: UV1.G11 UV9.E2
FBB_D6: UV1.F12 UV9.F4
FBB_D7: UV1.G12 UV9.F2
FBB_D8: UV1.G6 UV9.A11
FBB_D9: UV1.F5 UV9.A13
FBB_D10: UV1.E6 UV9.B11
FBB_D11: UV1.F6 UV9.B13
FBB_D12: UV1.F4 UV9.E11
FBB_D13: UV1.G4 UV9.E13
FBB_D14: UV1.E2 UV9.F11
FBB_D15: UV1.F3 UV9.F13
FBB_D16: UV1.C2 UV9.U11
FBB_D17: UV1.D4 UV9.U13
FBB_D18: UV1.D3 UV9.T11
FBB_D19: UV1.C1 UV9.T13
FBB_D20: UV1.B3 UV9.N11
FBB_D21: UV1.C4 UV9.N13
FBB_D22: UV1.B5 UV9.M11
FBB_D23: UV1.C5 UV9.M13
FBB_D24: UV1.A11 UV9.U4
FBB_D25: UV1.C11 UV9.U2
FBB_D26: UV1.D11 UV9.T4
FBB_D27: UV1.B11 UV9.T2
FBB_D28: UV1.D8 UV9.N4
FBB_D29: UV1.A8 UV9.N2
FBB_D30: UV1.C8 UV9.M4
FBB_D31: UV1.B8 UV9.M2
FBB_D32: UV1.F24 UV10.A4
FBB_D33: UV1.G23 UV10.A2
FBB_D34: UV1.E24 UV10.B4
FBB_D35: UV1.G24 UV10.B2
FBB_D36: UV1.D21 UV10.E4
FBB_D37: UV1.E21 UV10.E2
FBB_D38: UV1.G21 UV10.F4
FBB_D39: UV1.F21 UV10.F2
FBB_D40: UV1.G27 UV10.A11
FBB_D41: UV1.D27 UV10.A13
FBB_D42: UV1.G26 UV10.B11
FBB_D43: UV1.E27 UV10.B13
FBB_D44: UV1.E29 UV10.E11
FBB_D45: UV1.F29 UV10.E13
FBB_D46: UV1.E30 UV10.F11
FBB_D47: UV1.D30 UV10.F13
FBB_D48: UV1.A32 UV10.U11
FBB_D49: UV1.C31 UV10.U13
FBB_D50: UV1.C32 UV10.T11
FBB_D51: UV1.B32 UV10.T13
FBB_D52: UV1.D29 UV10.N11
FBB_D53: UV1.A29 UV10.N13
FBB_D54: UV1.C29 UV10.M11
FBB_D55: UV1.B29 UV10.M13
FBB_D56: UV1.B21 UV10.U4
FBB_D57: UV1.C23 UV10.U2
FBB_D58: UV1.A21 UV10.T4
FBB_D59: UV1.C21 UV10.T2
FBB_D60: UV1.B24 UV10.N4
FBB_D61: UV1.C24 UV10.N2
FBB_D62: UV1.B26 UV10.M4
FBB_D63: UV1.C26 UV10.M2
FBB_DBI0: UV1.E11 UV9.D2
FBB_DBI1: UV1.E3 UV9.D13
FBB_DBI2: UV1.A3 UV9.P13
FBB_DBI3: UV1.C9 UV9.P2
FBB_DBI4: UV1.F23 UV10.D2
FBB_DBI5: UV1.F27 UV10.D13
FBB_DBI6: UV1.C30 UV10.P13
FBB_DBI7: UV1.A24 UV10.P2
FBB_EDC0: UV1.D10 UV9.C2
FBB_EDC1: UV1.D5 UV9.C13
FBB_EDC2: UV1.C3 UV9.R13
FBB_EDC3: UV1.B9 UV9.R2
FBB_EDC4: UV1.E23 UV10.C2
FBB_EDC5: UV1.E28 UV10.C13
FBB_EDC6: UV1.B30 UV10.R13
FBB_EDC7: UV1.A23 UV10.R2
FBB_SEN0: RV379.2 UV9.J10
FBB_SEN2: RV392.2 UV10.J10
FBB_WCK01: UV1.F8 UV9.D4
FBB_WCK01#: UV1.E8 UV9.D5
FBB_WCK23: UV1.A5 UV9.P4
FBB_WCK23#: UV1.A6 UV9.P5
FBB_WCK45: UV1.D24 UV10.D4
FBB_WCK45#: UV1.D25 UV10.D5
FBB_WCK67: UV1.B27 UV10.P4
FBB_WCK67#: UV1.C27 UV10.P5
FBVDD_EN: DV9.1 PR705.1 QZ6.5 RV209.1
FBVREF_ALTV: QV22.2 QV23.2 QV24.2 QV25.2 RV544.1 UV1.L1
FCCM_GT: PU1100.11 PU1300.1 PU1301.1
FCCM_SA: PU1100.34 PU1302.7
FCCM_VCORE: PU1100.24 PU1200.1 PU1201.1 PU1202.1
FFS_INT1: RF4.2 UF1.11 UH2.AW17
FFS_INT2: QF1.2 RF5.2 UF1.9 UH2.AN41
FFS_INT2_Q: JHDD.11 QF1.3 RF2.2
FWP#: RE68.2 RE70.2 UE3.B65
GC6_EVENT#_D: DV10.2 RV542.1 UV1.M7
GC6_FB_EN: DV9.3 RPH32.3 UH2.AW27 UV1.P6
GPU_COMP: PC1045.2 PC1046.2 PU1000.12
GPU_EN: PC1011.1 PR1006.1 PR1025.1 PR1028.1 PU1000.3
GPU_EVENT#: DV10.1 UH2.AR24
GPU_FB: PC1036.2 PR1015.2 PR1016.1 PR1017.2 PU1000.11
GPU_FBRTN: PR1012.2 PR1013.2 PU1000.10
GPU_GPIO13: RV10.1 UV1.M4
GPU_HOT#_R: DV11.2 RV543.1 UV1.N3
GPU_JTAG_TCK: T174.1(TP-1) UV1.AM10
GPU_JTAG_TDI: T11.1(TP-1) UV1.AM11
GPU_JTAG_TDO: T12.1(TP-1) UV1.AP12
GPU_JTAG_TMS: T13.1(TP-1) UV1.AP11
GPU_JTAG_TRST#: RV324.1 UV1.AN11
GPU_PEX_RST_HOLD#: DV8.3 RPH34.4 UV1.P1
GPU_PGOOD: PR1024.1 PU1000.16
GPU_PSI: PR1001.2 PU1000.4 RV10.2
GPU_PVCC: PC1042.1 PR1014.1 PU1000.21
GPU_PWR_LEVEL: DV11.1 UE3.B41
GPU_REFADJ: PR1004.2 PU1000.6
GPU_REFIN: PC1008.1 PR1003.1 PR1005.1 PU1000.7
GPU_TESTMODE: RV320.2 RV323.1 UV1.AK11
GPU_TON: PR1010.2 PU1000.9
GPU_VDD_SENSE: PR1015.1 UV1.L4
GPU_VID: PR1000.2 PU1000.5
GPU_VID_0: PR1000.1 UV1.M5
GPU_VREF: PC1000.1 PR1002.1 PU1000.8
GPU_VSS_SENSE: PR1012.1 UV1.L5
H_CATERR#: RH570.2 UH1.BM30
H_CPUPWRGD: UH1.BT31 UH2.AM3
H_DRAMRST#: CD69.1 RD31.2 RD35.2 UH2.BC14
H_PECI: RE48.2 RH190.1 RH539.2
H_PECI_R: RH190.2 UH1.BT34
H_PM_DOWN: RH155.1 UH2.AH2
H_PM_DOWN_R: RH155.2 UH1.BP31
H_PM_SYNC_R: RH189.2 UH1.BM34
H_PROCHOT#: PR315.1 PR1103.1 RE96.2 RH158.1 RH165.2
H_PROCHOT#_EC: RE96.1 UE3.A46
H_PROCHOT#_R: RH158.2 UH1.BR30
H_THERMTRIP#: RH191.1 UH2.AJ3
H_THERMTRIP#_R: QE10.3 RH163.2 RH191.2 UH1.J31
H_VCCST_PWRGD: RH154.1 RH164.2 RH482.1 RZ82.2 UZ19.4
H_VCCST_PWRGD_EC: RZ82.1 RZ84.2 UE3.A44 UZ19.1
HDA_BITCLK: CH50.2 RP15.8 UH2.BA9
HDA_BITCLK_AUDIO: JAUDIO.9 RP15.1
HDA_RST#: RP15.6 UH2.BD8
HDA_RST#_AUDIO: JAUDIO.13 RP15.3
HDA_SDIN0: RH96.2 UH2.BE7
HDA_SDIN0_AUDIO: JAUDIO.15 RH96.1
HDA_SDOUT: CH51.2 RH454.2 RP15.5 UH2.BB7
HDA_SDOUT_AUDIO: JAUDIO.17 RP15.4
HDA_SYNC: RP15.7 UH2.BD9
HDA_SYNC_AUDIO: JAUDIO.11 RP15.2
HDD_DET#: JHDD.12 RH513.1 UH2.AG39
HDMI_CEC: CV182.2 JHDMI1.13
HDMI_HPLUG: CV180.2 JHDMI1.19 QV14.1 RV123.1
HDMI_RESERVED: CV181.2 JHDMI1.14
HOST_DEBUG_TX: JDEG1.8 RE64.2 UE3.B44
HOST_SD_WP#: QR1.2 RH563.2 UH2.AU44
I2C0_SCK: RH424.2 RH521.2 UH2.AR38
I2C0_SCK_DSP: JAUDIO.21 QE18.4 RE136.2 RH521.1
I2C0_SDA: RH425.2 RH522.2 UH2.AT42
I2C0_SDA_DSP: JAUDIO.19 QE18.1 RE137.2 RH522.1
I2C1_SCK_TP: QE2.3 RH119.2 UH2.AR41
I2C1_SCK_TP_C: CE79.1 DE5.3 JTP.6 QE19.3 RE9.1
I2C1_SDA_TP: QE2.6 RH120.2 UH2.AR44
I2C1_SDA_TP_C: CE80.1 DE5.2 JTP.7 QE19.6 RE7.1
I2C_EN8723: RI25.1 UI3.24
I2CA_SCL: RPH13.1 RPH15.1 UV1.R4
I2CA_SDA: RPH13.2 RPH15.2 UV1.R5
I2CB_SCL: RPH13.3 RPH15.3 UV1.R7
I2CB_SDA: RPH13.4 RPH15.4 UV1.R6
I2CC_SCL: RV299.1 RV319.1 UV1.R2
I2CC_SDA: RV300.1 RV331.1 UV1.R3
I_ADP: PR314.1 UE3.A12
I_BATT: PR317.1 RE55.2
ILIM_HI1: RI12.1 UI2.16
ILIM_HI3: RI7.1 UI1.16
ILIM_LO1: RI11.1 UI2.15
ILIM_LO3: RI6.1 UI1.15
ILIM_SEL_L: DI12.3 RI31.2 RI33.1 RI34.2 UI1.4
ILIM_SEL_R: DI12.2 RI30.2 RI32.1 RI34.1 RI35.2 UI2.4
ILMT_0.95V: PR811.2 PR812.1 PU800.3
ILMT_1.05V: PR910.2 PR912.1 PU900.3
ILMT_1V: PR510.2 PR512.1 PU500.3
IMVP_VR_ON: UE3.A1 UZ21.1
IMVP_VR_PG: PR1119.1 UH14.1
INA199_OUT: PC210.2 PD205.1 PR233.1 PR239.1 PU201.3
INTRUDER#: RH531.1 UH2.BE11
INV_PWM: DV2.1 JEDP1.25 RV109.1
IRQ_SERIRQ: RH111.1 UE3.A28 UH2.BA17
ISEN1_GT: PC1125.2 PR1303.2 PU1100.9
ISEN1_VCORE: PC1124.1 PR1201.2 PR1214.2 PR1216.2 PU1100.21
ISEN2_GT: PC1122.2 PR1306.2 PU1100.10
ISEN2_VCORE: PC1123.1 PR1205.2 PR1212.2 PR1217.2 PU1100.22
ISEN3_VCORE: PC1120.1 PR1209.2 PR1213.2 PR1215.2 PU1100.23
ISUMN_GT: PC1112.2 PC1119.1 PC1122.1 PC1125.1 PC1133.2 PH1102.2 PR1123.2 PR1127.1 PR1130.1 PR1302.1 PR1304.2
ISUMN_SA: PC1110.1 PC1111.1 PC1136.1 PH1101.1 PR1115.2 PR1117.1 PR1120.1 PR1310.2
ISUMN_VCORE: PC1120.2 PC1123.2 PC1124.2 PC1126.1 PC1127.1 PC1135.1 PH1103.1 PR1133.2 PR1134.1 PR1135.2 PR1203.1 PR1207.1 PR1211.1
ISUMP_GT: PC1112.1 PC1133.1 PR1122.1 PR1123.1 PR1301.2 PR1305.2 PU1100.7
ISUMP_SA: PC1111.2 PC1136.2 PR1120.2 PR1121.2 PR1309.2 PU1100.32
ISUMP_VCORE: PC1127.2 PC1135.2 PR1134.2 PR1136.2 PR1202.2 PR1206.2 PR1210.2 PU1100.19
JTAG_CLK: JDEG1.4 RP20.3 UE3.B56
JTAG_RST#: CE44.1 JTAG1.1 RE59.2 RE61.1 UE3.B47
JTAG_TDI: JDEG1.2 RP20.1 UE3.A51
JTAG_TDO: JDEG1.5 RP20.4 UE3.B55
JTAG_TMS: JDEG1.3 RP20.2 UE3.A53
KB_DET#: JKB.5 RH557.1 UH2.BD22
LAN_WAKE#: RH545.1 UE3.B27 UH2.BD11
LCD_DBC: RH527.1 RH528.1 UH2.U35
LCD_TST: RE32.2 RV110.1 UE3.A38
LCD_VCC_TEST_EN: DV7.2 UE3.A39
LDO_EN: PC219.1 PD202.1 PD203.1 PR272.2 PU203.1
LG_3V: PC415.1 PQ402.4 PU400.11
LG_5V: PC416.1 PQ403.4 PU400.15
LID_CL_SIO#: CE31.1 RE41.2 RE45.2 UE3.A21
LID_SW_IN#: CE16.1 RE15.2 RE45.1 UE2.3
LPC_AD0: JLPDE1.3 UE3.A30 UH2.AT22
LPC_AD1: JLPDE1.4 UE3.B32 UH2.AV22
LPC_AD2: JLPDE1.5 UE3.A31 UH2.AT19
LPC_AD3: JLPDE1.6 UE3.B33 UH2.BD16
LPC_FRAME#: JLPDE1.7 UE3.B31 UH2.BE16
LX_0.95V: PC805.2 PL801.1 PR802.1 PU800.10
LX_1.05V: PC906.2 PL901.1 PR902.1 PU900.10
LX_1V: PC505.2 PL501.1 PR502.1 PU500.10
LX_3V: PC410.1 PL400.2 PQ400.1 PQ400.2 PQ400.3 PQ402.5 PR413.1 PU400.8
LX_5V: PC411.2 PL401.1 PQ401.1 PQ401.2 PQ401.3 PQ403.5 PR414.1 PU400.18
M_CLK_DDR0: JDIMM1.137 UH1.AG1
M_CLK_DDR1: JDIMM1.138 UH1.AK2
M_CLK_DDR2: JDIMM2.137 UH1.AM9
M_CLK_DDR3: JDIMM2.138 UH1.AM7
M_CLK_DDR#0: JDIMM1.139 UH1.AG2
M_CLK_DDR#1: JDIMM1.140 UH1.AK1
M_CLK_DDR#2: JDIMM2.139 UH1.AN9
M_CLK_DDR#3: JDIMM2.140 UH1.AM8
M_ODT0: JDIMM1.155 UH1.AD3
M_ODT1: JDIMM1.161 UH1.AE4
M_ODT2: JDIMM2.155 UH1.AF7
M_ODT3: JDIMM2.161 UH1.AE8
MCARD_PCIE#_SATA: RD58.1 RH508.1 UD2.4 UH2.AG36
MCARD_PCIE_SATA#: JNGFF2.61 RD10.2 RD58.2 UD2.2
ME_EN: RH454.1 RH487.1 SW4.2
ME_FWP_EC: RH487.2 SW4.3 UE3.B1
ME_SUS_PWR_ACK: RH506.1 UE3.A8 UH2.BD19
MEC_XTAL1: CE42.1 UE3.A61 YE1.1
MEC_XTAL2: CE43.1 RE51.2 YE1.2
MEC_XTAL2_R: RE51.1 UE3.A62
MEDIACARD_IRQ#: RH546.1 RR10.1 UH2.AL39
MSATA_DEVSLP: JNGFF2.38 RD7.2 UH2.AG42
MSCLK: JDEG1.6 RE63.2 RE103.1
MSCLK_R: RE103.2 RE119.2 UE3.B43
MSDATA: JDEG1.7 RE27.1 RE65.2 RE102.1
MSDATA_R: RE102.2 RE118.2 UE3.A40
MULTI_STRAP_REF0_GND: RV318.1 UV1.J1
NB_MUTE#: JAUDIO.10 UE4.20
NC_B4: RT207.2 UT1.B4
NC_B5: RT208.2 UT1.B5
NC_G2: RT209.2 UT1.G2
NGFF_ON: DN3.1 RN33.2 UN3.3
NGFF_PWREN: DN3.2 RH520.2 UH2.BC27
NRB_BIT: RH524.2 UH2.BD28
P_SYS: PC1100.2 PR324.1 PR1100.2 PU1100.1 UE3.A57
PANEL_BKEN_EC: DV1.2 UE4.4
PANEL_BKEN_PCH: DV1.3 UH2.W35
PBAT_PRES#: PR111.2 PR112.1 PR322.1 UE3.A49
PBAT_SMBCLK: PR106.2 RE18.2 UE3.A56
PBAT_SMBDAT: PR108.2 RE17.2 UE3.B59
PBTN_SW#: CE29.1 DE2.2 JAPS.11 RE36.2 SW1.1
PCH_ALW_ON: PR500.2 RZ46.2 UE3.A34 UZ4.3 UZ23.2
PCH_BATLOW#: RH515.1 UH2.BD13
PCH_CPU_BCLK_N: UH1.A32 UH2.H2
PCH_CPU_BCLK_P: UH1.B31 UH2.G2
PCH_CPU_PCIBCLK_N: UH1.C36 UH2.J1
PCH_CPU_PCIBCLK_P: UH1.D35 UH2.J2
PCH_DPWROK: RH309.1 UE3.A36
PCH_DPWROK_R: RH309.2 RH401.2 UH2.AV11
PCH_ITP_PMODE: RH479.1 UH2.AT2
PCH_JTAG_TCK: JXDP.55 RH95.2 UH2.AN3
PCH_JTAG_TDI: RH100.2 RH477.2 UH2.AP2
PCH_JTAG_TDO: RH97.2 RH478.2 UH2.AP1
PCH_JTAG_TMS: RH12.2 RH98.2 UH2.AR2
PCH_JTAGX: RH491.1 UH2.AR3
PCH_PCIE_WAKE#: RH453.1 UE3.B46 UH2.BC13
PCH_PECI: RH539.1 UH2.AL3
PCH_PLTRST#: UH2.BB27 UH7.1 UH7.2
PCH_PLTRST#_EC: JLPDE1.8 JNGFF1.44 JNGFF2.50 RE31.2 RH77.1 UE1.17 UE3.B30 UH7.4 UR1.1 UT1.L4 UV14.2
PCH_PWROK: RH529.1 UH2.AW11 UH14.4
PCH_RSMRST#: RH133.1 RH481.1 UE3.A45
PCH_RSMRST#_R: RH88.2 RH133.2 UH2.BA11
PCH_RTCRST#: CH53.1 CLRP1.1 JAPS.9 RH84.2 UH2.BC10
PCH_RTCX1: CH45.1 RH70.1 UH2.BC9 YH1.1
PCH_RTCX2: CH46.1 RH70.2 UH2.BD10 YH1.2
PCH_SATA_LED#: RH512.1 UH2.AD44
PCH_SMBCLK: JDIMM1.253 JDIMM2.253 JXDP.53 QH4.1 RH463.2 UF1.4
PCH_SMBDATA: JDIMM1.254 JDIMM2.254 JXDP.51 QH4.4 RH462.2 UF1.6
PCH_SPI_CLK: RP4.1 UH8.6
PCH_SPI_CLK_R: RH579.2 RP4.8 UH2.BC31
PCH_SPI_CS1#: T18.1(TP-1) UH2.AW31
PCH_SPI_CS2#: RE126.1 RE132.1 RE133.1 UH2.AT31
PCH_SPI_CS2#_R: RE133.2 UE1.20
PCH_SPI_CS#: RH74.2 UH2.BD31 UH8.1
PCH_SPI_HOLD#: RH576.1 UH8.7
PCH_SPI_HOLD#_R: RH78.2 RH455.2 RH576.2 UH2.BD30
PCH_SPI_SI: RP4.2 UH8.5
PCH_SPI_SI_R: RH489.1 RH578.2 RP4.7 UH2.BB29
PCH_SPI_SO: RP4.3 UH8.2
PCH_SPI_SO_R: RH577.2 RP4.6 UH2.BE30
PCH_SPI_WP#: RP4.4 UH8.3
PCH_SPI_WP#_R: RH75.2 RH573.2 RP4.5 UH2.BC29
PCH_SRTCRST#: CH52.1 RH83.2 UH2.BB10
PCH_SYS_PWROK_XDP: JXDP.47 RH489.2 RH490.2 RH493.2
PCH_TPM_CLK: RE115.1 RH579.1
PCH_TPM_CLK_C: RE11.1 RE115.2 UE1.19
PCH_TPM_SI: RE114.1 RH578.1
PCH_TPM_SO: RE113.1 RH577.1
PCH_TRIGGER: RH167.1 UH2.AL2
PCH_TRIGGER_R: RH167.2 UH1.H23
PCH_XDP_CLK_N: JXDP.42 UH2.L1
PCH_XDP_CLK_P: JXDP.40 UH2.L2
PCI_CLK_LPC1: CH199.1 JLPDE1.10 RH428.2
PCIE_PRX_CARDTX_N2: CR13.1 UH2.E17
PCIE_PRX_CARDTX_N2_C: CR13.2 UR1.8
PCIE_PRX_CARDTX_P2: CR10.1 UH2.G17
PCIE_PRX_CARDTX_P2_C: CR10.2 UR1.7
PCIE_PRX_SSDTX_N10: JNGFF2.29 UH2.G29
PCIE_PRX_SSDTX_N11: JNGFF2.17 UH2.L31
PCIE_PRX_SSDTX_N12: JNGFF2.5 UH2.G33
PCIE_PRX_SSDTX_P10: JNGFF2.31 UH2.E29
PCIE_PRX_SSDTX_P11: JNGFF2.19 UH2.K31
PCIE_PRX_SSDTX_P12: JNGFF2.7 UH2.H33
PCIE_PRX_TBTX_N15: CT3.1 UH2.F41
PCIE_PRX_TBTX_N15_C: CT3.2 UT1.V22
PCIE_PRX_TBTX_N16: CT7.1 UH2.D43
PCIE_PRX_TBTX_N16_C: CT7.2 UT1.P22
PCIE_PRX_TBTX_P15: CT1.1 UH2.E41
PCIE_PRX_TBTX_P15_C: CT1.2 UT1.V23
PCIE_PRX_TBTX_P16: CT5.1 UH2.E42
PCIE_PRX_TBTX_P16_C: CT5.2 UT1.P23
PCIE_PRX_WLANTX_N1: JNGFF1.35 UH2.H15
PCIE_PRX_WLANTX_P1: JNGFF1.33 UH2.G15
PCIE_PTX_CARDRX_N2: CR9.1 UH2.B19
PCIE_PTX_CARDRX_N2_C: CR9.2 UR1.4
PCIE_PTX_CARDRX_P2: CR7.1 UH2.C19
PCIE_PTX_CARDRX_P2_C: CR7.2 UR1.3
PCIE_PTX_SSDRX_N10: CD45.1 UH2.C32
PCIE_PTX_SSDRX_N10_C: CD45.2 JNGFF2.35
PCIE_PTX_SSDRX_N11: CD43.1 UH2.C33
PCIE_PTX_SSDRX_N11_C: CD43.2 JNGFF2.23
PCIE_PTX_SSDRX_N12: CD37.1 UH2.B35
PCIE_PTX_SSDRX_N12_C: CD37.2 JNGFF2.11
PCIE_PTX_SSDRX_P10: CD46.1 UH2.B32
PCIE_PTX_SSDRX_P10_C: CD46.2 JNGFF2.37
PCIE_PTX_SSDRX_P11: CD44.1 UH2.B33
PCIE_PTX_SSDRX_P11_C: CD44.2 JNGFF2.25
PCIE_PTX_SSDRX_P12: CD42.1 UH2.A35
PCIE_PTX_SSDRX_P12_C: CD42.2 JNGFF2.13
PCIE_PTX_TBRX_N15: CT4.2 UH2.B39
PCIE_PTX_TBRX_N15_C: CT4.1 UT1.Y22
PCIE_PTX_TBRX_N16: CT8.2 UH2.A41
PCIE_PTX_TBRX_N16_C: CT8.1 UT1.T22
PCIE_PTX_TBRX_P15: CT2.2 UH2.A39
PCIE_PTX_TBRX_P15_C: CT2.1 UT1.Y23
PCIE_PTX_TBRX_P16: CT6.2 UH2.A40
PCIE_PTX_TBRX_P16_C: CT6.1 UT1.T23
PCIE_PTX_WLANRX_N1: CN20.1 UH2.A16
PCIE_PTX_WLANRX_P1: CN21.1 UH2.B16
PCIE_PTX_WLANRX_RE_N1: CN20.2 JNGFF1.29
PCIE_PTX_WLANRX_RE_P1: CN21.2 JNGFF1.27
PCIE_WAKE#: JNGFF1.47 RD59.2 RE19.1 RE120.2 UE3.B8
PD_EE_CLK: RT210.2 UT4.A3 UT5.6
PD_EE_CS#: RT168.2 RT213.2 UT4.B3 UT5.1
PD_EE_DI: RT211.2 UT4.B4 UT5.5
PD_EE_DO: RT169.2 RT212.2 UT4.A4 UT5.2
PD_EE_WP#: RT170.2 UT5.3
PD_HOLD#: RT171.2 UT5.7
PD_I2C_ALERT#: RE99.1 UE3.A42 UT4.B6
PD_SENSEN: PR218.2 UT4.A10
PD_SENSEP: PR221.2 UT4.B10
PEG_GTX_C_HRX_N0: CV532.2 UH1.E10
PEG_GTX_C_HRX_N1: CV534.2 UH1.E11
PEG_GTX_C_HRX_N2: CV536.2 UH1.E12
PEG_GTX_C_HRX_N3: CV538.2 UH1.E13
PEG_GTX_C_HRX_N4: CV540.2 UH1.E14
PEG_GTX_C_HRX_N5: CV542.2 UH1.E15
PEG_GTX_C_HRX_N6: CV544.2 UH1.E16
PEG_GTX_C_HRX_N7: CV546.2 UH1.E17
PEG_GTX_C_HRX_N8: CV548.2 UH1.F18
PEG_GTX_C_HRX_N9: CV551.2 UH1.D19
PEG_GTX_C_HRX_N10: CV557.2 UH1.F20
PEG_GTX_C_HRX_N11: CV559.2 UH1.D21
PEG_GTX_C_HRX_N12: CV561.2 UH1.F22
PEG_GTX_C_HRX_N13: CV563.2 UH1.D23
PEG_GTX_C_HRX_N14: CV565.2 UH1.F24
PEG_GTX_C_HRX_N15: CV567.2 UH1.D25
PEG_GTX_C_HRX_P0: CV531.2 UH1.F10
PEG_GTX_C_HRX_P1: CV533.2 UH1.D11
PEG_GTX_C_HRX_P2: CV535.2 UH1.F12
PEG_GTX_C_HRX_P3: CV537.2 UH1.D13
PEG_GTX_C_HRX_P4: CV539.2 UH1.F14
PEG_GTX_C_HRX_P5: CV541.2 UH1.D15
PEG_GTX_C_HRX_P6: CV543.2 UH1.F16
PEG_GTX_C_HRX_P7: CV545.2 UH1.D17
PEG_GTX_C_HRX_P8: CV547.2 UH1.E18
PEG_GTX_C_HRX_P9: CV550.2 UH1.E19
PEG_GTX_C_HRX_P10: CV552.2 UH1.E20
PEG_GTX_C_HRX_P11: CV558.2 UH1.E21
PEG_GTX_C_HRX_P12: CV560.2 UH1.E22
PEG_GTX_C_HRX_P13: CV562.2 UH1.E23
PEG_GTX_C_HRX_P14: CV564.2 UH1.E24
PEG_GTX_C_HRX_P15: CV566.2 UH1.E25
PEG_GTX_HRX_N0: CV532.1 UV1.AJ14
PEG_GTX_HRX_N1: CV534.1 UV1.AG14
PEG_GTX_HRX_N2: CV536.1 UV1.AJ15
PEG_GTX_HRX_N3: CV538.1 UV1.AK16
PEG_GTX_HRX_N4: CV540.1 UV1.AJ17
PEG_GTX_HRX_N5: CV542.1 UV1.AG17
PEG_GTX_HRX_N6: CV544.1 UV1.AJ18
PEG_GTX_HRX_N7: CV546.1 UV1.AK19
PEG_GTX_HRX_N8: CV548.1 UV1.AJ20
PEG_GTX_HRX_N9: CV551.1 UV1.AG20
PEG_GTX_HRX_N10: CV557.1 UV1.AJ21
PEG_GTX_HRX_N11: CV559.1 UV1.AK22
PEG_GTX_HRX_N12: CV561.1 UV1.AJ23
PEG_GTX_HRX_N13: CV563.1 UV1.AG23
PEG_GTX_HRX_N14: CV565.1 UV1.AJ24
PEG_GTX_HRX_N15: CV567.1 UV1.AK25
PEG_GTX_HRX_P0: CV531.1 UV1.AK14
PEG_GTX_HRX_P1: CV533.1 UV1.AH14
PEG_GTX_HRX_P2: CV535.1 UV1.AK15
PEG_GTX_HRX_P3: CV537.1 UV1.AL16
PEG_GTX_HRX_P4: CV539.1 UV1.AK17
PEG_GTX_HRX_P5: CV541.1 UV1.AH17
PEG_GTX_HRX_P6: CV543.1 UV1.AK18
PEG_GTX_HRX_P7: CV545.1 UV1.AL19
PEG_GTX_HRX_P8: CV547.1 UV1.AK20
PEG_GTX_HRX_P9: CV550.1 UV1.AH20
PEG_GTX_HRX_P10: CV552.1 UV1.AK21
PEG_GTX_HRX_P11: CV558.1 UV1.AL22
PEG_GTX_HRX_P12: CV560.1 UV1.AK23
PEG_GTX_HRX_P13: CV562.1 UV1.AH23
PEG_GTX_HRX_P14: CV564.1 UV1.AK24
PEG_GTX_HRX_P15: CV566.1 UV1.AL25
PEG_HTX_C_GRX_N0: CH36.2 UV1.AM12
PEG_HTX_C_GRX_N1: CH34.2 UV1.AM14
PEG_HTX_C_GRX_N2: CH32.2 UV1.AP15
PEG_HTX_C_GRX_N3: CH30.2 UV1.AM15
PEG_HTX_C_GRX_N4: CH28.2 UV1.AM17
PEG_HTX_C_GRX_N5: CH26.2 UV1.AP18
PEG_HTX_C_GRX_N6: CH24.2 UV1.AM18
PEG_HTX_C_GRX_N7: CH22.2 UV1.AM20
PEG_HTX_C_GRX_N8: CH20.2 UV1.AP21
PEG_HTX_C_GRX_N9: CH18.2 UV1.AM21
PEG_HTX_C_GRX_N10: CH16.2 UV1.AM23
PEG_HTX_C_GRX_N11: CH14.2 UV1.AP24
PEG_HTX_C_GRX_N12: CH12.2 UV1.AM24
PEG_HTX_C_GRX_N13: CH10.2 UV1.AM26
PEG_HTX_C_GRX_N14: CH8.2 UV1.AP27
PEG_HTX_C_GRX_N15: CH6.2 UV1.AM27
PEG_HTX_C_GRX_P0: CH35.2 UV1.AN12
PEG_HTX_C_GRX_P1: CH33.2 UV1.AN14
PEG_HTX_C_GRX_P2: CH31.2 UV1.AP14
PEG_HTX_C_GRX_P3: CH29.2 UV1.AN15
PEG_HTX_C_GRX_P4: CH27.2 UV1.AN17
PEG_HTX_C_GRX_P5: CH25.2 UV1.AP17
PEG_HTX_C_GRX_P6: CH23.2 UV1.AN18
PEG_HTX_C_GRX_P7: CH21.2 UV1.AN20
PEG_HTX_C_GRX_P8: CH19.2 UV1.AP20
PEG_HTX_C_GRX_P9: CH17.2 UV1.AN21
PEG_HTX_C_GRX_P10: CH15.2 UV1.AN23
PEG_HTX_C_GRX_P11: CH13.2 UV1.AP23
PEG_HTX_C_GRX_P12: CH11.2 UV1.AN24
PEG_HTX_C_GRX_P13: CH9.2 UV1.AN26
PEG_HTX_C_GRX_P14: CH7.2 UV1.AP26
PEG_HTX_C_GRX_P15: CH5.2 UV1.AN27
PEG_HTX_GRX_N0: CH36.1 UH1.B10
PEG_HTX_GRX_N1: CH34.1 UH1.B11
PEG_HTX_GRX_N2: CH32.1 UH1.B12
PEG_HTX_GRX_N3: CH30.1 UH1.B13
PEG_HTX_GRX_N4: CH28.1 UH1.B14
PEG_HTX_GRX_N5: CH26.1 UH1.B15
PEG_HTX_GRX_N6: CH24.1 UH1.B16
PEG_HTX_GRX_N7: CH22.1 UH1.B17
PEG_HTX_GRX_N8: CH20.1 UH1.C18
PEG_HTX_GRX_N9: CH18.1 UH1.A19
PEG_HTX_GRX_N10: CH16.1 UH1.C20
PEG_HTX_GRX_N11: CH14.1 UH1.A21
PEG_HTX_GRX_N12: CH12.1 UH1.C22
PEG_HTX_GRX_N13: CH10.1 UH1.A23
PEG_HTX_GRX_N14: CH8.1 UH1.C24
PEG_HTX_GRX_N15: CH6.1 UH1.A25
PEG_HTX_GRX_P0: CH35.1 UH1.C10
PEG_HTX_GRX_P1: CH33.1 UH1.A11
PEG_HTX_GRX_P2: CH31.1 UH1.C12
PEG_HTX_GRX_P3: CH29.1 UH1.A13
PEG_HTX_GRX_P4: CH27.1 UH1.C14
PEG_HTX_GRX_P5: CH25.1 UH1.A15
PEG_HTX_GRX_P6: CH23.1 UH1.C16
PEG_HTX_GRX_P7: CH21.1 UH1.A17
PEG_HTX_GRX_P8: CH19.1 UH1.B18
PEG_HTX_GRX_P9: CH17.1 UH1.B19
PEG_HTX_GRX_P10: CH15.1 UH1.B20
PEG_HTX_GRX_P11: CH13.1 UH1.B21
PEG_HTX_GRX_P12: CH11.1 UH1.B22
PEG_HTX_GRX_P13: CH9.1 UH1.B23
PEG_HTX_GRX_P14: CH7.1 UH1.B24
PEG_HTX_GRX_P15: CH5.1 UH1.B25
PEX_TSTCLK_OUT: RV286.2 UV1.AJ26
PEX_TSTCLK_OUT#: RV286.1 UV1.AK26
PLTRST_CPU#: RH480.1 UH1.BP35 UH2.AK2
POWER_SW_IN#: CE30.1 RE34.2 RE36.1 RE110.1 UE3.B67
PP_HV: CT155.1 PD203.2 PR287.1 UT4.A6 UT4.A7 UT4.A8 UT4.B7
PROC_DETECT#: RH519.1 UH2.Y44
PS_ID: PR101.2 PR102.2 UE3.B24
PSID: ADP100.4 PD100.1 PL104.1
PSID-1: PQ101.2 PR103.2 PR105.1
PSID-2: PQ100.2 PQ101.1 PR104.1
PSID-3: PQ100.3 PR100.2 PR102.1
PTP_DIS#: JTP.3 UE4.21
PTP_INT#: DH1.1 QE13.1 RE138.1
PTP_INT#_EC: RE138.2 RP19.2 UE3.B37
PTP_INT#_R: JTP.4 QE13.3 RE87.2
PWM1_GT: PU1100.12 PU1300.13
PWM1_VCORE: PU1100.25 PU1200.13
PWM2_GT: PU1100.13 PU1301.13
PWM2_VCORE: PU1100.26 PU1201.13
PWM3_VCORE: PU1100.27 PU1202.13
PWM_SA: PU1100.35 PU1302.3
PWR_BTN_DOCK1#: QV89.3 RT182.2 RT194.2
PWR_DEBUG#_XDP: JXDP.45 RH483.2 RH488.1
PWR_SRC_ILIMIT: PC211.1 PD205.2 PR236.1 PR239.2 PR266.1 PU201.1 RT198.2
PWR_SRC_ON: PR212.2 UE4.2
PWR_SRC_ON_PC: PR214.2 UT4.D10
PWR_TB_DOCK#: RE110.2 RT195.2
PWRBTN#_XDP: CH174.1 JXDP.41 RH2.2 RH6.1
PWRBTN_LED#: LED6.1 UE3.B57
REF_+1.35V_RUNP: PC708.2 PR701.1 PU700.26
REM_DIODE1_N: CE32.1 CE45.1 CE69.1 QE7.1 QE7.2 QE15.3 UE3.B13
REM_DIODE1_P: CE32.2 CE45.2 CE69.2 QE7.3 QE15.1 QE15.2 UE3.A13
REM_DIODE2_N: CE33.1 CE46.2 CE47.2 QE5.1 QE5.2 QE6.3 UE3.B14
REM_DIODE2_P: CE33.2 CE46.1 CE47.1 QE5.3 QE6.1 QE6.2 UE3.A14
REM_DIODE3_N: CE35.1 CE49.2 CE68.2 QE8.1 QE8.2 QE11.3 UE3.A15
REM_DIODE3_P: CE35.2 CE49.1 CE68.1 QE8.3 QE11.1 QE11.2 UE3.B16
REM_DIODE4_N: CE36.1 CE50.1 CE72.1 QE9.3 QE12.1 QE12.2 UE3.A16
REM_DIODE4_P: CE36.2 CE50.2 CE72.2 QE9.1 QE9.2 QE12.3 UE3.B17
RESET_OUT#: RE33.2 RH91.2 RH490.1 UE3.B39 UH2.AY1
ROM_CS_GPU: T176.1(TP-1) UV1.H6
ROM_SCLK_GPU: RV305.1 RV313.2 UV1.H4
ROM_SI_GPU: RV304.1 RV312.2 UV1.H5
ROM_SO_GPU: RV303.1 RV311.2 UV1.H7
RREF: RR6.2 UR1.9
RTD3_CIO_PWR_EN: RT39.2 UH2.R39 UT1.F1
RTD3_USB_PWR_EN: RT40.2 UT1.D4
RUN_ON: RE37.2 UE3.B9
RUN_ON#: QE4.5 QE4.6 RE56.2
RUN_ON_EC: QE4.2 RE35.1 RE37.1 RZ43.2 RZ76.1 UZ1.3 UZ1.5 UZ7.3 UZ20.1
RUN_ON_P: PR610.2 PR800.2 RZ50.1 RZ58.2 RZ90.1 UZ9.4 UZ11.4
RUNPWROK: QE4.3 RE52.2 UE3.B26 UH14.2
S5_1.2V: PC613.1 PR606.2 PU600.8
SATA_PRX_DTX_N1B: CS20.1 UH2.D39
SATA_PRX_DTX_N1B_RC: CS20.2 JHDD.8
SATA_PRX_DTX_P1B: CS19.1 UH2.E37
SATA_PRX_DTX_P1B_RC: CS19.2 JHDD.9
SATA_PRX_SSDTX_N0A: JNGFF2.43 UH2.G31
SATA_PRX_SSDTX_P0A: JNGFF2.41 UH2.H31
SATA_PTX_DRX_N1B: CS18.1 UH2.B38
SATA_PTX_DRX_N1B_RC: CS18.2 JHDD.6
SATA_PTX_DRX_P1B: CS17.1 UH2.C38
SATA_PTX_DRX_P1B_RC: CS17.2 JHDD.5
SATA_PTX_SSDRX_N0A: CD53.1 UH2.C31
SATA_PTX_SSDRX_N0A_C: CD53.2 JNGFF2.47
SATA_PTX_SSDRX_P0A: CD51.1 UH2.B31
SATA_PTX_SSDRX_P0A_C: CD51.2 JNGFF2.49
SD_CD#: JCR.8 UR1.30
SD_CLK: CR8.1 JCR.6 RR4.2
SD_CLK_R: RR4.1 UR1.17
SD_CMD: JCR.3 RR5.2
SD_CMD_R: RR5.1 UR1.19
SD_D2: JCR.1 RR8.2
SD_D2_R: RR8.1 UR1.21
SD_D3: JCR.2 RR7.2
SD_D3_R: RR7.1 UR1.20
SD_LN0_M: JCR.14 UR1.25
SD_LN0_P: JCR.13 UR1.26
SD_LN1_M: JCR.17 UR1.23
SD_LN1_P: JCR.18 UR1.22
SD_RCLK_M: JCR.10 RR2.2
SD_RCLK_M_R: RR2.1 UR1.15
SD_RCLK_P: JCR.9 RR3.2
SD_RCLK_P_R: RR3.1 UR1.16
SD_REG2: CR16.1 UR1.24
SIO_EXT_SCI#: RH383.2 UE3.A33 UH2.AV29
SIO_EXT_SMI#: RE140.1 RH110.1 UE3.A6 UH2.AF41
SIO_EXT_WAKE#: RH523.2 UE3.B5 UH2.AN44
SIO_PWRBTN#: RH6.2 UE3.B58 UH2.AT13
SIO_RCIN#: RH518.1 UE3.A27 UH2.AT17
SIO_SLP_A#: JAPS.6 UE3.B28 UH2.BC15
SIO_SLP_S0#: DZ1.2 JAPS.15 RE125.1 RZ59.1 RZ61.1 UH2.BC26
SIO_SLP_S3#: JAPS.2 RE35.2 RZ81.1 UE3.A35 UH2.AW15 UT1.D2 UZ20.2 UZ21.2
SIO_SLP_S4#: JAPS.5 RE38.2 UE3.B36 UH2.BD15 UZ22.2
SIO_SLP_S5#: DZ1.3 JAPS.4 RZ89.1 UE3.A18 UH2.BA13
SIO_SLP_SUS#: RE111.2 UH2.BB13
SIO_SLP_WLAN#: UE3.B45 UH2.AV13
SM_PG_CTRL: PR608.1 RH525.2 UC1.4
SMBALERT#: RH505.2 UH2.BB41
SMBCLK: QH4.6 RH458.2 UH2.AW44
SMBDATA: QH4.3 RH459.2 UH2.BB43
SML0_SMBCLK: RH501.2 UH2.AY44
SML0_SMBDATA: RH502.2 UH2.BB39
SML0ALERT#: RH503.2 UH2.BA40
SML1_SMBCLK: RH460.2 UE3.B6 UH2.AW42
SML1_SMBDAT: RH461.2 UE3.A5 UH2.AW45
SML1ALERT#: RH504.2 UH2.AT27
SNB_0.95V: PC801.1 PR802.2
SNB_1.05V: PC901.1 PR902.2
SNB_1V: PC501.1 PR502.2
SNUB_1.2V: PC611.1 PR602.2
SNUB_3V: PC414.1 PR413.2
SNUB_5V: PC417.1 PR414.2
SP7_SDWP: QR1.1 UR1.29
SP7_SDWP_C: JCR.11 QR1.3
SPK_DET#: JAUDIO.16 RE139.1 RH572.1 UH2.BD21
SPK_DET#_EC: RE139.2 UE3.B42
SPKR: JAUDIO.14 RH82.2 UH2.BD26
SRCCLKREQ1#: RH549.2 UH2.AW24
SRCCLKREQ2#: RH550.2 UH2.AT24
SRCCLKREQ8#: RP22.7 UH2.BD32
SRCCLKREQ9#: RP22.6 UH2.BC32
SRCCLKREQ10#: RP22.8 UH2.BB31
SRCCLKREQ11#: RP23.8 UH2.BC33
SRCCLKREQ12#: RP23.5 UH2.BA33
SRCCLKREQ13#: RP23.6 UH2.AW33
SRCCLKREQ14#: RP23.7 UH2.BB33
SRCCLKREQ15#: RP22.5 UH2.BD33
SSD_CLK_REQ#: JNGFF2.52 RP2.8 UH2.AT33
SSD_PCIE_WAKE#: JNGFF2.54 RD8.1 RD59.1
SSD_PWR_EN: RZ74.1 RZ75.1 UH2.M44
STRAP0: RV308.1 RV316.2 UV1.J2
STRAP1: RV307.1 RV315.2 UV1.J7
STRAP2: RV306.1 RV314.2 UV1.J6
STRAP3: RV302.1 RV310.2 UV1.J5
STRAP4: RV301.1 RV309.2 UV1.J3
SUS_ON: RE39.2 UE3.A9
SUS_ON_EC: RE30.1 RE38.1 RE39.1 RT240.1 UZ22.1
SUS_ON_EC_P: PR606.1 RZ87.1 RZ91.1 UZ10.3 UZ18.1 UZ22.4 UZ23.1
SUS_ON_EC_ST: RZ88.1 RZ91.2 UZ15.4 UZ23.4
SUS_ON_P: RZ72.1 RZ80.1 UZ18.4
SUSACK#: UE3.B7 UH2.BB19
SUSCLK: RD9.2 RN1.2 UH2.AN15
SUSCLK_R: JNGFF1.42 RN1.1
SW_1.2V: PC600.1 PL600.2 PQ600.1 PQ600.2 PQ600.3 PQ601.5 PR602.1 PU600.16
SW_+1.35VRUN: PL700.1 PR702.2 PR703.1 PU700.6 PU700.7 PU700.8 PU700.9
SYS_PEX_RST_MON#: DV8.2 RV50.2 RV187.1 RV208.1 UV1.L3 UV14.4
SYS_RESET#: JAPS.13 RH8.2 RH571.1 UH2.AW1
TB_HDMI_HPLUG: QV14.3 RV122.1 UT1.G1
TBT_BATLOW#: RT25.2 UT1.F2
TBT_CIO_PLUG_EVENT#: RT23.2 UH2.U41 UT1.W2
TBT_CLK_REQ#: RP2.7 RT21.2 UH2.BE25 UT1.AC5
TBT_DDC_CLK: QX1.1 RT33.2 UT1.Y2
TBT_DDC_DATA: QX1.4 RT34.2 UT1.Y1
TBT_FORCE_PWR: RT38.2 UH2.P43 UT1.H4
TBT_I2C_CLK: RT36.2 UT1.U2 UT4.D2
TBT_I2C_DATA: RT35.2 UT1.U1 UT4.D1
TBT_JTAG_TCK: RT7.2 T198.1(TP-1) UT1.T4
TBT_JTAG_TDI: RT9.2 T196.1(TP-1) UT1.Y4
TBT_JTAG_TDO: RT6.2 T199.1(TP-1) UT1.W4
TBT_JTAG_TMS: RT8.2 T197.1(TP-1) UT1.V4
TBT_LSRX: RT45.2 RT232.1 UT1.A4 UT4.K4
TBT_LSTX: RT44.2 RT233.1 UT1.A5 UT4.L4
TBT_ML0_N: CV172.2 UT1.R1
TBT_ML0_P: CV173.2 UT1.R2
TBT_ML1_N: CV174.2 UT1.N1
TBT_ML1_P: CV175.2 UT1.N2
TBT_ML2_N: CV176.2 UT1.L1
TBT_ML2_P: CV177.2 UT1.L2
TBT_ML3_N: CV170.2 UT1.J1
TBT_ML3_P: CV171.2 UT1.J2
TBT_PCIE_WAKE#: RE120.1 RT22.2 UT1.W1
TBT_POC_RST#: DT29.2 RT202.2 RT244.2 UT1.F4
TBT_PWR_EN: RH556.2 UH2.AU43
TBT_RBIAS: RT10.1 UT1.H6
TBT_ROM_CLK: RT231.1 UT1.AB4 UT2.6
TBT_ROM_CLK_R: RT210.1 RT231.2
TBT_ROM_CS#: RT18.2 RT230.1 UT1.AC3 UT2.1
TBT_ROM_CS#_R: RT213.1 RT230.2
TBT_ROM_DI: RT228.1 UT1.AB3 UT2.5
TBT_ROM_DI_R: RT211.1 RT228.2
TBT_ROM_DO: RT16.2 RT229.1 UT1.AC4 UT2.2
TBT_ROM_DO_R: RT212.1 RT229.2
TBT_ROM_HOLD#: RT15.2 UT2.7
TBT_ROM_WP#: RT17.2 UT1.V1 UT2.3
TBT_RSENSE: RT10.2 UT1.J6
TBT_SRC_CFG1: RT107.2 UT1.AA1
TBT_SVR_IND: LT1.1 UT1.C1 UT1.C2 UT1.D1
TBT_TEST_EN: RT3.2 UT1.E1
TBT_TEST_PWRG: RT4.2 UT1.AB5
TBT_TMU_CLK_OUT: RT37.2 UT1.V2
TBT_USB2_D+: UT1.E20 UT4.L5
TBT_USB2_D-: UT1.D20 UT4.K5
TBT_USB3_RX0_N: DT21.1 JUSBC1.B10 UT1.A21
TBT_USB3_RX0_P: DT20.1 JUSBC1.B11 UT1.B21
TBT_USB3_RX1_N: DT18.1 JUSBC1.A10 UT1.B15
TBT_USB3_RX1_P: DT19.1 JUSBC1.A11 UT1.A15
TBT_USB3_TX0_N: CT40.2 DT13.1 JUSBC1.A3
TBT_USB3_TX0_N_C: CT40.1 UT1.B19
TBT_USB3_TX0_P: CT39.2 DT12.1 JUSBC1.A2
TBT_USB3_TX0_P_C: CT39.1 UT1.A19
TBT_USB3_TX1_N: CT38.2 DT26.1 JUSBC1.B3
TBT_USB3_TX1_N_C: CT38.1 UT1.B17
TBT_USB3_TX1_P: CT37.2 DT27.1 JUSBC1.B2
TBT_USB3_TX1_P_C: CT37.1 UT1.A17
TBTA_AUX_N: CT42.2 UT4.J2
TBTA_AUX_N_C: CT42.1 UT1.W15
TBTA_AUX_P: CT41.2 UT4.J1
TBTA_AUX_P_C: CT41.1 UT1.Y15
TBTA_CC1: CT160.1 DT14.1 JUSBC1.A5 UT4.K9 UT4.L9
TBTA_CC2: CT159.1 DT25.1 JUSBC1.B5 UT4.K10 UT4.L10
TBTA_DEBUG1: RT184.2 UT4.L2
TBTA_DEBUG2: RT185.2 UT4.K2
TBTA_DEBUG3_LSTX: RT187.2 RT233.2 UT4.L3
TBTA_DEBUG4_LSRX: RT188.2 RT232.2 UT4.K3
TBTA_HPD: RT43.2 RT181.2 UT1.M4
TBTA_I2C_C_N: DT23.1 JUSBC1.B7 LT13.3
TBTA_I2C_C_P: DT24.1 JUSBC1.B6 LT13.2
TBTA_I2C_D_N: LT13.4 UT4.L7
TBTA_I2C_D_P: LT13.1 UT4.K7
TBTA_I2C_INT#: RT167.2 UT1.J4 UT4.C1
TBTA_LDO_BMC: CT144.1 UT4.E1
TBTA_PD_SBU1: RT176.1 UT4.K8
TBTA_PD_SBU2: RT177.1 UT4.L8
TBTA_RESET_N: DT29.1 UT4.F11
TBTA_SBU1: DT17.1 JUSBC1.A8 RT176.2
TBTA_SBU2: DT22.1 JUSBC1.B8 RT177.2
TBTA_USB2_D_N_C: DT16.1 JUSBC1.A7 LT12.2
TBTA_USB2_D_N_R: LT12.1 UT4.L6
TBTA_USB2_D_P_C: DT15.1 JUSBC1.A6 LT12.3
TBTA_USB2_D_P_R: LT12.4 UT4.K6
TBTA_VBUS_L: CT157.1 LT11.1 UT4.H11 UT4.J10 UT4.J11 UT4.K11
THERMAL_ALERT#: RPH34.3 UV1.M2
THERMATRIP2#: CE52.1 QE10.1 RE66.2 UE3.B34
THERMATRIP3#: QV88.1 RE25.1 UE3.A2
THERMATRIP_GPU#: QV88.3 RPH34.1 UV1.M1
THERMDA: UT1.AB23 UT1.AC23
THSEL_STRAP: RE57.1 UE3.B29
TMDS_L_TX0N: DV5.5 DV5.6 JHDMI1.3 RV532.2 RV539.1
TMDS_L_TX0P: DV5.4 DV5.7 JHDMI1.1 RV533.2 RV539.2
TMDS_L_TX1N: DV5.2 DV5.8 JHDMI1.6 RV534.2 RV540.1
TMDS_L_TX1P: DV5.1 DV5.9 JHDMI1.4 RV535.2 RV540.2
TMDS_L_TX2N: DV4.4 DV4.7 JHDMI1.9 RV536.2 RV541.1
TMDS_L_TX2P: DV4.5 DV4.6 JHDMI1.7 RV537.2 RV541.2
TMDS_L_TXCN: DV4.1 DV4.9 JHDMI1.12 RV530.2 RV538.1
TMDS_L_TXCP: DV4.2 DV4.8 JHDMI1.10 RV531.2 RV538.2
TMDS_TX0N: CV172.1 RV517.1 RV532.1
TMDS_TX0P: CV173.1 RV516.1 RV533.1
TMDS_TX1N: CV174.1 RV515.1 RV534.1
TMDS_TX1P: CV175.1 RV514.1 RV535.1
TMDS_TX2N: CV176.1 RV513.1 RV536.1
TMDS_TX2P: CV177.1 RV512.1 RV537.1
TMDS_TXCN: CV170.1 RV519.1 RV530.1
TMDS_TXCP: CV171.1 RV518.1 RV531.1
TOUCH_SCREEN_PD#: DI1.1 RH510.1 UH2.AE44
TOUCHPAD_INTR#: DH1.2 RH547.1 UH2.BC23
TP_PW_EN: RZ32.2 UE4.24 UE6.3
TPM_GPIO4: RE126.2 RE134.2 UE1.13
TPM_LPM#: QE17.1 RE127.1 UE1.3
TPM_PIRQ#: RE86.2 UE1.18 UH2.AN38
TPM_VDD: CE75.1 CE76.1 RE128.2 RE129.2 UE1.8
U2_BOOT1: PR1007.1 PU1000.1
U2_BOOT2: PR1019.1 PU1000.18
U2_BOOT3: PR1026.1 PU1001.4
U2_LGATE1: PQ1000.4 PR1011.2 PU1000.23
U2_LGATE2: PQ1001.4 PU1000.20
U2_LGATE3: PQ1002.4 PU1001.7
U2_PHASE1: PC1010.2 PQ1000.3 PR1023.1 PU1000.24
U2_PHASE2: PC1047.2 PQ1001.3 PR1022.1 PU1000.19
U2_PHASE3: PC1067.2 PQ1002.3 PR1020.1 PU1001.2
U2_PWM3: PU1000.22 PU1001.5
U2_UGATE1: PQ1000.2 PU1000.2
U2_UGATE2: PQ1001.2 PU1000.17
U2_UGATE3: PQ1002.2 PU1001.3
UART2_RXD: JUART.3 RH562.2 UH2.AR45
UART2_TXD: JUART.2 RH561.2 UH2.AR39
UARTT0_TX: JDEG1.9 UH2.AV44
UG_3V: PQ400.4 PU400.10
UG_5V: PQ401.4 PU400.16
UPD_GPU_SMBCLK: QE18.3 QT1.4 QV21.6 RE95.1 RT201.1 UE3.B49
UPD_GPU_SMBDAT: QE18.6 QT1.1 QV21.3 RE94.1 RT200.1 UE3.B48
UPD_MRESET: RT244.1 RT245.2 RZ41.1 UE3.A4
UPD_SMBCLK: QT1.3 RT192.2 RT201.2 UT4.B5
UPD_SMBDAT: QT1.6 RT193.2 RT200.2 UT4.A5
USB3RN1: CI8.1 UH2.B7
USB3RN1_C: CI8.2 UI3.23
USB3RN1_D-: DI9.1 DI9.9 JUSB2.5 RI40.2
USB3RN1_RE: RI40.1 UI3.8
USB3RN2: RI44.1 UH2.C8
USB3RN2_D-: DI7.1 DI7.9 JUSB1.5 RI44.2
USB3RP1: CI7.1 UH2.A7
USB3RP1_C: CI7.2 UI3.22
USB3RP1_D+: DI9.2 DI9.8 JUSB2.6 RI39.2
USB3RP1_RE: RI39.1 UI3.9
USB3RP2: RI43.1 UH2.B8
USB3RP2_D+: DI7.2 DI7.8 JUSB1.6 RI43.2
USB3T_N1: CI16.2 RI37.1
USB3T_N2: CI9.2 RI41.1
USB3T_P1: CI20.2 RI38.1
USB3T_P2: CI10.2 RI42.1
USB3TN1: CI6.1 UH2.C11
USB3TN1_C: CI6.2 UI3.20
USB3TN1_D-: DI9.4 DI9.7 JUSB2.8 RI37.2
USB3TN1_RE: CI16.1 UI3.11
USB3TN2: CI9.1 UH2.B12
USB3TN2_D-: DI7.4 DI7.7 JUSB1.8 RI41.2
USB3TP1: CI5.1 UH2.B11
USB3TP1_C: CI5.2 UI3.19
USB3TP1_D+: DI9.5 DI9.6 JUSB2.9 RI38.2
USB3TP1_RE: CI20.1 UI3.12
USB3TP2: CI10.1 UH2.A12
USB3TP2_D+: DI7.5 DI7.6 JUSB1.9 RI42.2
USB20_N1: UH2.AF5 UI2.2
USB20_N2: UH2.AD5 UI1.2
USB20_N4: LN1.1 UH2.AE1
USB20_N4_R: JNGFF1.5 LN1.2
USB20_N9: LI1.1 UH2.AA1
USB20_N9_R: DI3.2 JTS.4 LI1.2
USB20_N12: LV22.1 UH2.AD3
USB20_N12_R: DV12.3 JEDP1.31 LV22.2
USB20_P1: UH2.AG7 UI2.3
USB20_P2: UH2.AD7 UI1.3
USB20_P4: LN1.4 UH2.AE2
USB20_P4_R: JNGFF1.3 LN1.3
USB20_P9: LI1.4 UH2.AA2
USB20_P9_R: DI3.3 JTS.5 LI1.3
USB20_P12: LV22.4 UH2.AD2
USB20_P12_R: DV12.1 JEDP1.32 LV22.3
USB8723_TEST: RI24.1 UI3.14
USB_DET#_L: CE71.1 JUSB1.10 RE89.2
USB_DET#_R: CE37.1 JUSB2.10 RE54.2
USB_DET_EC#_L: CE70.1 RE89.1 RE90.2 UE3.B68
USB_DET_EC#_R: CE38.1 RE50.2 RE54.1 UE3.B63
USB_ILIM_SEL: DI12.1 RI35.1 UE4.3
USB_L_CTL: RI4.2 UI1.7 UI1.8
USB_OC0#: RH552.1 UH2.AD43 UI2.13
USB_OC1#: RH553.1 UH2.AD42 UI1.13
USB_OC2#: RH554.1 UH2.AD39
USB_OC3#: RH555.1 UH2.AC44
USB_OC4#: RP8.3 UH2.Y43
USB_OC5#: RP8.4 UH2.Y41
USB_OC6#: RP8.2 UH2.W44
USB_OC7#: RP8.1 UH2.W43
USB_PWR_EN: RH544.1 UH2.BC19 UI4.1 UI5.1
USB_PWR_EN_L: RI26.1 UI1.5 UI4.4
USB_PWR_EN_R: RI27.1 RI28.2 UI2.5 UI5.4
USB_PWR_SHR_EN_L#: RI5.2 UE3.A55 UI1.6
USB_PWR_SHR_EN_R#: RI10.2 UE4.19 UI2.6
USB_PWR_SHR_VBUS_EN_L: RI8.2 UE4.17 UI4.2
USB_PWR_SHR_VBUS_EN_R: DI11.1 RI13.2 RI28.1 UE4.18 UI5.2
USB_R_CTL: RI9.2 UI2.7 UI2.8
USB_STATUS#_L: RI32.2 UI1.9
USB_STATUS#_R: RI33.2 UI2.9
USBC_MCP23017_SMBCLK: RE21.1 RE109.2 UE3.B4 UE4.8
USBC_MCP23017_SMBDAT: RE20.1 RE108.2 UE3.A3 UE4.9
USBP1_D+: LI2.4 UI2.10
USBP1_D-: LI2.1 UI2.11
USBP1_R_D+: DI10.2 JUSB2.3 LI2.3
USBP1_R_D-: DI10.3 JUSB2.2 LI2.2
USBP2_D+: LI5.4 UI1.10
USBP2_D-: LI5.1 UI1.11
USBP2_R_D+: DI8.2 JUSB1.3 LI5.3
USBP2_R_D-: DI8.3 JUSB1.2 LI5.2
VCORE_B+: PC1210.1 PC1211.1 PC1212.1 PC1213.1 PC1214.1 PC1235.1 PC1236.1 PC1237.1 PC1238.1 PC1251.1 PC1252.1 PC1253.1 PC1254.1 PC1256.1 PC1277.1 PJP1200.2 PL1203.2 PL1204.2 PR1102.1 PU1200.6 PU1200.11 PU1201.6 PU1201.11 PU1202.6 PU1202.11
VGA_CLK_REQ#: QV39.1 RH551.2 UH2.AR31
VGA_ID: RE112.1 UE3.A10
VR_ON: PR1118.1 RZ60.2 RZ71.1 UZ12.4
VR_SVID_ALERT#: PR1132.1 RH152.2 RH153.1
VR_SVID_ALERT#_C: PR1132.2 PU1100.44
VR_SVID_ALERT#_R: RH153.2 UH1.BH31
VR_SVID_CLK: PR1131.2 PR1319.1 UH1.BH32
VR_SVID_CLK_C: PR1319.2 PU1100.45
VR_SVID_DATA: PR1145.2 PR1318.1 RH151.2 UH1.BH29
VR_SVID_DATA_C: PR1318.2 PU1100.43
VSB_N_001: PC111.2 PQ1301.4 PR107.2 PR110.2
VSB_N_002: PC113.1 PQ103.2 PR113.2
VSB_N_003: PQ103.1 PR110.1
VSET: RZ52.1 RZ54.2 UZ10.4
VSET_5085: CE41.1 RE58.1 UE3.A17
WLAN_CLK_REQ#: JNGFF1.45 RP2.5 UH2.BD25
WLAN_WIGIG60GHZ_DIS#: DN1.1 RE71.2 UE4.22
WLAN_WIGIG60GHZ_DIS#_R: DN1.2 JNGFF1.48
XDP_BPM#0: JXDP.21 UH1.BR27
XDP_BPM#1: JXDP.23 UH1.BT27
XDP_DBRESET#: CH175.1 JXDP.48 RH5.2 RH8.1
XDP_PLTRST#: JXDP.46 RH479.2 RH480.2 RH492.2
XDP_PRDY#: JXDP.5 UH1.BP27 UH2.AT4
XDP_PREQ#: JXDP.3 RH156.2 UH1.BL30 UH2.AT3
XDP_PWRGOOD: JXDP.39 RH481.2 RH482.2
XDP_TDI: JXDP.56 RH477.1 RH541.1
XDP_TDO: JXDP.52 RH478.1 RH540.1
XDP_TMS: JXDP.58 RH12.1 RH542.1
XDP_TRST#: JXDP.54 RH543.1
XTAL24_IN: CH47.1 RH72.1 UH2.A6 YH2.1
XTAL24_OUT: CH48.1 RH72.2 UH2.A5 YH2.3
XTAL_25_IN: CT43.1 UT1.D22 YT1.1
XTAL_25_OUT: CT44.1 UT1.D23 YT1.3
XTALOUTBUFF: RPH32.1 UV1.J4
XTALSSIN: RPH32.2 UV1.H1
N48197: PC1103.2 PR1104.2 PU1100.2
N48329: PC1104.2 PR1111.2 PU1100.4
N48371: PC1105.2 PR1111.1
N48789: PC1114.1 PR1129.1 PU1100.28
N48933: PC1117.1 PR1126.2
N48941: PC1115.1 PR1126.1 PU1100.29
N48965: PC1116.1 PR1124.2
N48979: PR1124.1 PR1125.1 PR1128.1 PU1100.30
N49205: PC1113.2 PR1130.2 PU1100.8
N49217: PC1113.1 PR1127.2
N49289: PC1139.2 PR1105.2 PU1100.3
N49471: PC1108.1 PR1117.2
N49551: PC1108.2 PR1115.1 PU1100.33
N49667: PR1103.2 PU1100.46
N49815: PR1116.1 PU1100.36
N50153: PC1101.1 PR1101.2 PU1100.42
N50385: PC1129.1 PR1137.1 PU1100.14
N50425: PH1104.2 PR1138.2 PR1144.1
N50433: PR1144.2 PU1100.15
N50477: PR1110.1 PU1100.40
N50505: PR1109.1 PU1100.39
N50517: PR1108.1 PU1100.38
N50567: PR1107.1 PU1100.37
N50631: PC1134.2 PR1141.2
N50639: PC1131.1 PR1141.1 PU1100.16
N50651: PC1132.1 PR1139.2
N50739: PR1139.1 PR1140.1 PR1142.2 PU1100.17
N51003: PC1128.1 PR1133.1 PU1100.20
N51011: PC1128.2 PR1135.1
N57527: PR1209.1 PR1210.1 PR1222.2
N3514407: PR405.2 PU400.5
N3514423: PC400.1 PR400.2 PU400.3
N3514453: PC419.1 PU400.13
N13272409: PC800.1 PR800.1 PR801.1 PU800.1
N13272413: PC807.2 PR804.1 PR806.1 PU800.4
N13272497: PC813.1 PU800.5
N13272521: PC805.1 PR803.2
N13347359: PR1114.2 PR1119.2 PU1100.47
N13351923: PC1102.1 PR1102.2 PU1100.41
N13352071: PR1118.2 PU1100.48
N13353452: PR1112.2 PR1113.2 PR1143.1 PU1100.5
N17034077: PR406.1 PU400.1
N17034092: PC418.1 PR415.1 PU400.12
N17198654: RV479.1 UV1.AG10
N17832487: RV352.2 UV5.J1
N17860472: RV354.2 UV5.J13
N17888940: RV327.1 UV1.J27
N17889477: RV328.1 UV1.H27
N17890015: RV329.1 UV1.H25
N17929472: RV330.1 UV1.F2
N17930576: RV332.1 UV1.F1
N18066258: QV22.1 RV357.2 RV359.2
N18135138: RV346.2 UV1.G14
N18135149: RV347.2 UV1.G20
N19849916: PC713.2 PR703.2
N19912586: PL1001.1 PQ1001.5 PQ1001.6 PQ1001.7 PR1021.1
N20180024: PC1029.1 PR1009.2 PR1010.1
N20194225: PC1009.1 PR1002.2 PR1003.2 PR1004.1
N25669355: RV365.2 UV6.J13
N25669840: RV363.2 UV6.J1
N35393149: RV290.1 UV1.AP29
N48708347: PC600.2 PR600.1
N48708367: PC614.1 PR608.2 PR610.1 PU600.7
N48708425: PR605.2 PU600.9
N49570867: PC500.1 PR500.1 PR501.1 PU500.1
N49570895: PC507.2 PR504.2 PR508.1 PU500.4
N49571010: PC512.1 PU500.5
N49571039: PC505.1 PR503.2
N50817763: PC333.2 PR320.1 PU300.17
N50817876: PR311.2 PR312.2 PR316.1 PU300.5
N50817886: PC327.1 PR314.2 PU300.7
N50817889: PC328.1 PR317.2 PU300.8
N50817917: PR315.2 PU300.10
N50817928: PC313.2 PC314.1 PR302.2 PU300.1
N50817929: PR321.2 PR323.1 PU300.16
N50817930: PC311.2 PC313.1 PR301.2 PU300.2
N50817943: PC330.2 PC331.1 PR310.2 PU300.20
N50817947: PC331.2 PC332.1 PR310.3 PU300.19
N50817961: PR322.2 PU300.15
N50817990: PR319.1 PU300.18
N52699143: PC329.1 PR313.1
N52999986: PL104.2 PQ100.1 PR100.1 PR103.1
N55155823: CV168.2 QV11.3 RV119.2 RV120.1
N55155843: QV12.1 RV120.2
N55341619: RV391.2 UV10.J13
N55342064: RV389.2 UV10.J1
N55351739: RV378.2 UV9.J1
N55351833: RV380.2 UV9.J13
N55360027: RV344.2 UV1.R28
N107416912: RV501.2 UV1.E1
N108873638: PR409.1 PU400.20
N109801960: QZ6.2 QZ6.3 RZ12.2
N109970739: PR410.1 PU400.19
N110700740: PC1036.1 PR1016.2
N110703687: PC1025.1 PR1008.2
N110833422: PL1000.1 PQ1000.5 PQ1000.6 PQ1000.7 PR1008.1
N110836828: PC1068.1 PR1027.2
N110836908: PL1002.1 PQ1002.5 PQ1002.6 PQ1002.7 PR1027.1
N110935541: PC1010.1 PR1007.2
N110936515: PC1047.1 PR1019.2
N110936719: PC1045.1 PR1018.2
N110936976: PC1067.1 PR1026.2
N111036757: PR1020.2 PU1000.13
N111036762: PR1022.2 PU1000.14
N111036767: PR1023.2 PU1000.15
N111069434: PR700.2 PR701.2 PU700.25
N111120800: PC701.2 PU700.21
N111796536: RZ13.1 UZ1.13 UZ1.14
N111796622: RZ15.1 UZ1.8 UZ1.9
N111798152: CZ4.1 UZ1.12
N111798158: CZ6.1 UZ1.10
N113626745: QV23.1 RV370.2 RV372.2
N113637608: QV24.1 RV383.2 RV385.2
N113676531: QV25.1 RV396.2 RV398.2
N113699173: RV345.2 UV1.AC28
N116140097: JEDP1.36 RV110.2
N116494866: PC709.2 PR702.1
N116496514: PC1055.1 PR1021.2
N118983880: PR318.1 PU300.21
N119009545: PQ205.1 PR203.2
N119009632: PC200.2 PQ200.4 PR201.2 PR205.1
N119009672: PC220.2 PQ201.4 PQ204.1 PR200.2 PR203.1
N119186848: RI23.1 UI3.7
N119186852: RI36.1 UI3.5
N119942216: ADP100.5 ADP100.6 ADP100.7 PC106.1 PL105.1 PL106.1
N119944306: PR303.2 PU300.3
N119944438: PC319.1 PR304.2 PU300.28
N119944456: PC322.2 PQ304.1 PR305.1 PR308.1 PU300.6
N119964762: PQ205.2 PR209.2
N119965248: PC222.1 PQ213.1 PQ213.2 PQ213.3 PQ217.3 PR216.4 PR223.1 PR224.1
N119965252: PQ220.1 PR232.2
N119965290: PC222.2 PC289.2 PQ213.4 PQ217.1 PR224.2 PR226.1
N119967293: PQ219.1 PR226.2
N119982519: PC208.2 PC288.2 PQ212.4 PR222.2 PR227.2 PR232.1
N120139517: RH71.2 UH2.E1
N120174690: T20.1(TP-1) UH2.AV15
N120176772: T2.1(TP-1) UH2.V44
N120176782: T4.1(TP-1) UH2.L43
N120176822: T8.1(TP-1) UH2.BD36
N120177456: T17.1(TP-1) UH2.BD17
N120264964: RT1.1 UT1.N16
N120290495: RT2.1 UT1.N6
N120293690: QV13.2 RV121.2
N120361079: JNGFF2.60 RD9.1
N120361841: RZ18.1 UZ4.7 UZ4.8
N120361881: CZ20.1 UZ4.6
N120533764: RE76.2 UE4.14
N120533798: RE75.2 UE4.13
N120533808: RE74.2 UE4.12
N120533818: RE73.2 UE4.11
N120553340: RE43.1 RE44.1 UE3.A59
N120553518: RE111.1 UE3.B52
N120553639: RE55.1 UE3.B61
N120554151: QE10.2 RE69.2
N120554627: CE48.1 RE62.2
N120918225: PD303.1 PD304.1 PR303.1 PR305.2 PR399.1
N120970730: PC1209.1 PR1200.2
N120971346: PC1234.1 PR1204.2
N120971480: PC1255.1 PR1208.2
N120976432: PL1202.1 PR1208.1 PR1222.1 PU1202.8
N120977691: PL1201.1 PR1204.1 PR1220.1 PU1201.8
N121029055: RH108.1 UH2.B18
N121029061: RH108.2 UH2.C17
N121033373: PR408.2 PU400.6
N121033408: PR407.2 PR428.2 PU400.7
N121070696: RH109.1 UH2.AG3
N121070776: RH24.2 UH1.G2
N121163993: RH150.2 UH1.J2
N121163994: RH149.2 UH1.H1
N121163995: RH148.2 UH1.G1
N121174975: RH168.1 UH2.BC17
N121388945: RH189.1 UH2.AJ4
N121479122: RH465.1 RH466.1 UH1.AG38
N121480352: RH469.1 RH470.1 UH1.M37
N121480355: RH201.1 RH202.1 UH1.M38
N121480375: RH473.2 UH1.Y12
N121507165: RH57.2 UH1.BR25
N121507167: RH58.2 UH1.BP25
N121507169: RH166.2 UH1.BT29
N121616264: RE93.1 UE6.7 UE6.8
N121616283: CE65.1 UE6.6
N121617744: CZ37.1 UZ7.12
N121617748: CZ39.1 UZ7.10
N121617759: RZ34.1 UZ7.13 UZ7.14
N121617766: RZ36.1 UZ7.8 UZ7.9
N121673930: PC1106.2 PR1112.1
N121674134: PC1130.1 PR1140.2
N121674335: PC1118.1 PR1125.2
N121710332: RH197.2 RH198.1 UH1.AG37
N121712022: RH203.2 RH204.1 UH1.AH38
N121718437: DE7.1 JFAN1.3 RE82.2
N121718548: DE8.1 JFAN2.3 RE84.2
N121775507: PR324.2 PR325.1 PU300.9
N121795600: PL1200.1 PR1200.1 PR1218.1 PU1200.8
N121865189: PQ219.2 PR267.2
N121865231: PQ232.2 PR235.2
N121981266: PH1100.2 PR1105.1 PR1106.2
N121981305: PH1102.1 PR1122.2
N121981509: PH1101.2 PR1121.1
N121981539: PH1103.2 PR1136.1
N121983108: PR1025.2 PU1001.1
N121994793: PC900.1 PR900.1 PR901.1 PR913.1 PU900.1
N121994795: PC907.2 PR904.2 PR906.1 PU900.4
N121994837: PC912.1 PU900.5
N121994849: PC906.1 PR903.2
N122017154: PC1201.2 PU1200.5
N122018016: PC1228.2 PU1201.5
N122018494: PC1250.2 PU1202.5
N122282431: RR9.1 UR1.28
N122314333: RH471.1 RH472.1 UH1.AH37
N122397475: RH145.1 UH1.G29
N122409296: RE13.1 RE14.2 UE1.4
N122409328: RE77.2 UE1.28
N122409465: RE114.2 UE1.21
N122409468: RE113.2 UE1.24
N122409512: RE85.2 UE1.27
N122409618: CE8.1 RE11.2
N122463812: JXDP.1 RH474.1 RH475.1
N122476680: PR1201.1 PR1202.1 PR1218.2
N122477585: PR1205.1 PR1206.1 PR1220.2
N122517438: RH536.2 SW4.1
N122528028: QF1.5 QF1.6 RF3.2
N122536166: PC202.2 PC203.2 PC204.2 PL202.1 PL203.1
N122563835: RH519.2 UH1.BR33
N122630698: D122.1 RH67.1
N122638318: RH428.1 UH2.AV19
N122687725: RZ58.1 RZ85.1 UZ11.1 UZ20.4
N122698769: T49.1(TP-1) UH1.BL34
N122698770: T39.1(TP-1) UH1.D1
N122698771: T44.1(TP-1) UH1.BT2
N122698772: T42.1(TP-1) UH1.E2
N122698773: T51.1(TP-1) UH1.R14
N122698774: T47.1(TP-1) UH1.H24
N122698775: T45.1(TP-1) UH1.BN35
N122698776: T50.1(TP-1) UH1.N29
N122698777: T53.1(TP-1) UH1.AA14
N122698778: T40.1(TP-1) UH1.E1
N122698779: T43.1(TP-1) UH1.BR1
N122698780: T41.1(TP-1) UH1.E3
N122698781: T48.1(TP-1) UH1.BN33
N122698782: T52.1(TP-1) UH1.AE29
N122698783: T46.1(TP-1) UH1.J24
N122698814: T58.1(TP-1) UH1.E30
N122698815: T63.1(TP-1) UH1.BR35
N122698816: T65.1(TP-1) UH1.BH30
N122698817: T62.1(TP-1) UH1.J3
N122698818: T59.1(TP-1) UH1.B30
N122698819: T64.1(TP-1) UH1.BR31
N122698820: T61.1(TP-1) UH1.G3
N122698821: T57.1(TP-1) UH1.F30
N122698822: T60.1(TP-1) UH1.C30
N122698841: T82.1(TP-1) UH1.BJ33
N122698842: T90.1(TP-1) UH1.C38
N122698843: T85.1(TP-1) UH1.B2
N122698844: T83.1(TP-1) UH1.G13
N122698845: T88.1(TP-1) UH1.BR2
N122698846: T81.1(TP-1) UH1.BJ34
N122698847: T86.1(TP-1) UH1.B38
N122698848: T89.1(TP-1) UH1.C1
N122698849: T84.1(TP-1) UH1.AJ8
N122698850: T87.1(TP-1) UH1.BP1
N122698871: T77.1(TP-1) UH1.BK21
N122698872: T73.1(TP-1) UH1.BJ16
N122698873: T74.1(TP-1) UH1.BK16
N122698874: T80.1(TP-1) UH1.BR17
N122698875: T75.1(TP-1) UH1.BK24
N122698876: T78.1(TP-1) UH1.BJ21
N122698877: T76.1(TP-1) UH1.BJ24
N122698878: T79.1(TP-1) UH1.BT17
N122698895: T66.1(TP-1) UH1.BM33
N122698896: T68.1(TP-1) UH1.BJ14
N122698897: T71.1(TP-1) UH1.BJ28
N122698898: T69.1(TP-1) UH1.BJ13
N122698899: T67.1(TP-1) UH1.BL33
N122698900: T70.1(TP-1) UH1.BK28
N122706757: PR806.2 PR809.1 PR810.2
N122715521: PQ206.1 PR206.2
N122716785: PQ216.2 PR220.2 PR229.1
N122717029: PQ216.1 PR227.1
N122717226: PQ204.2 PR202.2 PR206.1
N122717329: PQ219.3 PQ232.1
N122717720: PQ222.1 PR230.2
N122717744: PQ217.2 PR223.2 PR230.1
N122719403: PQ218.1 PR225.2
N122719762: PC221.2 PQ214.4 PR219.2 PR225.1
N122728389: PC207.2 PD207.1 PQ202.4 PQ203.4 PR204.2 PR210.1
N122728402: PQ207.3 PQ210.1
N122729223: PC207.1 PQ202.1 PQ202.2 PQ202.3 PQ203.1 PQ203.2 PQ203.3 PR204.1
N122733349: PC214.2 PR259.1 PR261.2 PR263.1 PU202.5
N122733365: PR257.1 PR264.2 PU202.6
N122733968: PQ228.1 PR253.1
N122734450: PC215.2 PR258.1 PR260.2 PR273.1 PU202.3
N122734452: PR254.1 PR265.2 PU202.2
N122739033: RZ59.2 UZ11.2
N122739099: RZ60.1 RZ86.1 UZ12.1 UZ21.4
N122739340: RZ61.2 UZ12.2
N122753661: PQ206.2 PR268.2
N122754331: RZ67.1 UZ16.7 UZ16.8
N122754354: CZ57.1 UZ16.6
N122755391: CZ82.1 RZ48.2 UZ9.6
N122762967: RZ69.1 UZ17.7 UZ17.8
N122763041: CZ95.1 UZ17.6
N122772225: PQ208.1 PR205.2
N122772428: PQ208.2 PQ211.1 PR213.2 PR217.1
N122774125: PR804.2 PR808.1 PR813.2
N122777610: PQ222.2 PR228.2
N122777613: PQ223.2 PR231.2
N122912247: CZ28.1 RZ66.1 UZ15.6
N123037911: QV86.1 RV511.1
N123346527: QV13.1 RV512.2 RV513.2 RV514.2 RV515.2 RV516.2 RV517.2 RV518.2 RV519.2
N123360127: RT12.1 UT1.H19
N123360144: RT5.1 UT1.Y18
N123628000: DI1.2 JTS.2
N123760602: PQ225.1 PR271.1 PR272.1 PU203.4
N123974826: PQ218.2 PR290.2 PR291.2
N123983992: PL1301.1 PR1307.1 PR1314.1 PU1301.8
N123984002: PR1305.1 PR1306.1 PR1314.2
N123984012: PC1355.1 PC1356.1 PC1357.1 PC1358.1 PJP1301.1 PL1305.2 PQ1300.2 PQ1300.3 PQ1300.4 PQ1300.10
N123984055: PR1311.1 PU1302.2
N123984061: PC1313.1 PL1306.1 PQ1300.9 PR1308.1 PR1316.1 PU1302.8
N123984063: PQ1300.1 PU1302.1
N123984071: PC1313.2 PR1311.2
N123984081: PR1301.1 PR1303.1 PR1312.2
N123984101: PC1337.2 PU1301.5
N123984161: PC1365.1 PR1308.2
N123984183: PL1300.1 PR1300.1 PR1312.1 PU1300.8
N123984193: PC1308.2 PU1300.5
N123984213: PR1304.1 PR1315.2
N123984277: PR1310.1 PR1317.2
N123984281: PR1309.1 PR1316.2
N123984351: PQ1300.8 PU1302.5
N123984423: PC1347.1 PR1307.2
N123984459: PC1318.1 PR1300.2
N123985122: PR1302.2 PR1313.2
N124073057: DI11.2 RI36.2
N124199479: PR705.2 PU700.28
N124211085: RT164.2 UT1.F19
N124411322: PD204.1 PQ209.2 PR292.1
N124417517: PR238.2 PR256.2 PU201.2
N124417993: PQ207.2 PR212.1 PR299.1
N124420412: PR21.1 PR207.2 PR215.3
N124420521: PR233.2 PU200.6
N124420534: PR21.2 PR211.2 PR215.2
N124420538: PR207.1 PU200.4
N124425215: PQ207.1 PR210.2
N124426141: PR216.2 PR218.1
N124426143: PR216.3 PR221.1
N124428383: PQ223.1 PR229.2
N124494273: RT181.1 UT4.C10
N124494860: CT158.1 UT4.H7
N124494892: RT191.1 UT4.G2
N124539520: RT183.1 UT4.H6
N124539694: T187.1(TP-1) UT4.G11
N124539765: RT182.1 UT4.D7
N124539944: UT4.E2 UT4.F2
N124607348: QV89.1 RT195.1
N124695542: PQ215.2 PR237.1 PR244.2
N124695548: PD207.2 PQ215.1
N124695638: PQ209.1 PR237.2
N124696815: PD204.3 PR266.2
N124699186: PQ210.2 PQ234.1 PR214.1 PR269.1 PR274.1
N124730498: RT178.1 UT4.C2
N124730527: T185.1(TP-1) UT4.B2
N124730736: RT198.1 UT4.G10
N124730838: JXDP.60 RH573.1
N124752685: CH101.2 RH211.1
N124753277: CH100.2 RH212.1
N124754324: RT189.1 RT199.1 RT246.1 UT4.F10
N124755351: T193.1(TP-1) UT4.G4
N124755352: T194.1(TP-1) UT4.F4
N124759625: RT226.2 UT4.E4
N124759627: RT227.2 UT4.D5
N124817422: RH580.1 UH2.AD10
N124817429: RH581.1 UH2.AG2
N125046794: RZ75.2 RZ76.2 UZ7.5
N125087358: PC1201.1 PR1224.1
N125087364: PR1224.2 PU1200.3
N125087423: PC1228.1 PR1225.1
N125087429: PR1225.2 PU1201.3
N125087470: PC1250.1 PR1226.1
N125087492: PR1226.2 PU1202.3
N125087796: PC1308.1 PR1320.1
N125087802: PR1320.2 PU1300.3
N125087876: PC1337.1 PR1321.1
N125087885: PR1321.2 PU1301.3
N125115914: PC209.1 PR208.2 PU200.3
N125173025: RT190.1 UT4.F1
N125233563: PC1138.2 PR1143.2
N125235154: PR211.1 PU200.5
N125273664: T195.1(TP-1) UT1.E2
N125374216: QZ8.1 RZ9.2
N125652796: PC223.2 PQ221.2 PR275.2 PR276.1
N125652818: PQ231.2 PR277.2
N125652875: PQ231.1 PR276.2
N125653204: PQ224.2 PR278.2 PR279.1
N125653216: PQ233.1 PR279.2
N125742089: RH586.1 RH587.1 UH7.5
N125743729: RE125.2 UE1.29
N125749803: QZ6.6 RZ8.2
N125750578: QZ7.6 RZ10.2
N125750624: QZ7.3 RZ11.2
N125811362: QE17.2 RE132.2
N125814267: RN34.1 UN3.7 UN3.8
N125814346: CN22.1 UN3.6
N125836022: RZ72.2 RZ90.2 UZ16.3
N125846238: RT186.1 RT245.1 UT4.E11
N125857121: RZ35.1 UZ8.1
N125861425: QZ9.1 RZ37.1
N125925558: CT106.1 UT3.6
N125927628: RT240.2 UT3.3
N125960908: RZ81.2 UZ19.2
N126088934: PR215.4 PR246.2
N126729390: DZ1.1 RZ89.2 UZ18.2
N126843005: LED6.2 RE3.2
N126911279: QE2.1 QE19.1
N127114927: PD211.2 PQ220.2 PR234.2 PR282.2 PR283.2
N127121027: PQ234.2 PR280.1
N127128586: PR282.1 PU204.4
N127291407: CZ31.1 UZ5.6
N127291517: RZ26.1 UZ5.7 UZ5.8
N127715891: RV547.2 UV17.8
N127915449: PC224.1 PQ226.2 PR27.2
N127915537: PC212.1 PD201.1 PQ227.1 PR247.1 PR248.2 PR249.1 PU201.5
N127915545: PQ227.2 PR270.1
N127915559: PQ226.1 PR242.1 PR291.1
N127915629: PR245.1 PR250.2 PU201.6
N127961998: PD204.2 PR262.2 PR287.2
N127994048: T200.1(TP-1) UT4.E10
N1211736753: T91.1(TP-1) UH2.R44
N1211736754: T92.1(TP-1) UH2.R43
N1211736758: T94.1(TP-1) UH2.U42
N1257483751: QE2.4 QE19.4
N12017464511: T120.1(TP-1) UH2.AL42
N12017464512: T121.1(TP-1) UH2.AN42
N12017464513: T122.1(TP-1) UH2.AM43
N12017464514: T123.1(TP-1) UH2.AJ33
N12017464515: T124.1(TP-1) UH2.AH44
N12017464518: T127.1(TP-1) UH2.AJ42
N12117367569: T182.1(TP-1) UH2.AG35
N12117367571: T104.1(TP-1) UH2.AD35
N12117367572: T105.1(TP-1) UH2.AD31
N12117367573: T106.1(TP-1) UH2.AD38
N12117367574: T107.1(TP-1) UH2.AC43
N12117367575: T108.1(TP-1) UH2.AB44
N12449474450: T191.1(TP-1) UT4.B9
N12449474451: T192.1(TP-1) UT4.A9

Pads without a net: DE2 3; DL1 3; DV12 4 6; FD1 1; FD2 1; FD3 1; FD4 1; JAPS 16 17 18; JAUDIO 23; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JEDP1 37; JHDD 1 2 3 16; JNGFF1 6 8 9 11 12 13 14 17 18 19 20 23 24 26 36 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 6 8 10 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 59; PU203 3; PU300 4 13 14; PU500 2; PU700 2 3 4 20 27; PU800 2; PU1200 4 9; PU1201 4 9; PU1202 4 9; PU1300 4 9; PU1301 4 9; RP19 3; RP24 6 7 8; RT183 2; SW1 2 3; UC1 1; UD2 1; UE1 2 5 6 7 10 11 12 15 25 26 30 31; UE3 B15 B62; UE4 7 10 15 16 29; UF1 2 3; UH1 A27 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B27 B33 B34 B36 BA1 BA2 BA3 BA4 BA5 BJ17 BJ19 BJ20 BJ23 BJ26 BJ27 BJ35 BJ36 BK17 BK19 BK20 BK23 BK26 BK27 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BM14 BM15 BM16 BM17 BM22 BM24 BM31 BN1 BN15 BN16 BN17 BP13 BP15 BP16 BP17 BR15 BR16 BT15 BT16 BT30 C33 C34 D34 E33 F33; UH2 A9 A14 A21 A23 AA44 AA45 AB2 AB3 AB13 AB33 AB35 AB36 AB39 AB41 AB42 AB43 AC2 AC3 AE17 AE45 AF2 AF3 AF17 AG8 AG10 AG14 AG15 AG43 AG44 AH43 AJ7 AJ8 AJ11 AJ13 AJ35 AJ43 AK44 AK45 AL7 AL8 AL27 AL35 AL43 AL44 AN17 AN24 AN29 AN36 AN43 AR15 AR17 AR19 AR22 AR27 AT43 AT44 AV4 AV43 AW35 B10 B13 B14 B15 B20 B21 B22 B23 B24 B36 BA4 BA35 BB17 BB36 BB38 BC8 BC18 BC22 BC35 BC36 BC38 BD1 BD18 BD23 BD34 BD35 BD38 BD39 BE2 BE5 BE6 BE34 BE39 C13 C14 C15 C20 C22 C23 C24 C36 D3 D13 D22 E11 E20 E22 E35 E45 F2 F45 G11 G13 G19 G22 G35 G37 G44 G45 H13 H40 H42 H43 H44 J45 K13 K15 K17 K19 K22 K24 K37 K44 L5 L7 L17 L19 L22 L24 L37 L39 L44 M45 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R41 R42 T44 T45 U2 U3 U13 U36 U39 V1 V2 W2 W3 W7 W10 W11 W13 W39 Y5; UR1 31; UT1 A7 A9 A11 A13 A23 B7 B9 B11 B13 B23 D19 E18 E19 F22 F23 H22 H23 K22 K23 M22 M23 V18 W16 W19 Y16 Y19; UV1 A9 A26 A27 A30 AA1 AA2 AA3 AA4 AA5 AA6 AA7 AA8 AB3 AB4 AB8 AC1 AC2 AC3 AC4 AC5 AC6 AC7 AC8 AC32 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF6 AF7 AF8 AF30 AF32 AG1 AG2 AG3 AG4 AG5 AG6 AG7 AG8 AG9 AH3 AH4 AH6 AH8 AH9 AH31 AJ1 AJ2 AJ3 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ28 AJ31 AJ32 AJ33 AK1 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 AP9 B2 B6 B23 C6 C12 C15 C20 D6 D7 D9 D19 D20 D22 D23 D26 D28 E4 E26 E34 F26 H30 H31 J30 J31 J32 J33 K3 K4 L2 L6 M3 M6 M30 M34 N4 N8 P2 P3 P4 P5 P7 P8 R1 R8 R32 T8 U1 U2 U3 U4 U5 U6 U7 U8 V1 V2 V3 V4 V5 V6 V7 V8 V32 W2 W3 W4 W5 W7 W8 Y1 Y2 Y3 Y4 Y5 Y6 Y7 Y8; UV5 A5 U5; UV6 A5 U5; UV9 A5 U5; UV10 A5 U5; UV17 1; UZ8 3; YH2 2 4

## Via types
v1: diameter 0.406, hole 0.203, TOP to BOTTOM, 591 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8177 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 542 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 113 vias
v5: diameter 0.432, hole 0.203, TOP to BOTTOM, 23 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_B+: length 21.7
  IN1 w0.254: v2(277.12,32.08) 277.62,32.08 278.51,32.97 282.32,32.97 283.02,32.27 286.58,32.27 287.02,32.71 291.72,32.71 292.8,31.63 292.8,28.18 v2(293.16,27.82)
  BOTTOM w0.254: v2(293.16,27.82) 293.16,27.59 PR605.1
  vias: v1(274.09,32.39) v2(274.63,32.71) v2(274.63,32.08) v2(275.21,32.71) v2(275.21,32.08) v2(275.85,32.71) v2(275.85,32.08) v2(276.48,32.71) v2(276.48,32.08) v2(277.12,32.71)
