# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_HTX_GRX_P7: length 17.6
  BOTTOM w0.076: UH1.A17 178,71.22 177.84,71.22 177.78,71.15 177.78,71 177.94,70.84 178.36,70.84 178.54,71.03 178.99,71.03 179.22,70.8 179.89,70.8 179.9,70.81 179.91,70.81
  BOTTOM w0.152: 179.91,70.81 v4(180.46,70.81) 184.07,70.81 189.89,76.63 191.78,76.63 CH21.1
PEG_HTX_GRX_P8: length 19.7
  BOTTOM w0.076: UH1.B18 177.35,72.01 177.18,72.01 177.06,71.89 177.06,71.71 177.17,71.61 177.59,71.61 177.75,71.45 178.4,71.45 178.55,71.29 179.02,71.29 179.11,71.38 179.76,71.38 179.79,71.34 179.81,71.34
  BOTTOM w0.152: CH19.1 192.61,78.1 190.66,78.1 183.86,71.29 v4(183.22,71.29) 180.76,71.29 180.71,71.34 179.81,71.34
PEG_HTX_GRX_P9: length 20.2
  BOTTOM w0.076: 179.85,72.09 179.3,72.09 179.02,72.37 178.54,72.37 178.39,72.22 177.88,72.22 177.59,72.51 177.59,72.63 177.5,72.72 UH1.B19
  BOTTOM w0.152: CH17.1 193.66,79.63 191.06,79.63 v4(186.15,74.72) 183.53,72.09 179.85,72.09
PEG_HTX_GRX_P10: length 20.1
  BOTTOM w0.076: UH1.B20 177.38,73.55 177.2,73.55 177.13,73.48 177.13,73.33 177.24,73.21 178.28,73.21 178.36,73.13 178.87,73.13 178.97,73.22 179.15,73.22 179.18,73.25 179.37,73.25 179.4,73.22
  BOTTOM w0.152: 179.4,73.22 179.48,73.3 182.04,73.3 182.57,73.82 183.06,73.82 190.95,81.71 v4(191.64,81.71) 192.63,81.71 CH15.1
PEG_HTX_GRX_P11: length 21.9
  BOTTOM w0.076: UH1.B21 177.56,74.17 177.56,74.04 177.78,73.81 178.36,73.81 178.55,74.01 179.58,74.01 179.61,73.98 179.7,73.98 179.74,74.02 179.76,74.02 179.78,74.04 180.08,74.04 180.28,73.83 180.35,73.83 180.39,73.8 180.4,73.8
  BOTTOM w0.152: 180.4,73.8 181.76,73.8 182.36,74.39 182.86,74.39 v4(183.84,75.38) 190.99,82.52 194.86,82.52 CH13.1
PEG_HTX_GRX_P12: length 20.4
  BOTTOM w0.076: UH1.B22 177.39,75.12 177.18,75.12 177.12,75.05 177.12,74.9 177.24,74.77 178.49,74.77 178.56,74.7 179.1,74.7 179.3,74.9 180.9,74.9 180.94,74.94 181.01,74.94 181.05,74.98 181.06,74.98
  BOTTOM w0.152: 181.06,74.98 181.2,74.98 181.88,75.66 182.55,75.66 190.99,84.11 v4(191.67,84.11) 192.62,84.11 CH11.1
PEG_HTX_GRX_P13: length 22.2
  BOTTOM w0.076: UH1.B23 177.58,75.72 177.58,75.58 177.78,75.37 178.5,75.37 178.64,75.51 179.29,75.51 179.46,75.35 179.9,75.35
  BOTTOM w0.152: 179.9,75.35 180.67,75.35 181.58,76.26 182.5,76.26 v4(189.12,82.88) 191.11,84.87 194.86,84.87 CH9.1
PEG_HTX_GRX_P14: length 22.1
  BOTTOM w0.076: 179.9,76 179.88,76 179.85,76.04 179.09,76.04 179.06,76.08 178.37,76.08 178.27,76.18 177.74,76.18 177.61,76.31 177.16,76.31 177.06,76.41 177.06,76.6 177.2,76.74 177.34,76.74 UH1.B24
  BOTTOM w0.152: 179.9,76 180.16,76 181.27,77.11 182.22,77.11 v4(182.66,77.56) 188.85,83.75 188.85,85.54 189.4,86.09 191.7,86.09 191.84,86.23 192.61,86.23 CH7.1
PEG_HTX_GRX_P15: length 23.6
  BOTTOM w0.076: 179.79,77.05 178.6,77.05 178.53,76.98 178.42,76.98 178.38,76.93 177.87,76.93 177.6,77.2 177.6,77.31 177.47,77.44 UH1.B25
  BOTTOM w0.152: CH5.1 194.86,87.35 191.72,87.35 191.27,86.9 188.86,86.9 187.83,85.87 187.83,83.84 v4(183.72,79.73) 181.9,77.91 180.8,77.91 179.93,77.05 179.79,77.05
PEX_TSTCLK_OUT: length 3
  TOP w0.102: v2(203.03,84.34) 203.03,84.45 202.95,84.53 202.7,84.53 202.41,84.82 202.41,85.56 RV286.2
  BOTTOM w0.089: UV1.AJ26 203.34,84.65 v2(203.03,84.34)
PEX_TSTCLK_OUT#: length 2.3
  TOP w0.102: v2(203.03,85.02) 202.84,84.84 202.72,84.84 202.63,84.93 202.63,86.01 RV286.1
  BOTTOM w0.089: UV1.AK26 202.65,84.65 v2(203.03,85.02)
PLTRST_CPU#: length 128.3
  TOP w0.14: v1(119.41,91.98) 119.19,92.2 v2(119.19,92.64) RH480.1
  IN4 w0.091: v2(104.78,19.57) 104.76,19.58 104.72,19.58 104.4,19.91 104.4,20.25 105.29,21.15 106.83,21.15 107.96,22.28 107.96,25.69 107.38,26.27 107.38,29.42 107.38,29.42 107.38,33.83 119.89,46.33 119.89,57.32 120.39,57.83 120.39,62.3 122.33,64.23 122.33,65.2 123.21,66.08 123.21,67.79 126.62,71.2 126.62,78.56 130.37,82.31 130.37,82.63 132.18,84.44 v2(132.18,85.38) 132.18,87.47 128.65,91 128.65,96.77 127.41,98.01 125.28,98.01 124.3,97.02 122.23,97.02 120.6,95.39 120.6,94.88 120.55,94.83 120.55,94.29 120.6,94.24 120.6,93.55 119.69,92.64 v2(119.19,92.64)
  BOTTOM w0.076: UH1.BP35 138.43,83.97 137.73,83.97 137.64,83.88 136.48,83.88 135.92,84.43 134.62,84.43
  BOTTOM w0.089: UH2.AK2 98.95,11.61 99.14,11.42 99.14,11.42 99.16,11.41 99.16,11.41 99.28,11.29 100.86,11.29 101.75,12.18
  BOTTOM w0.127: v2(104.78,19.57) 104.78,17.83 105.39,17.22 105.39,15.56 105.45,15.5 105.45,13.02 105.24,12.81 104.4,12.81 104.09,12.51 102.09,12.51 101.75,12.18
  BOTTOM w0.14: v2(132.18,85.38) 133.12,84.43 134.62,84.43
POWER_SW_IN#: length 26.5
  TOP w0.14: v2(294.54,9.09) 294.35,9.09 294.12,8.86 v3(294.12,8.77) 294.12,8.55 293.33,7.77 CE30.1 292.83,6.95 292.83,5.72 292.48,5.37 RE34.2 292.48,4.96 292.99,4.45 292.99,3.77 292.14,2.92 287.18,2.92 284.32,5.78 283.14,5.78 282.58,5.22 RE110.1 283.01,4.71 RE36.1 ; v2(295.86,12.4) 295.75,12.4 295.23,11.88 UE3.B67
  BOTTOM w0.14: v2(295.86,12.4) 295.82,12.37 295.82,10.53 294.54,9.25 v2(294.54,9.09)
PP_HV: length 10.6
  TOP w0.254: PR287.1 20.82,2.63 v2(20.96,2.49)
  TOP w0.508: PD203.2 12.98,2.27 12.42,2.83 v2(12.42,3.06)
  IN1 w0.254: v2(20.96,2.49) 12.99,2.49 v2(12.42,3.06)
  vias: v1(8.26,41.5) v2(7.71,41.64) v2(7.7,41.04)
PROC_DETECT#: length 109
  TOP w0.14: v1(106.07,34.9) 105.67,34.49 v2(104.79,34.49)
  IN2 w0.089: v2(77.33,16.28) 77.33,17.73 75.87,19.19 75.87,24.62 76.37,25.12 76.37,26.12 76.78,26.53
  IN2 w0.099: 76.78,26.53 76.88,26.63 79.53,26.63 81.1,28.21 83.2,28.21 83.58,28.58 86.36,28.58 90.1,32.32 98.62,32.32 98.74,32.44 100.95,34.65 102.42,34.65 102.99,34.08 104.38,34.08 v2(104.79,34.49)
  IN6 w0.099: v2(129.51,83.69) 128.98,83.16 128.98,78.79 126.61,76.41 126.61,71.15 124.72,69.26 124.72,66.32 123.99,65.59 121.68,65.59 120.54,64.45 120.54,63.68 117.74,60.88 117.74,56.49 115.77,54.53 115.77,45.66 108.15,38.04 105.24,38.04 104.29,37.09 104.29,35.45 104.79,34.96 v2(104.79,34.49)
  BOTTOM w0.089: v2(77.33,16.28) 77.65,16.6 UH2.Y44
  BOTTOM w0.14: v2(129.51,83.69) 129.78,83.96 RH519.1
PS_ID: length 308.3
  TOP w0.14: v2(302.15,13.85) 302.67,14.38 UE3.B24
  TOP w0.254: PR102.2 PR101.2 v3(47.25,30.92) 48.34,30.92 v2(50.53,33.11)
  IN2 w0.099: v2(307.32,29.68) 307.32,29.45 306.73,28.86 296.31,28.86 293.69,26.24 292.92,26.24 290.62,23.94 289.04,23.94 288.1,23 268.48,23 267.41,21.93 264.5,21.93 264.1,21.54 260.63,21.54 259.27,22.89 258.6,22.89 257.45,21.74 254.66,21.74 252.22,19.31 207.58,19.31 207.32,19.57 184.66,19.57 184.4,19.31 179.51,19.31 178.58,20.24 175.63,20.24 174.81,21.06 174.81,21.37 174.26,21.92 173.62,21.92 173.16,21.47 173.16,20.17 173.01,20.01 161.51,20.01 160.99,20.54 160.99,24.21 158.25,26.95 155.9,26.95 153.33,29.52 145.14,29.52 139.86,34.8 116.93,34.8 111.52,40.21 98.36,40.21 95.26,37.11 87.07,37.11 84.09,34.12 81.57,34.12 80.51,33.06 54.69,33.06 54.01,33.74 51.16,33.74 v2(50.53,33.11)
  BOTTOM w0.14: v2(307.32,29.68) 307.32,28.81 308.28,27.85 308.28,25.12 307.77,24.61 307.77,19.57 308,19.34 308,18 307.66,17.67 304.94,17.67 303.67,16.4 303.67,14.72 303.24,14.28 302.58,14.28 v2(302.15,13.85)
PSID: length 3.5
  TOP w0.254: PL104.1 17.82,76.85 PD100.1 18.14,76.54 18.77,76.54 v1(19.04,76.81) 19.04,77.24 v2(18.67,77.61)
PSID-1: length 7.1
  TOP w0.14: v1(42.93,36.2) 41.73,35 39.98,35 PR103.2
  TOP w0.254: PQ101.2 38.18,33.42 38.38,33.62 38.38,34.33 PR105.1 PR103.2
PSID-2: length 4.9
  TOP w0.14: PQ101.1 39.42,32.77 v1(39.98,33.34)
  TOP w0.254: PQ100.2 41.3,31.43 PR104.1 39.96,31.43 39.03,32.36 PQ101.1
PSID-3: length 3.7
  TOP w0.14: PR100.2 45.95,32.76 v3(46.29,33.11)
  TOP w0.254: PQ100.3 43.77,31.84 PR102.1 PR100.2
PTP_DIS#: length 69.6
  TOP w0.14: v1(274.83,18.44) v2(275.36,17.9) 275.64,17.9 275.93,17.62 UE4.21
  IN3 w0.091: v2(219.08,8.59) 221.13,10.65 230.43,10.65 231.24,11.47 232.83,11.47 233.6,12.23 252.2,12.23 253.92,13.95 256.56,13.95 256.78,14.17 260.72,14.17 260.84,14.28 266.61,14.28 268.65,16.32 273.79,16.32 v2(275.36,17.9)
  BOTTOM w0.14: JTP.3 221.4,9.42 221.66,9.16 221.66,8.47 221.41,8.22 219.45,8.22 v2(219.08,8.59)
PTP_INT#: length 283.2
  TOP w0.089: v2(89.68,10.17) 90.11,9.73 90.11,6.08 89.93,5.9 89.35,5.9 89.03,5.58 89.03,4.93 89.35,4.61 89.76,4.61 DH1.1
  TOP w0.14: v2(306.85,26.22) 306.29,25.66 RE138.1 ; v2(214.26,11.64) 214.01,11.4 214.01,10.65 214.26,10.39 214.69,10.39 215.74,11.45 216.14,11.45 217.09,10.5 218.09,10.5 218.95,9.65 QE13.1 218.5,8.96 v1(218.5,7.69)
  IN3 w0.091: v2(319.47,25.34) 319.17,25.04 316.19,25.04 314.2,27.03 312.1,27.03 311.61,27.52 308.16,27.52 v2(306.85,26.22)
  IN6 w0.089: v2(89.68,10.17) 90.06,10.55 90.98,10.55 91.98,11.55 95.46,11.55 95.57,11.65 97.65,11.65 98.17,11.13 99.01,11.13 99.25,11.36 101.98,11.36
  IN6 w0.099: v2(319.47,25.34) 318.52,24.38 318.52,20.2 314.57,16.25 314.57,13.08 311.39,9.9 303.86,9.9 303.51,10.24 295.13,10.24 294.34,11.03 293.41,11.03 292.61,10.23 289.3,10.23 289.14,10.08 289.14,9.45 289.31,9.28 289.31,8.69 289.11,8.5 284.77,8.5 283.7,9.57 279.89,9.57 278.3,7.98 275.12,7.98 274.6,8.49 271.18,8.49 270.68,8.99 270.68,9.35 270.21,9.82 262.76,9.82 262.14,9.2 248.72,9.2 248.19,8.67 234.67,8.67 233.24,10.11 228.71,10.11 228.26,10.56 224.84,10.56 223.75,11.64 v2(214.26,11.64) 213.82,11.2 212.77,11.2 212.39,11.59 200.9,11.59 200.05,12.44 187.21,12.44 186.62,11.85 177.32,11.85 177.07,11.59 169.55,11.59 169.41,11.45 163.64,11.45 162.8,10.61 160.29,10.61 159.45,11.45 155.07,11.45 154.22,12.3 126.3,12.3 125.86,11.85 113.42,11.85 112.75,11.18 107.88,11.18 107.21,11.85 102.82,11.85 102.33,11.36 101.98,11.36
PTP_INT#_EC: length 59.9
  TOP w0.14: RP19.2 291.37,8.14 291.65,8.42 v2(291.65,8.87) ; UE3.B37 302.02,19.26 301.49,18.73 v2(301.43,18.73) ; v2(305.3,24.91) 305.11,25.1 RE138.2 ; v2(314.19,9.35) v1(313.7,8.86)
  IN3 w0.091: v2(314.19,9.35) 314.15,9.38 314.15,19.07 312.09,21.13 303.71,21.13 301.86,19.29 301.86,19.16 v2(301.43,18.73)
  IN4 w0.091: v2(301.43,18.73) 301.43,18.77 301.81,19.15 301.81,19.6 303.62,21.41 303.62,23.78 304.37,24.54 304.92,24.54 v2(305.3,24.91)
  IN6 w0.099: v2(314.19,9.35) 314.19,9.36 314.06,9.49 303.39,9.49 303.05,9.83 294.14,9.83 294,9.69 293.15,9.69 292.33,8.87 v2(291.65,8.87)
PTP_INT#_R: length 10.5
  TOP w0.14: v1(214.52,10.87) 215.34,11.69 216.47,11.69 217.13,11.03 v2(217.37,11.03) 217.65,11.31 QE13.3 218.3,11.92 218.49,12.11 RE87.2
  BOTTOM w0.14: JTP.4 220.4,11.43 220,11.03 v2(217.37,11.03)
PWM1_GT: length 32.2
  TOP w0.14: v2(105.42,78.95) 105.72,78.65 v3(105.72,78.46)
  TOP w0.203: PU1100.12 113.84,103.69 113.6,103.45 113.6,103.07 v2(113.04,102.51)
  IN2 w0.254: v2(113.04,102.51) 113.67,101.89 113.67,91.07 112.65,90.05 112.65,83.64 109.67,80.65 109.67,79.96 109.16,79.45 105.93,79.45 v2(105.42,78.95)
  BOTTOM w0.254: v2(105.42,78.95) 105.67,79.19 PU1300.13
PWM1_VCORE: length 23.4
  TOP w0.14: v1(130.52,104.56) 129.92,103.96 v2(129.92,103.89)
  TOP w0.203: v2(120.84,103.08) 120.84,103.39 120.54,103.69 PU1100.25
  IN2 w0.254: v2(120.84,103.08) 121.51,103.08 122.26,103.83 122.75,103.83 123.74,104.82 127.05,104.82 127.98,103.89 v2(129.92,103.89)
  BOTTOM w0.254: PU1200.13 139.16,107.15 138.98,106.98 138.22,106.98 138.16,106.92 137.25,106.92 135.06,104.73 135.06,104.18 134.6,103.72 130.1,103.72 v2(129.92,103.89)
PWM2_GT: length 41.2
  TOP w0.14: v3(113.44,101.44) 113.88,101.44 v2(114.3,101.86)
  TOP w0.203: PU1100.13 115,102.43 114.43,101.86 v2(114.3,101.86)
  IN2 w0.254: v2(114.3,101.86) 114.02,101.58 114.02,90.85 113.09,89.92 113.09,83.38 110.43,80.72 110.43,79.7 111.57,78.56 111.57,74.18 109.08,71.69 107,71.69 106.88,71.8 106.48,71.8 106.42,71.74 104.88,71.74 104.59,71.45 v2(104.59,71.32)
  BOTTOM w0.254: v2(104.59,71.32) 104.91,71.64 PU1301.13
PWM2_VCORE: length 25.5
  TOP w0.14: v2(138.84,113.17) 138.71,113.29 v1(137.61,113.29)
  TOP w0.203: v2(121.15,103.73) 121.01,103.73 120.66,104.09 PU1100.26
  IN2 w0.254: v2(121.15,103.73) 121.51,103.73 122.04,104.26 122.68,104.26 123.19,104.78 123.19,106.09 123.91,106.81 125.08,106.81 127.24,108.97 132.06,108.97 135.43,112.35 138.02,112.35 v2(138.84,113.17)
  BOTTOM w0.254: v2(138.84,113.17) 138.84,113.32 139.22,113.71 PU1201.13
PWM3_VCORE: length 43
  TOP w0.14: v2(154.78,117.13) 154.77,117.13 v1(154.28,117.62)
  TOP w0.203: v2(121.13,104.32) 120.92,104.32 120.76,104.49 PU1100.27
  IN2 w0.254: v2(154.78,117.13) 154.43,117.48 151.22,117.48 150.58,116.85 143.03,116.85 142.8,117.07 139.17,117.07 138.23,116.13 137.47,116.13 136.74,115.4 136.74,114.89 131.18,109.33 127.09,109.33 124.93,107.17 123.76,107.17 122.84,106.24 122.84,104.92 122.53,104.62 121.43,104.62 v2(121.13,104.32)
  BOTTOM w0.254: PU1202.13 v2(154.78,117.13)
PWM_SA: length 20
  TOP w0.14: v2(121.21,108.78) 121.22,108.78 v3(121.58,109.14)
  TOP w0.203: PU1100.35 120.68,107.69 121.03,108.04 121.03,108.61 v2(121.21,108.78)
  IN1 w0.254: v2(121.21,108.78) 119.44,107.01 119.44,102.18 118.96,101.7 118.96,100.82 117.7,99.56 117.7,94.79 117.03,94.12 v2(116.97,94.12)
  BOTTOM w0.254: v2(116.97,94.12) 116.9,94.18 PU1302.3
PWR_BTN_DOCK1#: length 19.9
  TOP w0.14: RT182.2 8.59,37.14 8.89,36.84 9.59,36.84 9.84,36.58 9.84,36.24 10.06,36.03 10.34,36.03 10.75,35.62 10.75,34.86 11.22,34.39 12.09,34.39 12.73,33.75 12.73,32.76 12.18,32.22 12.18,31.75 12.68,31.26 13.16,31.26 13.42,31.01 13.42,30.47 v1(13.13,30.18) 12.9,29.95 12.9,26.07 13.31,25.66 14.94,25.66 RT194.2 16.03,26.26 16.13,26.16 QV89.3
PWR_DEBUG#_XDP: length 4.8
  TOP w0.14: JXDP.45 129.31,96.51 129.53,96.73 129.9,96.73 RH483.2 130.47,97.28 RH488.1 130.8,96.43 131.09,96.72 v3(131.74,96.72)
PWR_SRC_ILIMIT: length 95.1
  TOP w0.14: v2(12.99,30.82) 12.13,30.82 11.25,31.7 10.54,31.7 10.13,32.11 8.48,32.11 v1(8.16,32.43) 7.75,32.84 7.75,34.55 7.34,34.96 6.5,34.96 6.31,35.16 6.31,37.02 RT198.2
  TOP w0.254: v2(27.12,29.91) 27.12,30.44 PD205.2 ; PR266.1 v2(23.9,3.65) ; PD205.2 26.59,31.44 PR236.1 ; PD205.2 28.28,30.68 28.6,30.36 PR239.2 PC211.1
  IN2 w0.099: v2(23.9,3.65) 23.76,3.51 23.76,2.37 23.43,2.04 17.37,2.04 14.92,4.49 9.71,4.49 7.48,6.72 7.48,9.27 7.18,9.58 7.18,11.25 5.69,12.73 5.69,16.24 8.66,19.21 9.7,19.21 12.73,22.23 16.27,22.23 17.16,23.12 18.04,23.12 19,24.08 19,24.66 19.44,25.09 20.47,25.09 21,25.62 24.27,25.62 25.71,27.06 25.71,28.18 26.93,29.4 26.93,29.4 27.12,29.59 v2(27.12,29.91)
  IN6 w0.099: v2(27.12,29.91) 26.06,28.85 22.67,28.85 21.34,27.52 18.07,27.52 17.42,26.87 16.1,26.87 14.13,28.84 14.13,29.22 13.52,29.84 13.52,30.29 v2(12.99,30.82)
  BOTTOM w0.254: v2(27.12,29.91) 27.12,29.2 27.29,29.03 PU201.1
PWR_SRC_ON: length 294.2
  TOP w0.14: UE4.2 276.58,10.65 v2(275.83,9.91) ; v3(27.18,5.79) v2(27.75,6.36)
  TOP w0.254: PR212.2 29.34,6.23 28.82,5.71 28.08,5.71 27.81,5.98 27.81,6.3 v2(27.75,6.36)
  IN1 w0.099: v2(272.15,6.78) 272.7,6.78 v2(275.83,9.91)
  IN6 w0.089: 101.98,8.2 101.33,7.54 99.11,7.54 98.94,7.72 97.7,7.72 97.35,7.36 95.9,7.36 95.59,7.05 95.59,5.95 95.25,5.62 93.91,5.62 93.63,5.89 93.63,6.33 93.39,6.57 92.54,6.57 92.4,6.43 90.64,6.43 90,5.79 89.44,5.79 88.92,5.27 88.38,5.27 87.7,4.59 87.19,4.59 86.73,5.05 85.97,5.05 85.65,4.73 82.44,4.73 82.4,4.77 82.4,5.85 81.53,6.71 81.04,6.71 80.18,7.57 78.66,7.57 77.69,6.61 75.73,6.61 75.65,6.53 75.06,6.53
  IN6 w0.099: 75.06,6.53 72.77,6.53 71.53,7.77 71.53,8.31 71.12,8.72 69.64,8.72 67.9,10.45 64.45,10.45 63.54,11.36 60.87,11.36 60.08,10.57 57.99,10.57 56.96,11.6 55.76,11.6 55.18,12.17 54.89,12.17 53.94,13.13 53.94,15.34 53.54,15.73 53.54,17.75 51.58,19.71 50.53,19.71 50.14,20.1 41.61,20.1 40.79,20.93 34.79,20.93 33.91,21.8 31.18,21.8 30.62,21.24 29.68,21.24 27.45,19.01 27.45,13.35 28.6,12.2 28.6,7.21 v2(27.75,6.36) ; 101.98,8.2 102.77,8.99 104.25,8.99 105.33,7.91 106.67,7.91 108.13,9.37 117.57,9.37 118.22,10.03 126.7,10.03 127.47,9.26 134.22,9.26 135.24,10.28 146.33,10.28 149.49,7.12 151.88,7.12 152.35,7.59 155.26,7.59 155.42,7.43 157,7.43 157.76,8.19 169.55,8.19 171.35,9.99 174.26,9.99 174.71,9.54 186.58,9.54 187.88,10.84 199.38,10.84 200.23,9.99 210.71,9.99 213.32,7.38 226.53,7.38 228.02,5.88 238.05,5.88 239.01,6.84 242.53,6.84 243.3,6.07 245.23,6.07 246.03,6.87 246.32,6.87 246.65,6.87 246.65,6.87 256.33,6.87 257.06,7.6 262.39,7.6 262.73,7.25 271.67,7.25 v2(272.15,6.78)
PWR_SRC_ON_PC: length 72.7
  TOP w0.254: PR214.2 31.69,1.96 v2(32.04,1.96)
  IN6 w0.099: v2(2.49,39.38) 3.05,38.82 3.05,37.18 4.25,35.98 4.25,27.58 6.77,25.07 6.77,22.31 3.77,19.31 3.77,18.13 4.34,17.56 4.34,15.34 5.6,14.09 5.6,10.55 6.76,9.38 6.76,3.81 9.05,1.52 15.36,1.52 15.9,2.07 18.77,2.07 19.32,1.52 26.15,1.52 26.86,2.23 27.8,2.23 28.51,1.52 31.6,1.52 v2(32.04,1.96)
  BOTTOM w0.081: 5.36,38.68 5.37,38.67 6.55,38.67 UT4.D10
  BOTTOM w0.14: 5.36,38.68 5.04,38.68 4.95,38.77 3.1,38.77 v2(2.49,39.38)
PWR_TB_DOCK#: length 300
  TOP w0.14: RE110.2 280.01,3.79 v2(279.76,4.05) ; RT195.2 18.89,25.08 19.89,25.08 20.73,24.24 23.32,24.24 24.05,23.51 24.05,21.96 24.07,21.94 v2(24.07,20.9)
  IN2 w0.099: v2(24.07,20.9) 26.09,20.9 28.61,23.43 28.61,24.61 29.53,25.52 30.86,25.52 31.51,24.88 41.3,24.88 43.31,22.87 45.4,22.87 46.1,22.17 46.1,21.13 v2(46.14,21.09)
  IN3 w0.089: 88.46,1.41 88.43,1.43 88.43,1.89 88.2,2.12 87.75,2.12 87.61,2.26 87.61,3.16 87.24,3.53 86.75,3.53 86.5,3.78 86.06,3.78 85.81,3.53 82.92,3.53 81.09,1.71 75.06,1.71
  IN3 w0.091: v2(279.76,4.05) 279.12,3.41 268.61,3.41 267.45,4.58 264.88,4.58 263.95,3.65 249.8,3.65 249.3,4.15 247.12,4.15 246.94,3.97 243.78,3.97 242.67,5.08 236.27,5.08 233.97,2.78 215.01,2.78 210.08,7.71 184.27,7.71 182.39,5.83 175.72,5.83 174.59,4.7 169.46,4.7 167.84,3.09 151.2,3.09 149.92,1.81 140.34,1.81 138.1,4.05 133.87,4.05 133.01,4.9 130.81,4.9 129.16,6.55 122.36,6.55 121.32,5.52 119.9,5.52 115.89,1.51 109.11,1.51 108.69,1.93 107.05,1.93 106.43,1.32 88.55,1.32 88.46,1.41 ; 75.06,1.71 74.86,1.71 74.5,2.07 73.21,2.07 72.49,1.35 70.11,1.35 69.7,1.75 67.42,1.75 66.45,2.72 62.12,2.72 61.28,3.56 61.28,5.17 59.69,6.76 58.97,6.76 57.66,8.08 57.66,12.37 53.28,16.75 53.28,18.3 51.37,20.2 50.41,20.2 49.79,20.82 48.85,20.82 48.48,20.46 46.55,20.46 46.17,20.84 46.17,21.07 v2(46.14,21.09)
PWRBTN#_XDP: length 6.8
  TOP w0.14: v2(132.2,93.89) 132.2,94.38 v3(131.93,94.65) 131.74,94.84 130.66,94.84 CH174.1 130.07,94.65 129.59,95.14 129.58,95.14 129.33,95.39 129.21,95.51 JXDP.41
  BOTTOM w0.14: RH6.1 RH2.2 132.2,94.37 v2(132.2,93.89)
PWRBTN_LED#: length 144.8
  TOP w0.14: v2(333.58,118.69) 334.19,118.69 LED6.1 ; UE3.B57 294.74,16.88 294.95,16.67 295.44,16.67 v2(295.86,16.25)
  IN6 w0.099: v2(333.58,118.69) 337.83,118.69 343.7,112.83 343.7,97.74 343.47,97.52 v2(343.47,97.24) 343.47,89.36 342.57,88.46 336.25,88.46 330.2,82.4 330.2,76.34 329.26,75.41 329.26,69.25 328.98,68.97 328.98,60.48 327.81,59.31 327.81,55.4 326.31,53.9 326.31,53.07 324.1,50.86 324.1,45.15 317.82,38.88 317.82,31.08 316.82,30.07 316.82,29.08 315.35,27.61 315.35,21.31 312.79,18.76 311.93,18.76 310.97,17.8 304.07,17.8 303.47,17.19 301.7,17.19 300.76,16.25 v2(295.86,16.25)
REF_+1.35V_RUNP: length 5.1
  TOP w0.14: v1(250.36,50.1) 249.66,50.1 PC708.2
  TOP w0.203: PR701.1 247.38,50.94 PU700.26
  TOP w0.254: PC708.2 PR701.1
REM_DIODE1_N: length 457.6
  TOP w0.089: v2(158.02,70.13) QE15.3 158.51,70.93 158.68,71.1 158.68,71.73 CE69.1
  TOP w0.127: CE32.1 v2(303.79,5.89) ; UE3.B13 301.02,11.35 301,11.37 v2(301,12.05) ; v2(263.12,22.79) v1(263.12,22.11)
  IN2 w0.127: v2(116.85,116.08) 117.1,115.83 117.1,115.73 117.6,115.22 123.48,115.22 128.41,120.15 164.12,120.15 165.01,119.26 172.85,119.26 173.74,120.15 222.63,120.15 227.16,115.62 243.3,115.62 246.34,112.58 246.34,98.2 248.35,96.19 248.35,87.12 247.66,86.44 247.66,80.71 248.25,80.13 248.25,64.52 247.66,63.93 243.8,63.93 242.36,62.49 241.88,62.49 241.1,61.71 241.1,60.49 240.79,60.18 240.28,60.18 238.98,58.87 238.98,52.42 241.31,50.08 241.31,40.07 255.05,26.34 257.55,26.34 260.93,22.96 262.95,22.96 v2(263.12,22.79)
  IN3 w0.089: v2(158.02,70.13) 158.46,69.69 158.46,68.63 159.41,67.67 160.56,67.67 161.11,67.12 166.67,67.12 167.07,66.72 167.07,65.06 167.45,64.68 167.45,63.87 168.6,62.72 171.56,62.72 171.9,63.06 172.43,63.06 172.85,62.64 172.85,60.19 176.3,56.74 177.38,55.66 177.38,55.6 177.44,55.53 177.45,55.53
  IN3 w0.127: v2(303.79,5.89) 304.18,6.28 304.18,9.2 302.61,10.77 301.32,10.77 301,11.08 v2(301,12.05) ; v2(263.12,22.79) 263,22.91 261.67,22.91 253.13,31.44 252.51,31.44 251.98,31.97 232.94,31.97 218.42,46.49 215.43,46.49 211.47,50.45 208.13,50.45 207.34,51.24 204.86,51.24 203.54,52.56 197.28,52.56 195.91,51.19 181.79,51.19 177.45,55.53
  BOTTOM w0.127: v2(263.12,22.79) 263.31,22.98 263.42,22.98 264.23,22.18 266.72,22.18 267.86,23.31 273.45,23.31 274.58,22.18 274.58,19.76 275.93,18.41 275.93,17.88 277.15,16.65 277.15,5.6 280.11,2.64 301.94,2.64 303.67,4.36 303.67,5.05 303.33,5.39 303.33,6.66 303.45,6.79 303.61,6.79 303.79,6.61 v2(303.79,5.89) ; v2(116.85,116.08) 117.02,115.91 117.02,115.05 116.91,114.94 116.66,114.94 CE45.1 115.99,114.93 115.71,114.93 QE7.2 114.54,114.8 QE7.1
REM_DIODE1_P: length 452.6
  TOP w0.089: CE69.2 158.89,71.73 158.89,71.05 159.01,70.93 QE15.2 159.32,70.76 v2(158.67,70.11) QE15.1
  TOP w0.127: v2(263.12,23.38) v1(263.12,24.08) ; v2(303.76,8.14) 303.76,7.48 CE32.2 ; UE3.A13 301.27,9.23 v2(301.32,9.18)
  IN2 w0.127: v2(117.44,116.08) 117.35,115.99 117.35,115.83 117.7,115.48 123.38,115.48 128.31,120.4 164.22,120.4 165.11,119.52 172.75,119.52 173.63,120.4 222.73,120.4 227.27,115.87 243.41,115.87 246.6,112.68 246.6,98.31 248.6,96.3 248.6,87.02 247.92,86.33 247.92,80.82 248.5,80.23 248.5,64.41 247.77,63.67 243.91,63.67 242.47,62.23 241.98,62.23 241.35,61.6 241.35,60.39 240.89,59.93 240.39,59.93 239.23,58.77 239.23,52.53 241.57,50.19 241.57,40.18 255.16,26.59 257.66,26.59 261.04,23.21 262.95,23.21 v2(263.12,23.38)
  IN3 w0.089: v2(158.67,70.11) 158.67,68.72 159.5,67.89 160.65,67.89 161.2,67.34 166.76,67.34 167.29,66.81 167.29,65.15 167.66,64.77 167.66,63.96 168.69,62.93 171.47,62.93 171.81,63.28 172.52,63.28 173.06,62.73 173.06,60.28 177.63,55.71
  IN3 w0.127: v2(303.76,8.14) 303.76,9.26 302.51,10.52 301.56,10.52 301.32,10.27 v2(301.32,9.18) ; v2(263.12,23.38) 262.9,23.16 261.77,23.16 253.24,31.7 252.62,31.7 252.09,32.23 233.05,32.23 218.53,46.74 215.53,46.74 211.58,50.7 208.24,50.7 207.45,51.49 204.97,51.49 203.64,52.82 197.18,52.82 195.8,51.44 181.9,51.44 177.63,55.71
  BOTTOM w0.127: QE7.3 115.71,114.67 116.02,114.67 CE45.2 116.66,114.69 117.02,114.69 117.27,114.94 117.27,115.91 v2(117.44,116.08) ; v2(303.76,8.14) 303.76,7.22 303.58,7.04 303.35,7.04 303.07,6.77 303.07,5.28 303.41,4.94 303.41,4.47 301.84,2.89 280.22,2.89 277.41,5.7 277.41,16.76 276.19,17.98 276.19,18.52 274.84,19.86 274.84,22.28 273.55,23.57 267.76,23.57 266.62,22.43 264.34,22.43 263.53,23.24 263.26,23.24 v2(263.12,23.38)
REM_DIODE2_N: length 315.5
  TOP w0.127: CE33.1 304.93,5.8 v2(304.83,5.7) ; UE3.B14 v2(301.52,11.47) ; v2(193.31,93.79) 193.05,93.53 193.05,91.48 187.01,85.45 187.01,80.83 183.14,76.96 QE6.3 183.01,76.22 CE47.2 182.7,74.92 182.7,74.09 182.83,73.96 184.06,73.96 184.31,73.71 184.31,72.04 184.16,71.89 184.16,64.97 186.79,62.34 189.67,62.34 193.16,58.85 193.16,47.13 197.74,42.54 229.1,42.54 230.64,41 248.61,41 259.08,30.53 259.08,27.99 259.53,27.55 259.53,24.1 259.97,23.66 259.97,8.79 260.83,7.94 260.83,6.91 v2(260.97,6.77)
  IN1 w0.127: v2(304.83,5.7) 304.83,5.75 304.67,5.9 304.67,6.57 304.94,6.84 305.86,6.84 306.3,7.28 306.3,8.31 304.13,10.48 301.97,10.48 301.52,10.92 v2(301.52,11.47)
  IN3 w0.127: v2(260.97,6.77) 260.8,6.6 260.8,5.84 260.99,5.65 281.01,5.65 282.27,4.39 292.71,4.39 293.07,4.03 293.07,3.23 293.41,2.89 302.3,2.89 303.26,3.85 305.03,3.85 306.17,5 306.17,6.52 305.84,6.85 305.26,6.85 304.78,6.37 304.78,5.75 v2(304.83,5.7)
  IN4 w0.127: v2(167.28,117.22) 167.12,117.38 167.12,118.68 167.75,119.31 172.67,119.31 173.45,120.1 208.48,120.1 208.98,119.59 208.98,97.95 207.79,96.77 199.27,96.77 198.75,97.29 193,97.29 191.46,95.76 191.46,93.72 192.16,93.02 192.77,93.02 193.05,93.3 193.05,93.53 v2(193.31,93.79)
  BOTTOM w0.127: QE5.1 164.49,119.13 QE5.2 165.65,119.28 165.98,119.28 CE46.2 166.63,119.28 166.85,119.28 167.12,119.01 167.12,117.38 v2(167.28,117.22)
REM_DIODE2_P: length 315.2
  TOP w0.127: v2(304.61,8.15) 304.61,7.64 CE33.2 ; UE3.A14 301.77,9.31 v2(301.96,9.13) ; v2(260.36,6.77) 260.57,6.97 260.57,7.83 259.72,8.69 259.72,23.55 259.27,24 259.27,27.44 258.83,27.89 258.83,30.43 248.5,40.75 230.53,40.75 228.99,42.29 197.64,42.29 192.9,47.02 192.9,58.75 189.56,62.09 186.68,62.09 183.91,64.86 183.91,72 184.06,72.15 184.06,73.6 183.95,73.71 182.72,73.71 182.44,73.99 182.44,74.89 CE47.1 182.09,76.11 QE6.2 181.84,77.63 182.17,77.95 QE6.1 183.78,77.95 186.76,80.93 186.76,85.55 192.79,91.58 192.79,93.53 v2(192.53,93.79)
  IN1 w0.127: v2(304.61,8.15) 304.61,7.37 304.89,7.1 305.75,7.1 306.05,7.39 306.05,8.2 304.03,10.22 302.12,10.22 301.96,10.06 v2(301.96,9.13)
  IN3 w0.127: v2(260.36,6.77) 260.54,6.59 260.54,5.73 260.88,5.39 280.9,5.39 282.16,4.13 292.61,4.13 292.81,3.93 292.81,3.13 293.3,2.64 302.41,2.64 303.37,3.6 305.13,3.6 306.43,4.89 306.43,6.63 305.95,7.11 305.26,7.11 304.61,7.76 v2(304.61,8.15)
  IN4 w0.127: v2(192.53,93.79) 192.79,93.53 192.79,93.4 192.67,93.27 192.26,93.27 191.72,93.82 191.72,95.65 193.1,97.04 198.65,97.04 199.17,96.51 207.9,96.51 209.23,97.85 209.23,119.7 208.58,120.35 173.35,120.35 172.56,119.56 167.64,119.56 166.87,118.79 166.87,117.38 v2(166.7,117.22)
  BOTTOM w0.127: v2(166.7,117.22) 166.87,117.38 166.87,118.91 166.75,119.02 166.64,119.02 CE46.1 165.97,119.02 165.68,119.02 QE5.3
REM_DIODE3_N: length 361
  TOP w0.127: QE11.3 28.02,53.22 CE68.2 27.69,52 27.69,51.87 28.68,50.87 29.27,50.87 29.5,51.09 v2(29.5,51.41) ; UE3.A15 302.27,9.43 v2(302.83,8.88) ; v2(305.25,8.07) 305.25,8.02 CE35.1
  IN1 w0.127: v2(94.37,38.31) 94.17,38.11 92.53,38.11 91.81,37.38 87.18,37.38 84.38,34.59 84.38,34.58 84.35,34.55 81.33,34.55 80.25,33.47 76.21,33.47 75.19,32.46 70.95,32.46 67.77,29.28 53.96,29.28 53.4,28.71 41.64,28.71 38.93,31.42 38.93,37.98 35.88,41.03 35.88,43.25 35.18,43.95 35.18,44.95 34.42,45.71 34.42,45.9 33.73,46.58 33.73,47.09 33.34,47.49 33.34,48.45 33.08,48.71 33.08,48.93 30.32,51.69 29.92,51.69 29.65,51.41 v2(29.5,51.41)
  IN2 w0.127: v2(118.9,36) 118.45,36 118.02,36.43 117.14,36.43 112.49,41.08 97.91,41.08 94.98,38.15 94.54,38.15 v2(94.37,38.31)
  IN3 w0.127: v2(264.33,23.36) 264.15,23.54 263.87,23.54 262.14,25.27 261.18,25.27 253.12,33.33 233.18,33.33 219.11,47.39 215.79,47.39 211.83,51.35 209.87,51.35 207.07,54.15 203.78,54.15 203.1,53.48 201.35,53.48 200.81,54.01 198.87,54.01 198.32,53.45 196.73,53.45 195.35,52.08 190.48,52.08 190.22,52.34 190.22,52.71 v2(190.07,52.86)
  BOTTOM w0.127: v2(264.33,23.36) 264.5,23.54 264.76,23.54 265.59,24.37 273.7,24.37 275.51,22.56 275.51,20.56 277.81,18.25 277.81,17.52 278.3,17.04 278.3,7.09 281.45,3.94 300.22,3.94 302.4,6.12 302.4,8.45 v2(302.83,8.88) 303.4,9.46 305.2,9.46 305.74,8.92 305.74,7.3 305.61,7.17 305.46,7.17 305.25,7.38 v2(305.25,8.07) ; v2(190.07,52.86) 190.23,52.7 190.23,52.49 187.44,49.69 180.52,49.69 CE49.2 179.2,48.98 QE8.1 179.2,48.47 179.38,48.29 180.36,48.29 180.77,47.88 180.77,46.44 180.59,46.26 179.63,46.26 179.48,46.41 179.48,46.67 QE8.2 179.84,47.05 179.27,47.05 179.17,47.15 179.17,47.82 178.87,48.12 178.26,48.12 177.62,47.48 177.62,44.7 170.71,37.79 123.44,37.79 121.44,35.79 119.04,35.79 118.9,35.93 v2(118.9,36)
REM_DIODE3_P: length 365.6
  TOP w0.127: CE35.2 305.63,6.1 v2(305.63,5.78) ; QE11.1 26.85,54.56 26.85,54.54 26.59,54.29 QE11.2 26.59,52.84 CE68.1 27.43,52 27.43,51.76 28.58,50.62 29.38,50.62 29.75,50.99 29.75,51 v2(29.91,51) ; UE3.B16 302.52,11.41 v2(302.55,11.44)
  IN1 w0.127: v2(94.37,37.73) 94.25,37.85 92.64,37.85 91.91,37.13 87.28,37.13 84.63,34.48 84.63,34.48 84.46,34.3 81.44,34.3 80.36,33.22 76.32,33.22 75.3,32.2 71.06,32.2 67.88,29.02 54.07,29.02 53.5,28.46 41.53,28.46 38.67,31.31 38.67,37.88 35.62,40.92 35.62,43.15 34.93,43.85 34.93,44.84 34.16,45.6 34.16,45.79 33.48,46.48 33.48,46.99 33.08,47.38 33.08,48.35 32.83,48.6 32.83,48.82 30.22,51.44 30.03,51.44 29.91,51.32 v2(29.91,51)
  IN2 w0.127: v2(118.36,35.45) 118.36,35.73 117.91,36.18 117.03,36.18 112.38,40.83 98.02,40.83 95.09,37.89 94.54,37.89 v2(94.37,37.73)
  IN3 w0.127: v2(190.65,52.86) 190.48,52.69 190.48,52.45 190.59,52.33 195.25,52.33 196.62,53.71 198.21,53.71 198.77,54.26 200.92,54.26 201.45,53.73 202.99,53.73 203.67,54.41 207.17,54.41 209.98,51.6 211.93,51.6 215.89,47.65 219.22,47.65 233.28,33.58 253.22,33.58 261.28,25.52 262.24,25.52 263.97,23.8 264.17,23.8 v2(264.33,23.95)
  BOTTOM w0.127: v2(305.63,5.78) 305.31,6.1 305.31,6.71 305.51,6.92 305.72,6.92 305.99,7.19 305.99,9.03 305.31,9.71 303.31,9.71 302.88,10.14 302.88,11.11 v2(302.55,11.44) 302.06,10.94 302.06,9.86 302.4,9.52 302.4,8.85 302.15,8.59 302.15,6.23 300.11,4.19 281.55,4.19 278.55,7.19 278.55,17.14 278.07,17.63 278.07,18.36 275.77,20.66 275.77,22.66 273.81,24.62 265.48,24.62 264.67,23.81 264.47,23.81 v2(264.33,23.95) ; v2(190.65,52.86) 190.49,52.7 190.49,52.38 187.54,49.44 180.57,49.44 CE49.1 180.21,48.8 181.03,47.99 181.03,46.34 180.7,46.01 179.45,46.01 178.55,46.91 QE8.3 178.92,47.41 178.92,47.71 178.77,47.86 178.36,47.86 177.88,47.38 177.88,44.59 170.82,37.54 123.54,37.54 121.56,35.55 118.46,35.55 v2(118.36,35.45)
REM_DIODE4_N: length 223.3
  TOP w0.127: v2(312.74,32.43) 312.94,32.23 313.18,32.23 315.44,29.97 316.21,29.97 318.03,28.15 318.03,25.23 315.58,22.79 v4(315.58,21) 315.58,18.69 312.69,15.8 312.69,10.94 312.04,10.3 312.04,9.74 CE36.1 312.04,9.08 312.04,8.41 309.99,6.36 307.86,6.36 305.22,9 304.26,9 303.01,10.25 302.9,10.25 302.77,10.12 UE3.A16
  IN2 w0.127: v2(278.99,24.68) 279.16,24.85 279.16,25.09 279.44,25.38 282.97,25.38 284.34,24.01 287.73,24.01 288.54,24.81 290.07,24.81 292.4,27.14 293.2,27.14 296.28,30.22 299.48,30.22 299.68,30.43 303.04,30.43 304.58,31.96 308.77,31.96 309.08,32.27 312.57,32.27 v2(312.74,32.43)
  IN3 w0.127: v2(278.99,24.68) 278.82,24.51 265.05,24.51 249.25,40.31 249.25,51.6 247.36,53.48 244.13,53.48 242.87,52.23 240.11,52.23 239.27,53.07 239.27,58.82 240.38,59.92 240.93,59.92 241.35,60.35 241.35,61.67 243.75,64.07 247.82,64.07 248.62,64.86 248.62,80.32 247.92,81.02 247.92,87.35 248.35,87.78 248.35,96.39 247.13,97.61 247.13,100.57 242.83,104.87 242.83,114.54 v2(242.98,114.69)
  BOTTOM w0.127: QE9.3 239.93,115.91 240.11,115.73 241,115.73 CE72.1 241.5,115.58 242.4,115.58 242.81,115.16 242.81,114.86 v2(242.98,114.69) ; v2(278.99,24.68) 279.17,24.5 279.17,24.19 279.44,23.91 280.93,23.91 281.56,24.54 281.56,25.08 CE50.1 281.59,25.71 281.59,26.02 QE12.2 281.43,27.16 QE12.1
REM_DIODE4_P: length 220.1
  TOP w0.127: UE3.B17 303.02,10.6 304.37,9.25 305.32,9.25 307.96,6.62 309.88,6.62 311.79,8.52 311.79,9.08 CE36.2 311.79,9.74 311.79,10.4 312.43,11.05 312.43,15.9 315.33,18.8 315.33,22.89 317.77,25.34 317.77,28.04 316.1,29.71 315.34,29.71 313.08,31.97 312.87,31.97 v2(312.74,31.85)
  IN2 w0.127: v2(312.74,31.85) 312.57,32.01 309.18,32.01 308.88,31.71 304.69,31.71 303.15,30.17 299.78,30.17 299.58,29.97 296.39,29.97 293.31,26.89 292.5,26.89 290.17,24.56 288.64,24.56 287.84,23.75 284.23,23.75 282.86,25.12 279.55,25.12 279.41,24.99 279.41,24.86 v2(279.57,24.69)
  IN3 w0.127: v2(279.57,24.69) 279.57,24.67 279.16,24.25 264.95,24.25 249,40.2 249,51.49 247.26,53.23 244.23,53.23 242.97,51.97 240.01,51.97 239.02,52.97 239.02,58.92 240.27,60.18 240.82,60.18 241.1,60.45 241.1,61.77 243.65,64.32 247.72,64.32 248.36,64.97 248.36,80.22 247.66,80.92 247.66,87.45 248.1,87.88 248.1,96.28 246.88,97.5 246.88,100.46 242.57,104.77 242.57,114.51 v2(242.39,114.69)
  BOTTOM w0.127: QE9.2 238.9,115.26 QE9.1 240.07,115.48 240.69,115.48 CE72.2 241.5,115.32 242.29,115.32 242.56,115.06 242.56,114.86 v2(242.39,114.69) ; v2(279.57,24.69) 279.42,24.54 279.42,24.29 279.55,24.17 280.83,24.17 281.31,24.65 281.31,25.08 CE50.2 281.33,25.76 281.33,25.97 QE12.3
RESET_OUT#: length 404.6
  TOP w0.089: 101.98,5.94 101.44,5.94 101.09,5.6 101.09,4.97 v2(101.51,4.56)
  TOP w0.127: 101.98,5.94 103.87,5.94 104.56,6.63 104.56,7.57 104.37,7.76 104.37,8.95 106.48,11.06 111.59,11.06 113.14,12.61 113.14,15.93 112.52,16.55 112.52,16.74 112.05,17.22 109.34,17.22 108.79,17.77 105.65,17.77 102.48,20.94 102.09,20.94 99.9,23.13 99.9,24.61 98.93,25.58 98.93,27.36 101.94,30.37 105.9,30.37 115.67,40.15 v1(115.67,42.77) 115.67,46.35 v2(115.25,46.77)
  TOP w0.14: UE3.B39 301.02,19.69 300.87,19.54 300.87,19.15 v2(300.35,18.63) ; RE33.2 301.88,25.55 v2(302.52,24.91)
  IN2 w0.089: v2(101.51,4.56) 101.51,4.29 101.79,4.02 101.98,4.02
  IN2 w0.099: v2(315.07,7.29) 314.61,6.83 313.74,6.83 311.11,4.2 310.49,4.2 309.85,3.56 303.44,3.56 303.26,3.39 301.17,3.39 300.6,2.82 269.38,2.82 267.54,4.66 264.02,4.66 262.91,3.55 251.75,3.55 250.58,4.72 247.39,4.72 244.19,1.52 226.74,1.52 225.89,2.37 214.62,2.37 209.44,7.55 201.44,7.55 200.92,7.03 190.47,7.03 186.01,2.57 169.97,2.57 168.9,3.64 168.4,3.64 167.53,2.77 151.65,2.77 149.08,5.34 147.47,5.34 144.9,7.92 136.54,7.92 135.23,6.6 118.95,6.6 114.07,1.72 109.43,1.72 108.61,2.54 106.96,2.54 105.48,4.02 101.98,4.02
  IN3 w0.091: v2(315.07,7.29) 315.65,7.87 315.65,11.35 315.67,11.38 315.67,12.03 315.65,12.06 315.65,12.12 315.16,12.61 315.16,23.83 314.56,24.44 302.99,24.44 v2(302.52,24.91)
  IN4 w0.091: v2(300.35,18.63) 300.79,19.07 300.79,20.36 302.03,21.6 302.03,24.43 v2(302.52,24.91) ; v2(115.25,46.77) 117.16,48.68 117.16,52.22 117.62,52.68 117.62,54.83 117.73,54.94 117.73,63.11 119.69,65.07 119.82,65.07 121.83,67.08 121.83,68.36 124.78,71.32 124.78,85.42 123.19,87 123.19,92.08 123.22,92.08 123.6,92.46 123.6,92.49 123.85,92.74 123.88,92.74 124.26,93.13 124.26,93.15 124.49,93.38 124.92,93.38 v2(125.31,92.99)
  BOTTOM w0.089: UH2.AY1 100.09,6.47 101.09,5.47 101.09,4.97 v2(101.51,4.56)
  BOTTOM w0.127: 101.98,4.56 v2(101.51,4.56)
  BOTTOM w0.14: RH91.2 105.84,3.13 104.42,4.56 101.98,4.56 ; v2(125.31,92.99) 125.71,93.38 127.27,93.38 RH490.1
ROM_CS_GPU: length 4.8
  TOP w0.089: v2(221.5,68.34) 221.94,67.9 223.5,67.9 223.74,68.14 224.84,68.14 T176.1
  BOTTOM w0.089: UV1.H6 221.06,67.9 v2(221.5,68.34)
ROM_SCLK_GPU: length 8.7
  TOP w0.127: RV313.2 RV305.1 224.3,61.58 v2(224.6,61.27)
  IN4 w0.089: v2(220.59,65.9) 223.51,62.97
  IN4 w0.091: v2(224.6,61.27) 224.6,61.88 223.51,62.97
  BOTTOM w0.089: UV1.H4 220.94,66.25 v2(220.59,65.9)
ROM_SI_GPU: length 6.8
  TOP w0.089: v2(221.4,66.71) 221.83,66.28 222.47,66.28 222.67,66.07 222.67,64.8 222.96,64.51 223.15,64.51 v3(223.33,64.33) 223.84,63.83 223.84,63.65 RV304.1 RV312.2
  BOTTOM w0.089: UV1.H5 221.06,67.05 v2(221.4,66.71)
ROM_SO_GPU: length 17.4
  TOP w0.089: v2(220.65,68.32) 221.22,68.89 223.65,68.89 223.71,68.83 224.13,68.83 224.5,69.2 225.5,69.2 226.4,68.3
  TOP w0.127: RV311.2 232.99,64.03 231.71,64.03 231.41,64.33 230.85,64.33 v3(229.99,65.2) 226.89,68.3 226.4,68.3
  TOP w0.14: RV311.2 RV303.1
  BOTTOM w0.102: v2(220.65,68.32) 220.65,68.4 221,68.75 UV1.H7
RREF: length 3.3
  BOTTOM w0.203: 331.39,34.21 331.39,34.56 331.51,34.68 UR1.9
  BOTTOM w0.305: 331.39,34.21 331.39,33.26 v3(331.09,32.97) 330.92,32.8 RR6.2
RTD3_CIO_PWR_EN: length 86.5
  TOP w0.089: v1(80.28,18.51) 80.26,18.53 v2(79.68,18.53)
  IN6 w0.089: v2(79.68,18.53) 78.74,19.47 75.06,19.47 ; 27.28,34.3 27.28,34.63 26.32,35.59 23.66,35.59 22.23,37.03 22.23,38.11 22.61,38.49 23.45,38.49 24.61,39.65 24.61,40.98 26.16,42.53 26.16,43.19 27.06,44.09 27.06,44.39 25.65,45.81 25.3,45.81 v2(24.67,46.43)
  IN6 w0.099: 75.06,19.47 74.63,19.47 71.06,23.03 64.96,23.03 62.15,25.84 58.72,25.84 56.23,28.33 50.47,28.33 49.99,28.81 46.32,28.81 42.59,32.54 40.02,32.54 39.73,32.83 35.9,32.83 32.59,29.52 29.15,29.52 27.22,31.44 27.22,34.24 27.28,34.3
  BOTTOM w0.089: UH2.R39 80.41,19 79.99,18.58 79.73,18.58 v2(79.68,18.53)
  BOTTOM w0.102: RT39.2 24.84,47.39 24.84,46.61 v2(24.67,46.43) 24.67,46.24 24.27,45.84 UT1.F1
RTD3_USB_PWR_EN: length 13.1
  TOP w0.14: RT40.2 20.87,33.26 21.16,33.55 v2(21.34,33.55)
  IN3 w0.089: 21.75,34.3 21.75,34.86 22.37,35.49 22.37,36.37 21.8,36.94 21.8,41.37 22.63,42.2 22.63,44.03 v5(22.85,44.25)
  IN3 w0.091: v2(21.34,33.55) 21.75,33.96 21.75,34.3
  BOTTOM w0.089: UT1.D4 23.13,44.56 22.85,44.27 v5(22.85,44.25)
RUN_ON: length 25.7
  TOP w0.14: v3(304.8,27.06) 304.53,26.79 v2(304.24,26.79) 303.49,26.04 303.23,26.04 RE37.2 ; UE3.B9 299.02,11.77 v2(299.51,12.25)
  BOTTOM w0.14: v2(304.24,26.79) 304.82,26.22 305.84,26.22 306.91,25.15 306.91,19.16 306.46,18.72 306.46,18.17 306.2,17.91 304.84,17.91 303.09,16.16 300.92,16.16 300.14,15.39 300.14,12.89 v2(299.51,12.25)
RUN_ON#: length 4
  TOP w0.14: 311.02,13.47 RE56.2 311.02,12.16 v3(311.56,11.63) ; 311.02,13.47 311.43,13.47 311.67,13.71 QE4.6 ; 311.02,13.47 QE4.5
RUN_ON_EC: length 202.9
  TOP w0.127: UZ7.3 241.19,2.87 v2(240.64,2.32)
  TOP w0.14: UZ1.5 v2(315.14,35.01) 315.38,35.25 316.04,35.25 316.23,35.06 316.23,34.58 315.86,34.21 UZ1.3 ; v2(240.64,2.32) 239.95,1.63 RZ76.1 ; QE4.2 311.02,16.35 v2(311.54,16.87) 312.49,16.87 314.67,19.05 314.67,21.11 313.86,21.92 313.42,21.92 v3(312.94,22.4) 309.27,26.07 307.66,26.07 307.09,26.64 v2(305.33,26.64) 305.06,26.36 304.51,26.36 303.73,25.59 RE37.1 302.77,25.28 303.28,24.77 RE35.1 ; v2(180.21,6.49) 180.72,5.98 182.75,5.98 182.9,5.84 UZ20.1
  IN6 w0.099: v2(180.21,6.49) 180.56,6.14 182.47,6.14 183.98,7.65 210.43,7.65 215.7,2.38 238.71,2.38 239.23,1.86 240.18,1.86 v2(240.64,2.32) 240.64,1.99 240.91,1.72 244.31,1.72 247.65,5.06 252.8,5.06 254.18,3.67 262.49,3.67 263.62,4.8 266.77,4.8 268.55,3.02 295.04,3.02 295.92,3.91 306.09,3.91 308.06,5.88 309.98,5.88 v2(310.62,5.24)
  BOTTOM w0.14: v2(315.14,35.01) 315.08,35.07 RZ43.2 313.28,35.07 312.89,35.47 310.64,35.47 307.75,32.57 305.83,32.57 304.57,31.31 304.57,30.18 305.33,29.42 v2(305.33,26.64) ; v2(310.62,5.24) 311.58,6.21 311.58,11.17 311.14,11.61 311.14,16.47 v2(311.54,16.87)
RUN_ON_P: length 327.3
  TOP w0.14: v2(294.09,30.7) 293.06,30.7 292.75,30.39 PR610.2 ; UZ11.4 178.7,6.98 177.82,6.98 177.33,6.5 RZ58.2 176.96,13.41 178.33,14.78 178.33,19.62 178.03,19.92 178.03,24.86 v2(178.19,25.03) ; v1(112.65,65.43) 115.91,65.43 118.97,62.36 123.36,62.36 125.33,64.33 130.11,64.33 v2(130.27,64.49) 131.03,64.49 131.45,64.08 132.78,64.08 133.08,64.39 RZ90.1
  TOP w0.254: v1(112.65,65.43) v2(110.57,65.43) RZ50.1
  IN2 w0.099: v2(294.09,30.7) 293.29,30.7 292.97,30.38 292.97,29.82 289.25,26.1 287.16,26.1 286.48,26.78 282.35,26.78 281.81,27.31 278.69,27.31 274.78,23.4 268.31,23.4 267.24,22.33 264.41,22.33 264.19,22.56 263.6,22.56 263.2,22.16 260.58,22.16 259.44,23.29 258.43,23.29 257.29,22.14 254.49,22.14 253.06,20.72 252.2,20.72 251.78,21.13 250.96,21.13 v2(250.86,21.03) ; v2(184.47,63.7) 184.92,64.16 190.26,64.16 v2(190.65,63.76)
  IN5 w0.099: v2(250.86,21.03) 250.86,21.22 249.85,22.23 249.85,24.36 248.22,25.99 227.43,25.99 223.79,29.64 186.17,29.64 184.56,28.03 181.2,28.03 v2(178.19,25.03)
  IN6 w0.089: 181.1,63.19 179.87,63.19 177.47,65.59 177.47,67.75 176.41,68.81 175.66,68.81 174.87,69.6 174.36,69.6 174.15,69.8 164.02,69.8 163.79,69.57 161.05,69.57 159.98,70.65 156.08,70.65 155.17,69.74 151.69,69.74 150.14,71.29 144.41,71.29 143.43,70.32 141.97,70.32 141.14,69.48 138.18,69.48
  IN6 w0.099: 138.18,69.48 137.71,69.01 133.36,69.01 132.25,67.89 132.25,67.31 130.27,65.33 v2(130.27,64.49) ; v2(184.47,63.7) 183.96,63.19 181.1,63.19 ; v2(178.19,25.03) 180.47,27.3 180.47,31.66 193.11,44.3 193.11,58.93 193.09,58.95 193.09,59.94 190.65,62.37 v2(190.65,63.76) 190.65,64.32 189.12,65.86 186.18,65.86 181.95,70.09 181.95,79.02 181.55,79.42 181.55,85.94 182.3,86.69 v2(182.3,87.59)
  BOTTOM w0.14: UZ9.4 182.26,86.91 182.13,87.04 182.13,87.42 v2(182.3,87.59)
  BOTTOM w0.254: RZ50.1 v2(110.57,65.43)
RUNPWROK: length 226.3
  TOP w0.127: UH14.2 112.35,7.12 v2(112.68,6.79)
  TOP w0.14: UE3.B26 303.29,15.38 303.23,15.31 302.65,15.31 v2(302.21,14.87) ; QE4.3 310.37,15.12 310.07,14.82 RE52.2 308.52,14.09 308.12,14.09 v2(307.9,13.88) 307.9,13.45 v3(308.28,13.06)
  IN3 w0.091: v2(302.21,14.87) 302.6,14.47 303.37,14.47 303.95,13.89 307.89,13.89 v2(307.9,13.88) 308.19,13.59 308.19,10.37 309.35,9.21 v2(309.35,8.05)
  IN6 w0.099: v2(309.35,8.05) 308.93,8.48 308.14,8.48 307.42,7.76 306.71,7.76 306.02,7.07 302.08,7.07 301.18,6.17 300.09,6.17 299.39,6.87 284.32,6.87 282.76,5.31 272.17,5.31 271.63,5.85 268.63,5.85 267.82,6.66 263.21,6.66 262.9,6.36 256.92,6.36 256.82,6.46 246.19,6.46 245.21,5.48 227.86,5.48 227.24,6.1 214.03,6.1 210.99,9.13 174.22,9.13 173.39,8.3 171.8,8.3 170.68,7.18 163.72,7.18 162.9,6.36 158.51,6.36 157.55,5.39 152.34,5.39 151.63,6.1 148.28,6.1 144.91,9.47 135.66,9.47 134.63,8.45 127.05,8.45 126.31,9.19 118.55,9.19 117.81,8.45 117.26,8.45 115.6,6.79 v2(112.68,6.79)
S5_1.2V: length 4.4
  TOP w0.14: v1(290.67,28.58) 290.67,28.76 291.06,29.16 v2(291.15,29.16)
  TOP w0.254: v2(291.15,29.16) 291.83,28.47 PC613.1
  BOTTOM w0.203: PU600.8 290.67,29.64 v2(291.15,29.16) 291.83,28.47 PC613.1
SATA_PRX_DTX_N1B: length 165
  IN6 w0.119: v2(234.99,14.04) 235.11,13.92 235.11,13.74 234.99,13.62 231.97,13.62 229.45,16.14 186.05,16.14 185.53,15.62 168.82,15.62 168.07,14.88 161.27,14.88 160.48,15.67 129.68,15.67 129.22,16.13 105.1,16.13 104.76,15.79 102.55,15.79 102.25,16.08 102.25,16.59 101.59,17.25 93.84,17.25 92.78,18.31 92.78,18.89 92.94,19.05 92.94,19.81 92.72,20.04 92.72,20.72 92.11,21.34 88.96,21.34 88.41,21.88 88.41,23.46 88.1,23.78 88.04,23.83 87.88,24 87.87,24 87.64,24.23 81.68,24.23 80.92,23.47 v2(80.79,23.47)
  BOTTOM w0.089: v2(80.79,23.47) 80.85,23.53 80.85,24.02 80.79,24.09 80.79,24.09 UH2.D39
  BOTTOM w0.17: CS20.1 235.03,13.62 235.03,14 v2(234.99,14.04)
SATA_PRX_DTX_N1B_RC: length 2.2
  BOTTOM w0.17: CS20.2 235.01,12.32 235.01,11.58 234.86,11.43 JHDD.8
SATA_PRX_DTX_P1B: length 164.9
  IN6 w0.119: v2(235.57,14.04) 235.37,13.84 235.37,13.63 235.1,13.36 231.87,13.36 229.35,15.88 186.15,15.88 185.64,15.36 168.93,15.36 168.18,14.62 161.17,14.62 160.37,15.41 129.57,15.41 129.11,15.87 105.21,15.87 104.86,15.53 102.44,15.53 101.99,15.97 101.99,16.48 101.48,16.99 93.73,16.99 92.52,18.2 92.52,19 92.69,19.16 92.69,19.71 92.46,19.93 92.46,20.61 92,21.08 88.85,21.08 88.15,21.78 88.15,23.35 87.91,23.59 87.86,23.64 87.69,23.81 87.54,23.97 81.79,23.97 81.43,23.61 v2(81.43,23.43)
  BOTTOM w0.089: UH2.E37 81.3,23.97 81.2,23.87 81.2,23.66 v2(81.43,23.43)
  BOTTOM w0.17: CS19.1 235.64,13.42 235.46,13.6 235.46,13.93 v2(235.57,14.04)
SATA_PRX_DTX_P1B_RC: length 2.2
  BOTTOM w0.17: JHDD.9 235.36,11.32 235.45,11.4 235.45,12.24 CS19.2
SATA_PRX_SSDTX_N0A: length 186.4
  IN6 w0.119: v2(83.96,22.66) 83.96,22.4 84.05,22.31 84.42,22.31 84.64,22.08 84.64,20.37 84.93,20.09 86.79,20.09 87.05,20.34 91.1,20.34 91.71,19.73 91.71,18.1 93.03,16.79 98.91,16.79 99.66,16.03 101.19,16.03 102.16,15.06 105,15.06 105.34,15.4 128.99,15.4 129.39,14.99 160.2,14.99 161.03,14.16 168.32,14.16 168.91,14.75 185.67,14.75 186.38,15.45 229.02,15.45 231.54,12.93 249.76,12.93 251.01,11.69 258.43,11.69 258.75,12.01 258.75,12.16 v2(258.56,12.35)
  BOTTOM w0.101: UH2.G31 84.41,23.08 v2(83.96,22.66)
  BOTTOM w0.17: v2(258.56,12.35) 258.56,12.28 258.94,11.9 259.35,11.9 259.5,12.04 JNGFF2.43
SATA_PRX_SSDTX_P0A: length 186.5
  IN6 w0.119: v2(259.14,12.35) 259.01,12.22 259.01,11.9 258.54,11.43 250.9,11.43 249.66,12.68 231.43,12.68 228.91,15.2 186.49,15.2 185.78,14.49 169.02,14.49 168.43,13.9 160.92,13.9 160.09,14.73 129.28,14.73 128.88,15.14 105.45,15.14 105.11,14.8 102.05,14.8 101.08,15.77 99.55,15.77 98.8,16.53 92.92,16.53 91.45,18 91.45,19.62 90.99,20.08 87.15,20.08 86.9,19.83 84.82,19.83 84.38,20.26 84.38,21.97 84.31,22.05 84.09,22.05 v2(83.98,21.94)
  BOTTOM w0.101: v2(83.98,21.94) 84.39,22.32 UH2.H31
  BOTTOM w0.17: v2(259.14,12.35) 258.99,12.51 258.99,12.79 259.12,12.91 259.39,12.91 259.75,12.54 JNGFF2.41
SATA_PTX_DRX_N1B: length 166.3
  IN6 w0.119: v2(233.68,14.04) 233.61,14.12 233.61,16.73 232.58,17.76 186.51,17.76 185.1,16.36 168.58,16.36 167.8,15.57 161.54,15.57 160.76,16.36 129.96,16.36 128.73,17.58 102.23,17.58 102.07,17.74 94.23,17.74 93.8,18.18 93.8,22.98 92.6,24.17 88.97,24.17 87.38,25.76 81.67,25.76 80.62,24.71 v2(80.49,24.71)
  BOTTOM w0.089: v2(80.49,24.71) 80.54,24.71 81.13,25.29 UH2.B38
  BOTTOM w0.17: CS18.1 233.62,13.61 233.62,13.98 v2(233.68,14.04)
SATA_PTX_DRX_N1B_RC: length 2.2
  BOTTOM w0.17: CS18.2 233.62,12.32 233.62,11.67 233.86,11.43 JHDD.6
SATA_PTX_DRX_P1B: length 166.3
  IN6 w0.119: v2(233.1,14.04) 233.35,14.3 233.35,16.62 232.47,17.5 186.61,17.5 185.21,16.1 168.69,16.1 167.91,15.32 161.44,15.32 160.66,16.1 129.85,16.1 128.62,17.32 102.12,17.32 101.96,17.48 94.12,17.48 93.54,18.07 93.54,22.87 92.5,23.91 88.86,23.91 87.28,25.5 81.78,25.5 80.85,24.57 80.85,24.37 80.98,24.24 81.08,24.24 v2(81.2,24.37)
  BOTTOM w0.089: v2(81.2,24.37) 81.14,24.3 80.99,24.3 80.9,24.39 80.9,24.59 UH2.C38
  BOTTOM w0.17: v2(233.1,14.04) 233.18,13.96 233.18,13.53 233.08,13.42 CS17.1
SATA_PTX_DRX_P1B_RC: length 2.2
  BOTTOM w0.17: JHDD.5 233.36,11.32 233.19,11.49 233.19,12.24 CS17.2
SATA_PTX_SSDRX_N0A: length 190.2
  IN6 w0.119: v2(84.8,27.54) 84.58,27.54 84.49,27.45 84.49,27.31 85.05,26.76 87.4,26.76 88.79,25.36 92.54,25.36 94.34,23.56 94.34,18.53 94.66,18.21 100.68,18.21 101.07,18.61 102.17,18.61 102.51,18.27 129.42,18.27 130.1,17.58 162.51,17.58 163.66,16.43 167.49,16.43 168.61,17.55 185.06,17.55 186.02,18.52 234.46,18.52 235.94,17.04 235.94,16.24 237.25,14.93 238.65,14.93 239.88,13.7 255.17,13.7 255.94,12.92 255.94,12.36 v2(256.12,12.19)
  BOTTOM w0.089: v2(84.8,27.54) 84.8,27.28 84.99,27.1 84.99,26.29 84.65,25.94 84.65,25.26 84.46,25.07 UH2.C31
  BOTTOM w0.17: CD53.1 256.64,10.73 256.3,10.73 255.76,11.27 255.76,12.1 255.93,12.26 256.04,12.26 v2(256.12,12.19)
SATA_PTX_SSDRX_N0A_C: length 2.6
  BOTTOM w0.17: JNGFF2.47 259.41,11.04 259.37,11.01 v3(259.03,11.01) 258.19,11.01 CD53.2
SATA_PTX_SSDRX_P0A: length 190.1
  IN6 w0.119: v2(255.33,12.19) 255.69,12.54 255.69,12.82 255.06,13.44 239.77,13.44 238.54,14.67 237.14,14.67 235.68,16.14 235.68,16.93 234.35,18.26 186.13,18.26 185.17,17.29 168.72,17.29 167.59,16.17 163.56,16.17 162.4,17.32 130,17.32 129.31,18.01 102.4,18.01 102.06,18.35 101.18,18.35 100.79,17.95 94.55,17.95 94.08,18.43 94.08,23.45 92.43,25.1 88.69,25.1 87.29,26.5 84.94,26.5 84.21,27.22 v2(84.21,27.71)
  BOTTOM w0.089: UH2.B31 84.36,25.5 84.44,25.59 84.44,26.02 84.8,26.37 84.8,26.97 84.21,27.56 v2(84.21,27.71)
  BOTTOM w0.17: CD51.1 256.12,10.3 255.33,11.09 v2(255.33,12.19)
SATA_PTX_SSDRX_P0A_C: length 2.6
  BOTTOM w0.17: CD51.2 258.3,10.58 259.37,10.58 259.41,10.54 JNGFF2.49
SD_CD#: length 18.1
  TOP w0.14: JCR.8 328.42,44.9 329.44,43.89 329.88,43.89 330.91,42.86 330.91,38.09 331.41,37.6 335.06,37.6 335.32,37.34 335.32,36.55 336.68,35.19 337.01,35.19 v2(337.08,35.11)
  BOTTOM w0.14: UR1.30 336.33,35.48 336.69,35.11 v2(337.08,35.11)
SD_CLK: length 22.5
  TOP w0.14: v2(329.02,45.73) 328.45,46.3 JCR.6
  BOTTOM w0.14: RR4.2 CR8.1 325.13,40.73 325.01,40.85 325.01,41.17 325.13,41.29 v1(326.18,41.29) 329.06,41.29 329.19,41.42 329.19,41.72 329.06,41.85 325.79,41.85 325.67,41.98 325.67,42.3 325.79,42.43 328.76,42.43 328.89,42.55 328.89,45.6 v2(329.02,45.73)
SD_CLK_R: length 9.7
  BOTTOM w0.14: UR1.17 332.48,38.39 332.3,38.58 331.56,38.58 RR4.1 330.33,39.46 330.1,39.23 328.99,39.23 328.02,40.2 326.56,40.2 v1(325.08,38.73)
SD_CMD: length 22.3
  TOP w0.14: v2(336.87,48.21) 336.72,48.35 330.26,48.35 328.8,49.81 328.8,52.83 328.38,53.25 JCR.3
  BOTTOM w0.14: RR5.2 333.21,41.07 333.21,42.17 v1(333.57,42.53) 336.87,45.83 v2(336.87,48.21)
SD_CMD_R: length 1.9
  BOTTOM w0.14: UR1.19 333.28,39.39 RR5.1
SD_D2: length 25.5
  TOP w0.14: v2(338.08,48.71) 337.25,49.54 330.54,49.54 329.85,50.24 329.85,54.47 328.26,56.05 JCR.1
  BOTTOM w0.14: RR8.2 334.65,42.03 338.08,45.46 v1(338.08,46.63) v2(338.08,48.71)
SD_D2_R: length 1.9
  BOTTOM w0.14: RR8.1 334.08,39.25 UR1.21
SD_D3: length 24.2
  TOP w0.14: v2(336.93,49.09) 336.83,48.99 330.35,48.99 329.32,50.02 329.32,53.83 328.51,54.65 JCR.2
  BOTTOM w0.14: v2(336.93,49.09) 337.5,48.52 337.5,45.69 v1(336.95,45.14) 333.76,41.94 RR7.2
SD_D3_R: length 1.7
  BOTTOM w0.14: UR1.20 333.68,39.74 RR7.1
SD_LN0_M: length 25
  TOP w0.102: v2(338.79,37.18) 338.25,37.18 338.01,37.41 338.01,37.74 342.18,41.91 342.18,44.57 344.82,47.21 344.82,50.82 346.39,52.39 346.97,52.39 347.58,51.78 JCR.14
  BOTTOM w0.102: UR1.25 336.32,37.48 336.77,37.93 337.83,37.93 338.12,37.64 338.12,37.43 338.37,37.18 v2(338.79,37.18)
SD_LN0_P: length 25
  TOP w0.102: v2(337.14,37.18) 337.52,37.18 337.74,37.4 337.74,37.85 337.82,37.93 341.92,42.02 341.92,44.68 344.55,47.32 344.55,50.93 346.28,52.66 347.05,52.66 347.66,53.28 JCR.13
  BOTTOM w0.102: v2(337.14,37.18) 337.66,37.18 337.85,37.37 337.85,37.53 337.72,37.66 336.89,37.66 336.3,37.08 UR1.26
SD_LN1_M: length 29.7
  TOP w0.102: v2(337.09,42.17) 336.93,42.01 336.93,37.86 336.43,37.36 336.43,36.94 336.84,36.53 342.25,36.53 344.57,38.85 345.33,39.61 345.33,44.29 346.11,45.07 347.16,45.07 347.3,45.21 347.3,45.53 347.55,45.78 347.6,45.78 JCR.17
  BOTTOM w0.102: UR1.23 334.88,38.83 335.74,39.69 335.74,41.53 335.95,41.74 336.66,41.74 v2(337.09,42.17)
SD_LN1_P: length 29.7
  TOP w0.102: JCR.18 347.62,44.28 347.09,44.8 346.22,44.8 345.59,44.18 345.59,39.5 344.84,38.74 342.36,36.27 336.73,36.27 336.17,36.83 336.17,37.47 336.67,37.97 336.67,42.01 v2(336.51,42.17)
  BOTTOM w0.102: v2(336.51,42.17) 336.34,42.01 335.84,42.01 335.47,41.64 v4(335.47,41.37) 335.47,39.8 334.62,38.94 334.62,38.68 334.48,38.55 UR1.22
SD_RCLK_M: length 22.4
  TOP w0.102: v2(327.28,37.56) 327.15,37.69 327.15,38.36 326.87,38.64 324.95,38.64 324.66,38.36 324.66,37.36 324.54,37.23 323.86,37.23 323.74,37.36 323.74,40.08 323.86,40.2 324.38,40.2 324.51,40.08 324.51,39.54 324.8,39.25 326.25,39.25 326.51,39.5 326.51,40.1 326.22,40.38 325.68,40.38 325.55,40.51 325.55,41.54 325.68,41.67 326.47,41.67 326.58,41.56 326.58,40.78 326.65,40.7 JCR.10
  BOTTOM w0.102: RR2.2 328.23,37.97 328.06,37.97 327.78,38.25 327.78,39.1 327.59,39.29 v4(327.31,39.29) 327,39.29 326.78,39.07 326.78,38.53 327.09,38.22 327.09,37.75 v2(327.28,37.56)
SD_RCLK_M_R: length 2.8
  BOTTOM w0.102: UR1.15 331.06,37.08 330.83,37.31 330.7,37.31 330.09,37.91 329.83,37.91 RR2.1
SD_RCLK_P: length 22.5
  TOP w0.102: JCR.9 326.65,42.1 326.58,42.03 326.58,42.03 326.47,41.93 325.57,41.93 325.29,41.65 325.29,40.4 325.57,40.12 326.11,40.12 326.24,39.99 326.24,39.61 326.14,39.51 324.91,39.51 324.78,39.65 324.78,40.19 324.49,40.47 323.75,40.47 323.47,40.19 323.47,37.25 323.75,36.97 324.65,36.97 324.93,37.25 324.93,38.25 325.06,38.38 326.76,38.38 326.89,38.25 326.89,37.8 v2(326.65,37.56)
  BOTTOM w0.102: RR3.2 328.35,38.23 328.17,38.23 328.04,38.36 328.04,39.21 327.7,39.56 326.89,39.56 326.52,39.18 326.52,38.42 326.82,38.11 326.82,37.74 v2(326.65,37.56)
