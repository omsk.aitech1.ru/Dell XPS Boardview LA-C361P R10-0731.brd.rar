# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
1.2V_FB: length 5.4
  TOP w0.14: v2(291.02,31) 290.55,31.47 v1(290.55,31.94)
  TOP w0.254: PR604.1 291.21,31.19 v2(291.02,31)
  BOTTOM w0.203: PR607.1 PR604.1 291.21,31.19 v2(291.02,31) 290.46,30.44 PU600.6
1.05V_DGPU_PG: length 22.5
  TOP w0.14: v2(222.95,52.84) 223.06,52.84 v3(223.48,52.42)
  TOP w0.254: PR907.1 v2(222.95,52.84)
  IN3 w0.091: v2(207.9,58.99) 208.08,58.99 209.52,57.54 209.52,56.87 209.31,56.67 209.31,54.44 209.93,53.83 216.31,53.83 217.29,52.84 v2(222.95,52.84)
  BOTTOM w0.14: DV9.2 208.65,59.73 v2(207.9,58.99)
1.05VA_PG: length 3
  TOP w0.254: PU900.2 220.11,52.25 v3(220.43,52.57) 220.7,52.84 PR907.2 PR905.2
3.3V_CAM_EN#: length 376.6
  TOP w0.14: v2(40.81,25.87) 40.47,25.53 QZ9.2
  IN1 w0.099: v2(347.17,43.37) 347.17,43.37 345.89,42.09 345.89,37.79 339.65,31.56 329.5,31.56 328.13,30.19 327.32,30.19 326.95,29.82 326.95,21.89 326.03,20.96 322.26,20.96 321.57,20.28 321.57,13.53 317.37,9.33 317.36,9.33 v2(316.8,8.77) ; v2(46.59,23.82) 46.31,23.82 45.85,23.36 45.7,23.21 43.03,23.21 40.81,25.43 v2(40.81,25.87)
  IN2 w0.089: v2(93.2,3.29) 93.2,3.29 93.2,3.29 92.67,3.29 92.25,2.88 91.07,2.88 90.87,2.68 90.87,1.85 90.61,1.59 90.27,1.59 89.72,2.14 87.76,2.14 87.44,2.46 87.44,3.27 87.22,3.49 86.83,3.49 86.13,2.8 84.15,2.8 83.77,2.42 83.77,1.89 83.78,1.88 83.77,1.88 83.77,1.48 83.69,1.41
  IN2 w0.099: 83.69,1.41 83.63,1.34 74.53,1.34 73.81,2.07 73.22,2.07 72.49,1.34 66.28,1.34 65.23,2.4 59.02,2.4 55.75,5.66 55.75,6.92 53.88,8.79 53.88,10.13 54.3,10.55 54.3,11.45 54.82,11.98 54.82,13.52 54.99,13.7 54.99,14.55 56.26,15.82 56.26,17.98 50.33,23.91 46.68,23.91 v2(46.59,23.82)
  IN5 w0.089: v2(93.2,3.29) 93.85,3.95 94.32,3.95 95.2,3.06 95.76,3.06 96.27,2.55 98.84,2.55 100.13,3.84 101.98,3.84
  IN5 w0.099: 101.98,3.84 104.81,3.84 106.54,2.1 110.05,2.1 110.29,1.86 114.28,1.86 118.92,6.51 133.37,6.51 134.58,7.72 144.77,7.72 147.47,5.01 159.29,5.01 159.54,4.76 165.23,4.76 165.89,4.1 168.55,4.1 170.19,2.46 181.07,2.46 186.69,8.09 211.07,8.09 211.51,7.64 217.61,7.64 217.83,7.86 226.65,7.86 227.94,6.57 234.85,6.57 236.19,7.9 252.39,7.9 253.17,8.68 261.74,8.68 262.89,7.54 273.85,7.54 275.73,5.65 281.92,5.65 283.1,4.47 301.23,4.47 301.85,5.09 307.07,5.09 308.28,6.31 310.1,6.31 312.09,8.3 316.33,8.3 v2(316.8,8.77)
  BOTTOM w0.089: v2(93.2,3.29) 93.35,3.44 93.35,4.25 93.16,4.44 UH2.BD14
  BOTTOM w0.14: RZ38.1 346.03,43.16 346.96,43.16 v2(347.17,43.37) 347.18,43.38 347.59,43.38 v1(347.82,43.61)
3.3V_MSATA_EN: length 30.5
  TOP w0.14: v3(62.74,3.88) 62.74,3.56 v2(62.43,3.26) 62.19,3.5 RH423.1
  IN5 w0.089: v2(86.32,2.34) 85.5,2.34 84.93,2.9 83.73,2.9 82.85,2.02 75.08,2.02 75.06,2.05
  IN5 w0.099: v2(62.43,3.26) 62.84,3.67 63.83,3.67 63.93,3.56 65.92,3.56 66.4,3.08 68.2,3.08 68.47,3.36 68.94,3.36 69.66,4.08 71.65,4.08 72.14,3.59 73.52,3.59 75.06,2.05
  BOTTOM w0.089: v2(86.32,2.34) 86.32,2.98 86.6,3.27 86.6,3.59 86.48,3.72 86.48,4.3 86.34,4.43 UH2.BD27
3.3V_TS_EN: length 297.4
  IN2 w0.089: 101.98,11.77 100.92,11.77 99.96,10.8 92.93,10.8 91.62,9.5 90.46,9.5 90.2,9.24 89.11,9.24 88.83,8.97 87.64,8.97 87.14,9.47 v2(84.9,9.47)
  IN2 w0.099: 101.98,11.77 102.55,11.77 102.7,11.92 112.75,11.92 115.41,14.58 121.48,14.58 122.18,13.88 152.12,13.88 154.74,11.26 159.34,11.26 160.11,10.49 163.21,10.49 164,11.28 174.71,11.28 175.23,10.77 210.69,10.77 213.73,7.73 226.32,7.73 227.71,6.34 238.31,6.34 240.15,8.18 245.29,8.18 245.6,8.49 245.72,8.49 245.72,8.49 252.48,8.49 253.22,7.75 255.71,7.75 256.74,8.78 262.53,8.78 262.78,8.53 273.11,8.53 275.09,6.55 281.82,6.55 282.57,7.3 287.78,7.3 287.93,7.15 292.31,7.15 292.85,6.6 296.36,6.6 296.78,7.03 309.56,7.03 314.71,12.17 318.44,12.17 321.72,15.46 321.72,22.37 326.85,27.49 329.18,27.49 330.47,28.79 335.51,28.79 336.47,29.74 338.58,29.74 345.21,36.37 345.21,42.4 v2(344.81,42.81)
  BOTTOM w0.089: UH2.AR29 v2(84.9,9.47)
  BOTTOM w0.14: v3(346.13,44.87) 346.13,44.36 RZ39.1 345.58,43.58 v2(344.81,42.81) 344.24,42.24 UZ5.3
3V3_MAIN_EN: length 120.6
  TOP w0.102: UZ17.3 232.83,60.84 232.88,60.79 234.8,60.79 v2(234.86,60.85)
  TOP w0.14: RPH34.2 216.55,58.42 216.41,58.57 216.41,59.19 216.69,59.47 v2(216.69,59.51) ; PR1028.2 PR913.2 167.32,102.17 v2(167.98,101.51) 168.24,101.51 169.31,102.58 v1(171.08,102.58)
  IN3 w0.091: v2(216.69,59.51) 217.11,59.93 219.83,59.93 220.85,58.9 221.65,58.9 222.31,59.56 222.91,59.56 223.25,59.9 227.39,59.9 229.08,61.59 229.56,61.59 230.67,62.71 234.25,62.71 234.86,62.1 v2(234.86,60.85)
  IN5 w0.089: 217.58,62.97 218.12,63.51 218.12,67.6 v2(218.86,68.33)
  IN5 w0.099: 217.58,60.4 217.58,62.97
  IN5 w0.102: 217.58,60.4 v2(216.69,59.51) 215.81,60.38 211.67,60.38 210.41,61.64 198.46,61.64 196.34,63.76 196.34,65.43 194.62,67.15 194.62,82.59 189.56,87.65 185.09,87.65 179.11,93.63 171.53,93.63 170.63,94.54 170.63,98.87 v2(167.98,101.51)
  BOTTOM w0.102: v2(218.86,68.33) 218.5,68.69 UV1.L7
3V/5VALW_EN: length 14.2
  TOP w0.14: v2(348.93,25.41) 349.15,25.41 349.39,25.65 v1(349.39,25.92)
  TOP w0.254: PR408.1 346.08,24.9 346.56,25.38 PR326.2 348.02,25.38 PC335.1 v2(348.93,25.41)
  BOTTOM w0.254: PR409.2 347.68,18.06 346.33,19.4 346.33,21.9 347.16,22.73 347.16,24.58 347.98,25.41 v2(348.93,25.41)
5VS_FAN1: length 4.3
  TOP w0.14: v2(96.79,36.66) 96.18,36.66 v1(95.8,36.28)
  TOP w0.508: RE104.2 97.03,36.42 v2(96.79,36.66)
  BOTTOM w0.508: JFAN1.2 97.25,36.2 v2(96.79,36.66)
5VS_FAN2: length 4
  TOP w0.14: v1(323.51,41.63) 323.23,41.91 RE105.2
  TOP w0.508: RE105.2 322.2,41.09 v2(322.14,41.03)
  BOTTOM w0.508: v2(322.14,41.03) 322.14,40.87 321.5,40.23 JFAN2.2
+0.6VS: length 132.2
  TOP w1.524: 283.52,25.89 280.96,23.34 278.82,23.34 277.87,22.39 275.49,22.39 269.5,16.39 268.54,16.39 265,12.85 265,6.18 262.19,3.37 258.45,3.37 257.57,4.25 257.57,7.57 251.85,13.28 251.85,16.09
  IN4 w1.524: 250.12,15.51 249.07,14.46 244.26,14.46 243.49,15.24 223.3,15.24 222.58,14.51 221.02,14.51 220.03,15.5 177.51,15.5 176.44,16.57
  BOTTOM w0.305: JDIMM1.258 173.63,17.27 173.91,16.98 v2(173.91,16.86) ; JDIMM2.258 249.93,17.28 249.76,17.12 v2(249.76,16.8)
  vias: v1(175.24,16.19) v2(174.57,16.87) v2(175.15,16.87) v2(250.35,16.8) v2(250.93,16.8)
+0.6VSP: length 2.9
  TOP w0.508: v2(287.66,32.01) 287.66,31.38 287.08,30.81 286.64,30.81
  BOTTOM w0.203: PU600.2 287.87,31.68 287.66,31.89 v2(287.66,32.01)
  vias: v1(286.06,30.16) v2(285.41,30.81) v2(286.01,30.81)
+0.95VSP: length 99
  TOP w0.254: v2(172.3,72.94) 171.82,72.46 PR813.1 ; v2(105.86,66.05) 105.86,65.86 106.17,65.54 PC807.1
  IN1 w0.254: v2(115.57,61.54) 116.37,60.74 116.37,57.1 114.58,55.32 104.78,55.32 103.76,56.33 103.76,64.78 104.46,65.48 105.52,65.48 105.86,65.82 v2(105.86,66.05)
  IN2 w0.508: v2(116.21,62.81) 117.6,62.81 120.14,65.35 123.52,65.35 124.42,66.25 129.09,66.25 130.39,67.56 v2(130.39,67.73)
  IN6 w0.508: v2(130.39,67.73) 130.84,68.18 130.84,69.47 132.42,71.05 136.97,71.05 138.14,72.22 141.45,72.22 143.66,74.43 143.66,77.31 144.96,78.61 155.62,78.61 157.1,77.14 166.21,77.14 170.64,72.7 172.06,72.7 v2(172.3,72.94)
  vias: v1(117.26,62.44) v2(115.57,62.81) v2(115.57,62.18) v2(116.21,62.18)
+1.2V_DDR: length 160.5
  TOP w0.381: CH197.1 121.4,53.21 UC1.5
  TOP w0.508: v2(145.1,16.86) 145.52,17.28 CD70.1 ; v2(149.54,16.87) 149.14,17.28 CD71.1 ; 127.23,52.41 127.09,52.27 v2(122.66,52.27) 122.12,52.27 121.37,53.01 CH197.1
  IN2 w0.508: v2(132.84,66.18) 130.01,66.18 129.42,65.58 126.14,65.58 122.24,61.69 122.24,58.21 122.58,57.87 123.05,57.87 124.11,56.81 124.11,54.13 122.66,52.69 v2(122.66,52.27)
  IN3 w0.508: v2(110.17,16.66) 110.17,16.32 110.56,15.93 119.8,15.93 120.42,16.56 v2(120.42,16.68)
  BOTTOM w0.203: UH1.AW6 149.77,62.99 v2(149.42,62.65) 149.37,62.65 UH1.AY6 ; UH1.AG5 159.17,62.34 v2(159.48,62.65) ; UH1.AG9 v2(159.42,65.4) ; v2(159.48,62.65) 159.79,62.34 UH1.AF5 ; v2(159.48,62.65) 159.58,62.65 UH1.AF6 ; UH1.K6 172.3,63.18 171.85,63.18 171.66,62.99 UH1.L6 ; UH1.AJ12 156.96,66.9 v2(156.68,66.61) 156.31,66.25 UH1.AL11
  BOTTOM w0.254: UH1.L12 171.96,67.1 172.4,67.1 UH1.K12 172.91,66.59 v2(173.01,66.59) ; v2(151.94,62.62) 152.01,62.62 UH1.AR6 UH1.AP6 153.48,63.25 UH1.AP7 ; UH1.AR12 152.43,66.9 v2(152.1,66.57) 151.78,66.9 UH1.AT12 ; UH1.AE12 160.68,66.9 v2(160.39,67.19) ; UH1.AA6 164.11,62.98 v2(164.5,62.6) 164.88,62.99 UH1.W6 ; UH1.T6 167.35,62.99 v2(167.02,62.66) ; UH1.K6 UH1.J6 173.4,62.99 v2(173.73,62.65) 173.42,62.34 UH1.J5
  BOTTOM w0.305: v2(221.36,16.86) 221.99,16.86 222.43,17.29 JDIMM2.148 ; JDIMM2.111 211.18,28.83 210.8,29.21 v2(210.6,29.21) ; JDIMM2.178 229.93,19.41 v2(230.31,19.8) ; v2(219.04,16.86) 218.93,16.98 JDIMM2.142 ; UH1.R6 UH1.T6 ; v2(196.98,16.87) 196.92,16.92 JDIMM2.54 ; JDIMM2.220 240.42,17.01 240.35,16.93 v2(240.35,16.87) ; JDIMM1.96 131.12,16.9 v2(131.13,16.9) ; JDIMM1.123 137.88,27.75 v2(138.08,27.95) ; JDIMM2.33 191.68,27.3 191.74,27.37 191.74,27.93 191.41,28.26 v2(191.16,28.26) ; JDIMM2.160 225.42,17.27 225.84,16.86 v2(225.84,16.86) ; JDIMM2.135 217.18,27.66 216.44,28.4 v2(216.23,28.4) 215.95,28.4 215.62,28.07 215.62,27.44 215.67,27.39 JDIMM2.129 ; v2(224.16,16.87) 223.93,17.11 JDIMM2.154 ; JDIMM1.148 146.12,17.29 145.69,16.86 v2(145.1,16.86) ; v2(214.44,16.86) 214.43,16.88 JDIMM2.124 ; v2(149.54,16.87) 149.12,17.29 JDIMM1.160 ; JDIMM1.199 158.89,27.58 159.55,28.24 v2(159.72,28.24) ; JDIMM1.75 125.88,27.52 v2(125.71,27.69) ; JDIMM2.199 235.18,27.55 v2(235.6,27.97) ; JDIMM2.163 226.18,27.49 226.33,27.65 v2(226.69,27.65) ; JDIMM2.153 223.67,27.33 223.39,27.61 v2(222.72,27.61) 222.59,27.61 222.18,27.2 JDIMM2.147 ; v2(163.87,16.86) 163.87,16.99 164.12,17.24 JDIMM1.220 ; JDIMM2.159 225.18,27.49 v2(225.02,27.64) ; JDIMM2.117 212.67,27.32 212.55,27.44 212.55,28.06 212.93,28.44 v2(213.11,28.44) ; v2(142.86,28.3) 142.72,28.3 142.3,27.88 142.3,27.43 142.37,27.37 JDIMM1.141 ; v2(153.1,16.89) 153.26,16.89 153.63,17.25 JDIMM1.178 ; v2(215.93,16.86) JDIMM2.130 ; JDIMM1.154 147.63,17.11 v2(147.84,16.9) ; JDIMM1.153 147.37,27.33 147,27.7 v2(146.56,27.7) 146.11,27.7 145.87,27.46 JDIMM1.147 ; v2(142.63,16.88) JDIMM1.142 ; v2(214.06,28.37) 214.1,28.37 214.52,27.95 214.52,27.56 214.18,27.22 JDIMM2.123 ; JDIMM1.135 140.88,28.16 v2(139.88,29.16) 139.32,28.6 139.32,27.44 139.37,27.39 JDIMM1.129 ; JDIMM1.112 135.12,17.12 v2(135.35,16.9) ; v2(169.48,27.75) 169.37,27.64 JDIMM1.241 ; JDIMM1.159 148.87,27.36 149.12,27.61 149.87,27.61 149.87,27.61 ; JDIMM1.118 v2(136.62,16.9) ; JDIMM1.111 v2(134.88,29.64) ; v2(120.42,16.68) 120.62,16.88 JDIMM1.54 ; v2(136.78,28.44) 136.6,28.44 136.25,28.09 136.25,27.44 136.39,27.3 136.39,26.37 JDIMM1.117 ; 149.87,27.61 JDIMM1.163 ; 149.87,27.61 149.93,27.67 v2(150.5,27.67) ; v2(212.94,16.86) 212.92,16.87 JDIMM2.118 ; JDIMM2.75 202.18,27.51 v2(202.02,27.67) ; v2(245.29,27.68) 245.67,27.3 JDIMM2.241 ; JDIMM2.141 218.67,27.37 218.6,27.43 218.6,27.87 218.97,28.24 v2(219.16,28.24) ; v2(114.86,28.21) 115.16,28.21 115.44,27.93 115.44,27.45 115.37,27.38 JDIMM1.33 ; JDIMM2.12 186.43,17.09 186.64,16.88 v2(186.64,16.87) ; v2(217.43,16.86) 217.43,18.15 ; JDIMM1.130 v2(139.63,16.9) ; v2(211.65,16.86) 211.43,17.08 JDIMM2.112 ; v2(141.14,19.43) 141.12,19.42 JDIMM1.136 ; v2(207.46,16.86) 207.44,16.87 JDIMM2.96 ; JDIMM1.12 110.13,16.88 110.17,16.83 v2(110.17,16.66) ; v2(138.12,16.9) JDIMM1.124
  vias: v1(158.34,34.2) v2(254.92,23.63) v2(254.92,23) v2(255.55,23.63) v2(255.55,23) v2(256.22,23.62) v2(256.22,22.98) v2(256.86,23.62) v2(256.86,22.98) v2(257.49,23.62) v2(257.49,22.98)
+1.2V_MEN_P: length 66.5
  TOP w0.254: PR604.2 v2(291.19,32.1)
  IN1 w0.254: v2(291.19,32.1) 291.85,31.44 291.85,28.91 289.68,26.74 288.63,26.74 288.03,26.14 280.37,26.14 279.63,25.4 278.11,25.4 277.64,24.93 269.46,24.93 267.7,26.68 258.89,26.68 v2(258.83,26.74)
  IN1 w1.016: 263.02,28.52 264.12,27.42 268.2,27.42 269.91,25.7 276.86,25.7 278.64,27.48 280.73,27.48 282.45,29.19 282.45,30.54
  BOTTOM w0.203: PU600.5 289.07,31.71 289.46,32.1 v2(291.19,32.1) PR604.2
  vias: v2(262.32,29.35) v2(262.95,29.35) v2(282.13,31.44) v2(282.78,31.44)
+1.2V_PWROK: length 5
  BOTTOM w0.127: v3(291.52,25.23) 291.83,25.55 PR609.2
  BOTTOM w0.203: PR609.2 291.61,26.3 290.53,27.38 290.53,28.51 290.2,28.84 PU600.10
+1.2V_VCCPLL_OC: length 21.7
  TOP w0.127: v1(132.02,64.72) v2(131.57,65.16)
  TOP w0.508: CZ49.1 174.06,66.23 v2(173.85,66.02) ; RH530.1 v2(165.85,66.65) ; v2(131.57,65.16) 131.03,65.16 130.66,65.53 RZ67.2
  IN1 w0.508: v2(131.57,65.16) 131.57,68.02 132.11,68.55 133.94,68.55 134.51,67.98 138.54,67.98 140.14,69.57 141.26,69.57 141.61,69.21 141.61,68 142.37,67.25 v2(142.96,67.25)
  BOTTOM w0.203: UH1.BH13 142.83,67.25 v2(142.96,67.25)
  BOTTOM w0.229: v2(173.85,66.02) 174.18,66.35 UH1.G11
+1.05VSDGPU: length 58.1
  TOP w0.508: RZ9.1 235.71,106.35 v2(235.84,106.47)
  TOP w0.762: 196.7,93.43 195.47,93.43 v2(194.55,92.52)
  IN4 w0.762: v2(194.55,92.52) 194.55,93.96 196.15,95.55 203.8,95.55 206,93.35 209.96,93.35 210.72,94.11 210.72,96.2 213.05,98.53 213.05,98.68 223.78,98.68 225.2,100.1 229.62,100.1 v2(231.06,98.65)
  IN6 w0.508: v2(235.84,106.47) 231.06,101.7 v2(231.06,98.65)
  BOTTOM w0.254: UV1.AN28 UV1.AM28
  vias: v1(205.04,59.23) v2(196.91,68) v2(196.91,67.41) v2(197.8,68.36) v2(197.78,67.78) v2(197.8,67.19) v2(198.79,68.36) v2(198.77,67.78) v2(198.79,67.19) v2(203.11,86.77) v2(203.94,85.86) v2(203.88,84.22) v2(204.7,84.22) v2(204.7,83.37) v2(205.53,83.37) v2(205.78,82.81) v2(205.89,81.15) v2(205.88,80.29) v2(205.96,75.94) v2(205.96,75.04) v2(206.16,74.25) v2(206.35,77.92) v2(206.41,82.81) v2(206.35,79.26) v2(206.62,75.05)
+1.05VSP: length 23.1
  TOP w0.254: PR904.1 PC907.1 222.75,49.03 v2(222.87,48.9)
  IN2 w0.254: v2(205.18,54.92) 205.36,54.75 206.74,54.75 214.21,47.28 221.25,47.28 v2(222.87,48.9)
  vias: v1(206.02,55.76) v2(210.06,57.48) v2(210.06,56.84) v2(210.69,57.48) v2(210.69,56.84) v2(211.33,57.48) v2(211.33,56.84)
+1.35V_RUN_B+: length 1.6
  TOP w0.127: v1(233.92,46.36) 234.2,46.64 235.37,46.64
+1.35V_VSNS: length 22.2
  TOP w0.203: PU700.22 244.79,48.49 245.33,47.95 v2(245.75,47.95)
  IN1 w0.254: v2(245.75,47.95) 245.23,47.43 241.9,47.43 241.07,48.26 241.07,51.16 239.51,52.73 239.51,58.72 241.87,61.08 v2(242.54,61.08)
  vias: v1(245.31,59.86) v2(242.54,60.45) v2(242.54,59.81) v2(243.18,61.08) v2(243.18,60.45) v2(243.18,59.81) v2(243.81,61.08) v2(243.81,60.45) v2(243.81,59.81) v2(244.45,61.08) v2(244.45,60.45) v2(244.45,59.81)
+1.35VSDGPU: length 230.8
  TOP w0.381: CV808.1 242.46,77.57 243.11,76.91 v2(243.11,76.83)
  TOP w0.508: CV680.1 203.38,108.03 v2(203.49,108.15) ; v2(245.52,73.64) 245.6,73.72 CV711.1 ; CV811.1 243.73,89.08 v2(243.92,89.27) ; v2(204.26,111.36) 204.2,111.41 CV679.1 ; CV730.1 237.39,89.4 v2(237.52,89.27) ; CV706.1 235.09,76.86 v2(235.13,76.81) ; v2(221.49,100.16) 221.22,99.89 CV663.1 ; v2(197.83,100.07) 197.63,99.86 CV687.1 ; CV677.1 v2(192.2,110.79) ; v2(243.91,85.27) 243.88,85.3 CV731.1 ; CV813.1 243.16,94.91 v2(243.11,94.87) ; v2(205.86,111.36) 205.86,112.04 206.33,112.51 207.59,112.51 RV373.1 208.29,111.81 RV371.1 ; v2(205.08,107.34) 205.14,107.27 CV803.1 ; CV809.1 242.27,69.68 v2(242.35,69.6) ; v2(237.51,67.23) 237.46,67.18 CV707.1 ; v2(246.38,67.16) 246.45,67.23 RV386.1 ; v2(235.04,88.47) 234.91,88.34 234.42,88.34 CV738.1 ; v2(205.06,104.16) 204.8,103.9 CV683.1 ; CV713.1 247.02,75.21 v2(246.43,75.21) ; RV339.2 216.69,100.96 v2(216.69,100.96) ; RV360.1 224.9,100.36 RV358.1 224.9,101.81 v2(224.79,101.93) ; CV712.1 246.58,69.68 v2(246.48,69.78) ; v2(234.97,92.9) 234.92,92.85 CV737.1 ; v2(213.49,102.56) 213.25,102.32 CV799.1 ; RV347.1 220.64,80.15 v2(220.64,80.9) ; v2(223.09,100.16) 223,100.07 CV661.1 ; v2(246.33,77.63) 246.71,77.63 CV702.1 ; CV805.1 CV806.1 196.52,107.09 v2(196.25,107.36) ; CV704.1 234.99,66.77 v2(234.97,66.76) ; v2(230.61,59.18) 229.41,57.98 228.75,57.98 227.92,57.15 227.92,56.31 227,55.39 225.88,55.39 225.44,55.84 RV332.2 ; CV662.1 214.71,99.66 214.32,100.05 v2(214.32,100.13) ; CV708.1 235.2,74.43 v2(235.91,74.43) ; v2(215.89,111.36) 215.89,112.1 CV654.1 ; CV735.1 246.91,95.82 246.7,95.6 v2(246.39,95.6) ; CV729.1 242.15,91.26 243.15,92.26 v2(243.15,92.47) ; RV338.2 201.87,98.9 CV684.1 201.88,100.13 v2(201.86,100.16) ; CV734.1 245.66,82.94 246.13,83.41 246.13,84.28 v2(246.31,84.46) 246.57,84.46 247.35,83.69 RV399.1 ; CV800.1 216.43,108.73 v2(216.68,108.97) ; CV688.1 196.15,99.15 195.45,99.84 v2(195.45,100.16) ; v2(239.26,87.3) 239.13,87.17 CV732.1 ; CV804.1 198.16,102.55 v2(198.67,102.55) ; v2(223.89,110.56) 223.9,110.57 CV659.1 ; v2(220.69,111.36) 220.14,111.91 CV655.1 ; v2(238.34,67.23) 238.84,67.23 CV705.1 ; CV607.1 219.98,79.25 CV608.1 220.63,79.26 v2(220.64,79.25) ; CV686.1 205.09,100.05 v2(205.06,100.08) ; CV657.1 215.57,99.68 215.9,100.01 v2(215.9,100.15) ; v2(223.1,103.37) 222.76,103.37 222.45,103.68 CV652.1 ; CV802.1 211.28,108.39 211.86,108.97 v2(211.9,108.97) ; CV814.1 246.57,92.26 v2(246.37,92.47) ; v2(222.32,108.15) 222.42,108.05 CV656.1 ; CV658.1 221.92,111.73 v2(222.29,111.36) ; v2(245.21,99.36) 245.21,99.7 245.55,100.05 RV397.1 ; v2(225.04,109.93) 225.12,109.85 CV801.1 ; v2(192.6,111.95) 192.59,111.95 CV682.1 ; v2(212.69,111.37) 212.97,111.65 CV653.1 ; CV660.1 221.5,104.61 v2(221.23,104.34) ; RV344.1 214.03,86.91 214.27,87.15 214.27,87.48 v2(214.28,87.49) ; v2(234.96,96.04) 234.9,96.1 CV728.1 ; RV384.1 v2(242.73,80.9) ; v2(239.21,77.62) 239.09,77.51 CV807.1 ; CV736.1 243.36,82.79 243.94,83.37 v2(243.94,83.64) ; v2(246.44,68.85) 246.49,68.8 CV710.1 ; v2(220.59,82.53) 219.65,83.47 CV591.1 RV342.1 ; v2(244.7,71.24) 245.27,71.24 CV703.1 ; CV733.1 244.04,98.54 243.9,98.68 v2(243.9,98.95) ; CV727.1 235.88,85.33 235.42,84.86 v2(234.97,84.86) ; v2(242.28,68.01) 242.11,67.84 CV810.1 ; CV812.1 245.54,94.04 v2(245.51,94.07) ; RV409.2 v2(232.64,87.28) ; RZ8.1 v2(239.7,101.41)
  BOTTOM w0.203: UV1.E16 222.83,76.3 v2(222.48,76.65)
  BOTTOM w0.254: UV10.G2 v2(235.91,88.47) UV10.G1 ; UV5.R5 213.09,104.09 v2(212.93,104.25) ; UV10.C10 242.6,85.67 v2(242.29,85.98) ; v2(223.09,101.76) UV5.B3 ; v2(243.15,70.43) 243.51,70.79 UV9.G11 ; v2(236.71,74.43) UV9.M3 ; UV9.L11 243.53,74.03 v2(243.92,74.41) ; UV6.E10 203.11,107.76 v2(203.49,108.15) 203.49,108.2 UV6.D11 ; UV9.P11 243.51,76.4 v2(243.89,76.03) ; UV5.M3 215.5,102.16 v2(215.9,102.56) ; v2(204.27,108.95) 204.25,108.97 204.24,108.97 UV6.D12 ; v2(226.59,73.63) 226.17,73.63 UV1.B13 ; UV9.R5 239.1,77.62 v2(239.21,77.62) ; UV5.L1 v2(216.69,100.96) UV5.L2 ; v2(244.71,86.07) UV10.D12 ; v2(236.7,76.01) 236.7,76.04 237.09,76.43 UV9.P3 ; UV1.W33 212.04,90.64 v2(212.04,90.94) ; UV5.E5 221.09,104.19 v2(221.23,104.34) ; 244.69,74.45 244.69,74.46 244.32,74.83 UV9.M12 v2(243.91,75.23) ; 244.69,74.45 v2(244.69,74.45) ; 244.69,74.45 UV9.L13 UV9.K12 ; UV6.L13 198.24,110.16 v2(197.86,109.77) ; UV6.C5 v2(205.06,104.16) ; v2(243.11,94.07) UV10.P11 ; UV9.T14 245.93,78.03 v2(246.33,77.63) ; UV10.G4 237.91,88.88 v2(237.52,89.27) 237.12,89.67 UV10.H3 ; v2(237.51,67.23) UV9.B3 ; UV6.D3 v2(203.46,102.56) ; v2(239.25,95.27) UV10.R5 ; v2(243.91,77.63) UV9.T12 ; v2(195.45,100.16) UV6.P1 ; UV6.B14 v2(205.86,111.36) ; v2(246.44,68.85) 246.33,68.85 UV9.D14 ; UV10.M14 245.97,92.87 v2(246.37,92.47) ; UV10.D14 246.37,86.47 246.44,86.39 v2(246.47,86.39) ; v2(220.66,101.77) 220.29,102.14 UV5.F3 ; v2(234.97,84.86) UV10.B1 ; v2(234.97,66.76) 235.44,66.76 UV9.B1 ; v2(234.98,94.49) 235.49,94.49 UV10.P1 ; UV5.P14 v2(214.29,110.56) ; v2(198.64,100.09) 198.26,100.47 UV6.L1 ; v2(246.31,84.46) UV10.B14 ; v2(238.32,76.03) 238.71,75.64 UV9.N5 ; UV10.H12 244.31,89.67 v2(243.92,89.27) 243.51,88.87 UV10.G11 ; v2(239.25,93.67) UV10.N5 ; UV5.F1 220.29,100.53 v2(219.86,100.09) ; UV6.M3 v2(197.05,101.76) ; v2(243.91,94.07) UV10.P12 ; UV6.G4 201.43,102.96 v2(201.05,102.58) 200.66,102.18 UV6.H3 ; v2(197.86,108.16) 197.86,108.17 198.24,108.55 198.26,108.55 UV6.L11 ; UV6.G2 201.47,101.36 201.87,101.76 ; UV1.W30 211.84,88.05 v2(211.43,87.64) ; v2(209.78,87.7) 210.13,88.05 UV1.AA30 ; UV5.L13 v2(215.89,110.56) UV5.M14 ; UV5.G1 v2(219.89,100.96) UV5.G2 ; v2(236.71,93.27) UV10.M3 ; UV9.P14 246.29,76.81 v2(246.29,76.84) ; UV5.P11 v2(214.29,108.96) UV5.P12 ; v2(198.64,109.76) 199.01,109.39 199.02,109.39 UV6.K12 ; UV9.B14 246.25,67.16 v2(246.38,67.16) ; v2(237.47,72.03) 237.11,71.67 UV9.H3 v2(236.71,71.23) UV9.G2 ; v2(214.32,100.13) 213.89,100.56 UV5.P1 ; v2(205.08,107.34) 205.08,107.34 UV6.C10 ; v2(237.51,94.87) UV10.P3 ; UV6.T1 194.64,100.17 v2(194.64,100.17) ; v2(220.69,111.36) UV5.F14 ; UV10.F1 235.44,88.07 v2(235.04,88.47) ; v2(215.89,111.36) UV5.L14 ; UV9.L14 245.9,74.03 245.52,73.65 v2(245.52,73.64) ; v2(214.29,107.36) UV5.N10 ; UV10.E5 239.22,87.27 v2(239.26,87.3) ; v2(205.06,100.08) 205.06,100.16 UV6.B1 ; UV9.G13 245.11,70.83 v2(244.7,71.24) 244.31,71.63 UV9.H12 ; v2(217.45,102.57) 217.09,102.21 UV5.K3 ; v2(223.08,74.18) 223.22,74.18 UV1.E13 ; UV6.P11 v2(196.25,108.16) ; UV5.G4 219.5,102.96 v2(219.89,103.35) ; v2(244.73,91.64) 244.36,91.27 UV10.K12 ; v2(221.53,109.77) 221.89,109.41 UV5.D12 ; UV10.T1 235.49,96.04 v2(234.96,96.04) ; v2(219.86,111.33) UV5.G14 ; UV10.M1 235,92.87 v2(234.97,92.9) ; UV10.D11 243.51,86.47 v2(243.11,86.87) 242.72,87.27 UV10.E10 ; UV9.E5 v2(239.14,68.8) ; UV6.R10 v2(195.45,108.16) ; UV9.T1 235.13,78.41 v2(235.13,78.41) ; UV6.N5 196.69,103.76 197.1,103.35 v2(197.1,103.35) ; UV6.L14 198.24,110.96 v2(197.85,110.57) 197.84,110.57 UV6.M14 ; UV6.G1 201.48,100.56 v2(201.86,100.94) ; UV10.L13 v2(245.51,92.47) UV10.L14 ; UV1.B19 226.1,78.9 v2(226.5,78.9) ; v2(225.62,75.89) 225.62,75.95 225.96,76.3 UV1.B16 ; UV5.L11 216.29,108.59 v2(216.68,108.97) 217.06,109.36 UV5.K12 ; UV5.G11 v2(219.88,108.95) ; UV6.T12 v2(194.65,108.96) ; v2(212.66,101.74) 212.66,101.79 UV5.T3 ; v2(242.28,68.01) 242.65,67.63 UV9.C10 ; UV6.F3 202.26,102.14 201.87,101.76 ; UV5.G13 219.49,110.14 v2(219.08,109.72) 218.71,109.36 UV5.H12 ; v2(197.83,100.07) 197.46,100.44 UV6.M1 ; v2(198.66,101.76) UV6.L2 ; v2(236.71,77.68) 237.07,78.03 UV9.T3 ; UV10.K3 v2(237.51,91.67) UV10.L4 ; v2(243.92,69.62) 243.92,69.68 244.26,70.03 UV9.F12 ; v2(194.65,104.39) 195.05,103.99 UV6.R5 ; UV6.G13 201.46,110.17 v2(201.87,110.58) ; v2(243.92,76.83) 243.92,76.83 UV9.P12 ; v2(237.51,71.23) UV9.G4 ; UV6.G14 201.46,110.97 v2(201.87,111.38) ; v2(201.87,101.76) 201.87,101.76 ; UV1.T30 214.28,87.98 v2(214.28,87.49) ; v2(236.71,86.87) UV10.D3 ; UV6.E5 203.09,103.76 v2(203.45,104.12) ; UV9.D12 243.93,68.05 v2(243.93,68.04) ; v2(212.66,100.14) 212.66,100.18 UV5.T1 ; v2(235.91,74.43) UV9.M1 ; UV5.R10 v2(213.49,107.36) ; v2(243.11,94.87) UV10.R10 ; UV6.M12 v2(197.86,108.96) ; UV5.C5 222.72,103.76 v2(223.1,103.37) ; UV10.L2 236.24,91.99 235.59,91.99 UV10.L1 234.97,92.07 v2(234.96,92.08) ; v2(242.35,69.6) 242.71,69.24 UV9.E10 242.71,69.22 v2(243.11,68.82) 243.5,68.43 UV9.D11 ; v2(243.91,92.47) UV10.M12 ; UV9.D1 235.35,68.43 v2(234.95,68.83) ; UV9.G14 UV9.F14 245.96,69.99 246.01,69.99 246.22,69.78 v2(246.48,69.78) ; UV6.F14 202.26,110.97 v2(202.67,111.38) ; UV5.F12 220.29,109.36 220.27,109.36 v2(220.69,109.77) ; UV9.M14 v2(245.51,74.43) ; v2(237.51,72.83) UV9.K3 ; v2(245.52,87.67) 245.91,88.07 UV10.F14 ; v2(236.71,69.63) UV9.F3 ; UV9.F1 235.44,70.03 v2(235.04,70.43) ; v2(223.27,78.41) 223.6,78.74 UV1.E19 ; v2(246.39,95.6) 245.93,96.07 UV10.T14 ; v2(235.91,73.63) UV9.L1 ; UV10.N10 v2(242.31,94.07) ; v2(243.91,95.67) UV10.T12 ; v2(237.51,85.27) UV10.B3 ; v2(208.9,90.85) 209.3,90.45 UV1.AB33 ; v2(223.89,110.56) UV5.B14 ; v2(223.09,100.16) UV5.B1 ; UV6.P12 v2(196.25,108.96) ; v2(201.07,109.78) 200.66,109.37 UV6.H12 ; v2(243.11,76.83) UV9.R10 ; UV5.D3 v2(221.49,101.76) ; UV5.M1 v2(215.9,100.15) ; UV10.C5 v2(238.31,85.27) ; UV10.L11 243.48,92.1 243.48,92.15 v2(243.15,92.47) ; UV5.H3 218.69,102.18 v2(218.31,101.8) ; UV10.G13 245.14,88.87 v2(245.52,88.49) 245.9,88.87 UV10.G14 ; UV5.P3 v2(213.49,102.56) ; UV5.B12 223.49,109.34 v2(223.85,108.97) ; v2(193.85,102.56) UV6.T3 ; v2(222.29,111.36) UV5.D14 ; UV5.N5 v2(215.09,104.16) ; UV6.F12 202.65,108.96 v2(202.67,108.96) ; UV5.L4 v2(215.88,103.37) ; UV6.K3 199.06,102.17 v2(198.67,102.55) 198.26,102.96 UV6.L4 ; UV10.F12 244.23,88.07 243.92,87.76 v2(243.92,87.67) ; v2(243.91,67.23) UV9.B12 ; UV6.B3 v2(205.06,102.56) ; v2(222.32,108.15) 222.69,107.77 UV5.C10 ; v2(245.51,94.07) UV10.P14 ; v2(238.34,67.23) 238.71,67.61 UV9.C5 ; UV5.E10 221.13,107.76 v2(221.52,108.15) 221.89,108.52 UV5.D11 ; UV9.N10 v2(242.31,76.03) ; v2(211.9,108.97) 212.28,109.36 UV5.T12 ; v2(236.71,73.63) UV9.L2 ; v2(235.04,86.87) 235.05,86.87 235.07,86.85 235.13,86.85 UV10.D1 ; v2(203.46,100.16) UV6.D1 ; UV6.D14 v2(204.26,111.36) ; v2(236.71,87.67) UV10.F3 ; v2(237.51,73.63) UV9.L4 ; UV9.P1 235.13,76.81 v2(235.13,76.81) ; UV5.M12 v2(215.88,109.75) ; v2(201.86,100.16) UV6.F1 ; UV6.B12 v2(205.06,108.96) ; UV5.T14 212.29,110.97 v2(212.69,111.37) ; UV6.P3 v2(195.45,102.56) ; UV6.T14 v2(194.65,111.36) ; v2(243.91,85.27) UV10.B12 ; v2(221.49,100.16) UV5.D1 ; v2(236.71,68.83) UV9.D3 ; v2(235.91,70.43) UV9.G1 ; UV6.G11 201.46,108.56 v2(201.82,108.2) ; UV6.N10 v2(196.25,107.36) ; UV6.P14 v2(196.25,110.56) ; UV10.T3 v2(236.71,96.47)
  BOTTOM w0.279: UV1.H9 220.93,70.62 220.93,71.13 UV1.H10 221.06,71.3 220.79,71.57 219.91,71.57 v2(219.75,71.41) ; v2(214.51,91.67) 214.51,90.61 UV1.T33
  BOTTOM w0.305: UV1.H14 220.85,74.65 v2(220.45,74.25) 220.9,73.8 UV1.H13 ; UV1.H23 220.97,82.15 v2(220.59,82.53) 221.01,82.95 UV1.H24 ; UV1.H19 221.09,78.8 v2(220.64,79.25) 221.04,79.65 UV1.H20 ; UV1.H11 220.99,72.15 v2(220.59,72.55) 220.99,72.95 UV1.H12 ; UV1.H8 219.84,70.81 v2(219.75,70.81) ; v2(221.53,78.37) 221.11,77.95 UV1.H18 ; UV1.H16 221.04,76.3 v2(220.64,75.9) 221.09,75.45 UV1.H15 ; UV1.H21 221.09,80.45 v2(220.64,80.9) 221.04,81.3 UV1.H22
  BOTTOM w0.508: v2(195.45,100.16) 195.45,99.23 CV685.1 ; v2(234.95,68.83) 234.22,68.83 233.96,68.58 RV410.2
  vias: v1(236.02,62.67) v2(206.43,85.15) v2(207.28,85.12) v2(208.96,85.12) v2(210.58,85.12) v2(216.43,85.12) v2(217.28,85.07) v2(218.08,85.07) v2(223.17,96.06) v2(223.59,95.64) v2(236.48,61.73) v2(236.48,61.1) v2(236.78,62.26) v2(237.11,61.73) v2(237.11,61.1) v2(237.47,62.28) v2(237.75,61.73) v2(237.75,61.1) v2(237.97,60.52) v2(238.1,62.28) v2(238.38,61.74) v2(238.38,61.1) v2(238.61,62.59) v2(238.61,60.52) v2(238.82,59.94) v2(238.9,61.43) v2(239.02,62.14) v2(239.27,60.96) v2(239.29,60.35) v2(239.45,61.67) v2(239.89,61.1) v2(240.11,61.7)
+1V_MPHY: length 3.3
  BOTTOM w0.127: UH2.V28 v2(85.81,16.87)
  BOTTOM w0.152: UH2.V26 v2(86.58,16.87) ; UH2.U21 v2(88.91,17.64) ; UH2.U26 v2(86.58,17.64) ; v2(87.36,17.64) UH2.U25 ; UH2.U23 v2(88.13,17.64)
  vias: v1(83.21,30.44) v2(110.52,14.07) v2(111.1,14.07) v2(111.68,14.07) v2(112.27,14.07)
+1V_MPHY_MPHYPLL:
  vias: v1(80.78,29.32) v2(76.01,25.9) v2(78.69,26.22)
+1V_PCH: length 116.1
  TOP w0.279: v2(129.76,95.56) 129.71,95.56 129.26,96.01 JXDP.43 ; RH492.1 119.66,95.39 120.27,95.39 120.81,95.93 121.32,95.93 121.4,96.01 JXDP.44 123.94,96.01 v2(124.11,96.17)
  TOP w0.381: RH196.1 88.02,10.92 v2(88.49,10.92)
  TOP w0.508: RH584.1 101.52,15.38 100.99,15.91 100.99,16.53 v2(101.02,16.56)
  IN1 w0.508: v2(124.11,96.17) 124.11,96.29 125.42,97.61 126.68,97.61 128.73,95.56 v2(129.76,95.56)
  IN4 w0.508: 102.87,22.93 102.87,28.69 106.4,32.22 106.4,33.98 118.07,45.66 118.07,51.98 118.9,52.8 118.9,62.9 122.42,66.42 122.42,68.12 125.67,71.36 125.67,78.93 128.61,81.87 128.61,87.17 128.25,87.53 128.25,96.6 127.31,97.54 125.68,97.54 124.31,96.17 v2(124.11,96.17)
  BOTTOM w0.152: v2(92.17,19.6) 91.82,19.96 UH2.N17 ; UH2.AD15 92.34,14.26 v2(92.58,13.77) ; UH2.R19 89.96,18.74 v2(89.72,18.98) ; UH2.V17 v2(91.23,16.87) ; v2(90.77,18.97) 91,18.74 UH2.R17 ; v2(91.23,14.54) UH2.AC17 ; UH2.U20 v2(89.68,17.64)
  BOTTOM w0.203: UH2.AL22 88.7,11.12 v2(88.49,10.92)
  BOTTOM w0.508: RH71.1 104.07,23.05 v2(104.54,23.52) ; CH3.1 121.79,95.65 122.31,96.17 v2(124.11,96.17)
  vias: v1(90.36,21.1)
+1V_PCH_AZPLL: length 23.6
  TOP w0.14: v3(109.35,12.39) v2(108.9,12.84)
  TOP w0.508: LH2.2 108.61,12.54 v2(108.9,12.84) ; v2(90.75,10.18) 91.2,10.18 91.44,10.42 CH203.1
  IN2 w0.508: v2(108.9,12.84) 108.39,13.35 99.07,13.35 97.79,12.07 92.38,12.07 91.63,11.32 91.63,10.55 91.27,10.18 v2(90.75,10.18)
  BOTTOM w0.152: v2(90.75,10.18) 90.67,10.18 UH2.AN19
+1V_PCH_CLK5: length 11.5
  TOP w0.508: RH584.2 103.19,15.76 102.74,16.2 v2(102.74,16.39)
  BOTTOM w0.152: UH2.K2 98.85,21.27 UH2.K3
  BOTTOM w0.381: UH2.K2 100.41,21.36 100.55,21.5 101.49,21.5 CH179.1
  BOTTOM w0.508: CH179.1 101.84,20.87 102.3,20.42 CH178.1 101.11,20.04 100.81,19.75 100.81,17.7 v1(100.88,17.63) 101.1,17.41 102.01,17.41 CH177.1
+1V_PCH_PRIM: length 8.8
  BOTTOM w0.152: UH2.AC23 v2(88.13,14.54) UH2.AE23 ; UH2.AA28 v2(86.58,15.32) ; UH2.Y23 v2(88.13,16.09) UH2.AA23 ; UH2.Y25 v2(87.36,16.09) UH2.AA26 ; UH2.AE26 v2(87.36,14.54) ; UH2.AJ20 v2(89.68,12.22) UH2.AJ21 v2(88.91,12.22) UH2.AJ23 v2(88.13,12.22) UH2.AJ25 ; UH2.AC28 v2(86.58,14.54) ; UH2.AC26 v2(87.36,15.32)
  vias: v1(87.67,13.62)
+1V_PCH_USBPLL: length 11.9
  TOP w0.508: RH583.2 105.92,13.05 CH201.1 104.9,12.58 104.27,11.95 102.91,11.95 CH202.1 101.09,11.06 100.46,11.69 99.82,11.69 98.91,10.78 97.85,10.78 v1(97.56,11.07) 97.28,11.07 97,10.8 v2(97,10.16)
+1V_VCCDSW: length 7.6
  TOP w0.089: v3(84.44,5.44) 84.44,6.03 v2(84.87,6.45)
  TOP w0.381: RH196.2 87.53,9.51 87.28,9.51 86.77,9 86.77,7.66 86.68,7.58 86.68,6.88 86.37,6.57 CH176.1
  TOP w0.508: CH176.1 84.99,6.57 v2(84.87,6.45)
  BOTTOM w0.254: UH2.BA29 v2(84.87,6.45)
+1VALW: length 137.2
  TOP w0.127: v2(121.41,14.07) v1(122.16,14.07)
  IN4 w1.524: 194.07,59.91 192.86,61.12 192.86,69.53 193.93,70.6 193.93,81.01 192.43,82.51 189.21,82.51 188.19,81.49 184.74,81.49 183.82,82.41
  BOTTOM w2.032: 124.47,12.58 124.69,12.8 129.07,12.8 130.96,14.69 171.53,14.69 171.88,14.34 175.9,14.34 179.12,17.57 179.12,23.08 180.39,24.35 180.39,31.36 180.13,31.63 180.13,37.58 196.17,53.62 196.17,56.16
  vias: v2(103.63,16.82) v2(103.63,16.21) v2(104.5,16.79) v2(104.51,16.21) v2(106.74,14.07) v2(107.33,14.07) v2(107.91,14.07) v2(116.97,14.07) v2(117.6,14.07) v2(118.24,14.07) v2(118.87,14.07) v2(119.51,14.07) v2(120.14,14.07) v2(120.78,14.07) v2(182.96,84.35) v2(182.96,83.74) v2(183.54,84.36) v2(183.54,83.75) v2(195.12,59.39) v2(195.42,59.94) v2(195.75,59.41)
+1VSP: length 22
  TOP w0.508: PR504.1 134.76,1.56 v2(134.79,1.53)
  IN1 w0.254: v2(134.79,1.53) 134.79,1.75 134.43,2.1 130.37,2.1 129.67,1.41 119.7,1.41 118.68,2.42 118.68,5.22 119.06,5.6 v2(119.19,5.6)
  BOTTOM w0.508: PC507.1 v2(134.79,1.53)
  vias: v1(124.77,6.3) v2(122.43,5.66) v2(123.13,5.66) v2(123.76,5.66) v2(124.46,5.66) v2(125.1,5.66) v2(125.79,5.66)
+2.5V_MEM: length 75.9
  IN4 w1.524: 175.81,29.05 177.9,29.05 179.45,27.5 179.45,19.62 180.48,18.59 240.84,18.59 242.18,19.94
  vias: v1(179.82,26.29) v2(174.42,30.18) v2(175.06,30.18) v2(175.71,30.18) v2(250.71,29.83) v2(250.69,29.23)
+2.5VS_G9141:
  vias: v1(179.71,12.79)
+3.3V_ALW_DEG: length 5
  TOP w0.102: RE60.2 v1(314.29,28.66)
  TOP w0.508: v2(311.75,30.18) 311.75,30.01 312.26,29.5 312.26,28.9 312.5,28.66 RE60.2
  BOTTOM w0.305: v2(311.75,30.18) 311.11,30.82 JDEG1.1
+3.3V_GFX_AON: length 112.3
  TOP w0.381: UV14.5 198.63,47.76 199.59,48.73 CV129.1
  TOP w0.508: v2(200.53,49.53) 199.84,48.84 CV129.1 ; RV325.1 212.52,62.95 213.02,62.45 213.02,61.32 v2(212.88,61.18) ; RV302.2 228.92,62.49 v2(229.4,62.01) 229.87,62.48 RV306.2 ; RV29.1 196.9,53.09 RV50.1 v1(196.9,47.43) 196.9,45.8 198.5,44.2 201.63,44.2 v2(205.76,48.34) ; RV307.2 v2(232.55,61.98) ; RZ11.1 203.46,50.49 203.15,50.8 v2(200.64,50.8) ; RV543.2 221.25,63.17 221.59,62.82 v2(221.59,62.18) 221.22,62.18 221.12,62.28 RV542.2
  IN3 w0.508: v2(200.64,50.8) 200.53,50.69 v2(200.53,49.53)
  IN4 w0.508: v2(166.37,101.55) 167.08,100.83 168.6,100.83 170.15,99.29 171.54,99.29 172.19,98.64 172.19,97.21 176.02,93.38 177.78,93.38 179.99,91.17 180.79,91.17 184.35,87.6 184.35,86.47 186.68,84.15 192.57,84.15 196.5,80.22 196.5,69.83 195.07,68.41 195.07,62.01 v2(194.43,61.36)
  BOTTOM w0.203: v2(204.65,71.75) 204.7,71.8 v2(204.7,72.47)
  BOTTOM w0.254: RPH32.5 205.69,56.19 v2(205.49,56.4) ; PR1001.1 v2(166.37,101.55)
  BOTTOM w0.305: UV1.AG12 205.1,72.87 v2(204.7,72.47) 204.3,72.87 UV1.AH12
  BOTTOM w0.508: v2(194.43,61.36) 194.44,61.35 RV320.1 ; v2(199.04,55.49) 198.64,55.09 198.64,52.79 v2(200.64,50.8) 200.95,50.48 203.62,50.48 v2(205.76,48.34) ; RV331.2 213.86,60.41 RV319.2 212.88,60.49 v2(212.88,61.18)
  vias: v2(202.62,60.93) v2(203.25,60.93) v2(203.94,66.61) v2(203.92,65.82) v2(203.92,65.1) v2(203.89,60.93) v2(205.55,66.67) v2(210.64,63.47) v2(211.19,63.17) v2(218.9,58.89) v2(219.48,58.89) v2(219.76,69.24)
+3.3V_GFX_RUN: length 135.7
  TOP w0.508: PR900.2 223.04,53.73 223.75,53.02 v2(225.55,53.02) ; v2(234.1,62.28) 234.49,62.67 RV303.2
  IN1 w0.381: v2(206.5,59.7) 201.04,59.7 198.31,56.97 198.31,55.42 v2(197.64,54.75)
  IN3 w0.508: v2(170.27,100.15) 170.27,100.55 172.17,98.64 172.17,97.21 172.52,96.87 173.2,96.87 174.03,96.05 174.03,95.39 174.8,94.61 176.61,94.61 177.06,94.15 177.89,94.15 180.31,91.73 182.55,91.73 186.09,88.2 190.69,88.2 195.63,83.26 195.63,69.87 193.74,67.98 193.74,56.43 195.34,54.83 197.57,54.83 197.66,54.75 v2(197.64,54.75)
  BOTTOM w0.381: QV21.5 v2(206.5,59.7) QV21.2
  BOTTOM w0.508: v2(227.55,58.76) 227.55,58.04 225.55,56.04 v2(225.55,53.02) 225.55,46.4 224.51,45.36 204.69,45.36 201.5,48.55 200.25,48.55 199.78,49.01 199.78,50.26 197.64,52.41 v2(197.64,54.75) ; v2(170.27,100.15) 170.21,100.09 169.41,100.09 168.86,100.64 168.86,101.49 168.28,102.08 PR1006.2
  vias: v1(223.05,60.66) v2(217.25,69.16) v2(218.1,69.16) v2(225.53,59.26) v2(226.11,59.26)
+3.3VDX_SSD: length 12.2
  TOP w0.508: CD40.1 268.55,4.33 v2(269.31,4.33) ; v2(269.32,21.93) 269.2,22.04 CD36.1 ; v2(269.24,8.99) 268.95,9.28 RD8.2 v1(268.43,10.49) RD7.1 268.98,13.34 v2(269.18,13.15) ; v2(269.24,18.87) 268.54,19.57 CD38.1 ; v2(269.96,18.79) 269.96,18.54 269.63,18.21 268.77,18.21 CD39.1 ; CD41.1 268.76,5.47 v2(269.27,4.96)
  vias: v2(244.54,9.34) v2(245.16,9.34) v2(245.76,9.34) v2(246.38,9.34) v2(247.02,9.34) v2(269.24,11.5) v2(269.81,13.15) v2(269.84,11.5) v2(270.45,11.5)
+3V_LDO: length 38.7
  TOP w0.508: PR281.1 33.71,32.63 v2(33.32,33.01) ; PU203.5 26.01,20.34 25.63,19.96 v1(25.63,19.03) 25.63,17.33 25.31,17.01 PC218.1 23.8,15.86 PQ224.1 21.31,15.86 20.12,17.05 v2(20.12,18.4)
  IN5 w0.508: v2(20.12,18.4) 22.53,18.4 25,20.86 25,23.57 24.61,23.95 24.61,26.54 24.21,26.95 24.21,29.44 25.71,30.94 26.46,30.94 27.18,31.66 27.18,32.99 27.6,33.41 32.93,33.41 v2(33.32,33.01)
+3V_PCH: length 370.3
  TOP w0.356: UZ11.5 178.03,6.35 v2(178.03,5.27)
  TOP w0.381: RH571.2 106.3,5.22 107.16,6.08 109.15,6.08 109.31,5.92 110.85,5.92 111,5.76 111.53,5.76 ; v2(172.58,5.42) 173.13,5.97 UZ12.5 ; v2(183.47,3.18) 183.4,3.25 UZ20.5 ; 224.28,13.16 v2(224.28,14.04) 224.28,15.06 ; CH192.1 77.09,5.05 v2(77.17,5.13) ; RH461.1 77.15,6.47 76.63,6.47 RH458.1
  TOP w0.508: v2(170.56,6.49) 170.56,5.17 UZ21.5 169.98,4.98 168.97,5.98 168.97,7.11 167.9,8.19 167.06,8.19 166.16,9.09 v1(164.15,9.09) 163.51,9.72 163.51,11.63 160.14,15 150.31,15 RE121.1 ; RH119.1 68.66,14.1 69.34,13.42 v2(69.34,13.15) ; RH554.2 75.11,15.54 75.67,16.1 v2(75.83,16.1) ; v2(79.94,13.74) 79.52,14.17 CH190.1 ; RH82.1 RH506.2 73.2,4.26 73.05,4.42 v2(72.52,4.42) 71.13,4.42 RH459.1 ; v2(97.01,9.16) 97.65,9.8 CH189.1 ; RH504.1 RH130.1 84.49,11.29 v2(83.74,11.29) 83.74,10.38 RH546.2 ; RH558.2 91.19,5.34 91.44,5.6 CH186.1 91.27,6.41 v2(90.75,5.89) ; RH110.2 74.87,12.58 74.42,13.03 v2(74.11,13.03) ; v2(69.89,7.74) 69.51,7.74 68.09,9.17 RH557.2 ; UZ19.5 120.13,60.95 RZ84.1 119.51,61.03 v2(119.51,61.73) ; RH524.1 82.36,4.21 81.93,4.64 81.92,4.63 RH505.1 79.87,4.63 RH136.1 79.44,4.77 79.22,4.99 78.96,4.99 v2(78.81,5.14) 78,5.14 77.47,5.67 RH461.1 ; CH187.1 98.63,3.7 v2(98.55,3.63) ; v2(80,11.28) 79.65,10.93 CH191.1 ; LH1.1 113.88,8.94 v2(113.88,8.28) 113.88,7.46 113.98,7.36 RH536.1 113.69,6.37 113.08,5.76 111.53,5.76
  IN3 w0.508: v2(183.47,3.18) 183.08,2.79 180.23,2.79 178.03,4.99 v2(178.03,5.27)
  IN4 w0.508: v2(62.23,9.69) 62.23,9.66 v2(63.17,8.72) ; v2(116.41,53.32) 116.14,53.32 112.92,50.1 112.92,48.01 113.83,47.1 113.83,42.27 105.79,34.24 105.79,32.47 103.56,30.23 102.19,30.23 97.74,25.79 96.22,25.79 94.51,24.09 90.7,24.09 88.75,22.13 88.75,21.12 86.11,18.47 84.76,18.47 84.2,17.92 81.38,17.92 80.19,19.11 78.54,19.11 77.73,18.3 73.1,18.3 72.56,17.75 v2(70.35,17.75) ; v2(126.7,81.58) 126.7,84.36 127.64,85.3 127.64,94.2 v2(126.7,95.14)
  IN5 w0.457: v2(179.33,10.36) 182.12,13.15 223.84,13.15 224.28,13.6 v2(224.28,14.04)
  IN5 w0.508: v2(178.03,5.27) 177.44,5.86 175.45,5.86 175.01,5.42 172.59,5.42 ; 172.59,5.42 172.48,5.53 171.51,5.53 v2(170.56,6.49) 170.56,7.6 169.9,8.26 156.66,8.26 155.77,9.15 154.39,9.15 153.73,8.49 152.21,8.49 151.28,7.56 149.16,7.56 146.2,10.52 126.62,10.52 125.72,9.63 117.67,9.63 117.25,9.21 114.54,9.21 113.88,8.55 ; 172.59,5.42 v2(172.58,5.42) ; v2(97.01,9.16) 97.52,8.64 101.91,8.64 102.86,9.6 105.64,9.6 106.56,10.51 107.11,10.51 107.2,10.42 107.21,10.42 107.83,9.81 112.63,9.81 113.88,8.55 ; 113.88,8.55 v2(113.88,8.28)
  BOTTOM w0.203: v2(83.83,6.45) 84.18,6.1 UH2.BA31 ; UH2.AN5 97,9.46 97,9.17 v2(97.01,9.16)
  BOTTOM w0.254: RP8.8 70.24,18.86 69.72,18.34 v2(69.72,17.87) 69.78,17.87 70.27,18.36 RP8.7 ; UH2.BA20 90.6,6.04 v2(90.75,5.89) ; UH2.AD41 v2(79.94,13.74) ; UH2.BD40 79.94,4.77 UH2.BC42 ; RP8.5 70.56,17.36 70.35,17.57 v2(70.35,17.75) 70.45,17.86 RP8.6
  BOTTOM w0.305: JAPS.1 178.62,5.86 v2(178.03,5.27)
  BOTTOM w0.508: v2(126.7,81.58) 126.7,80.75 129.08,78.37 129.08,70.84 126.94,68.69 126.94,67.17 125.18,65.41 123.51,65.41 122.73,64.63 122.73,63.38 121.08,61.73 v2(119.51,61.73) 119.51,56.31 120.28,55.54 120.28,53.75 119.84,53.32 v2(116.41,53.32) ; v2(126.7,95.14) 127.13,94.71 RH493.1 ; v2(62.23,9.69) 62.1,9.69 RH586.2 ; RH502.1 RH501.1 69.91,7.77 v2(69.89,7.74) ; v2(71.79,14.78) 71.79,14.83 71.81,14.84 RH555.2 RH553.2 ; RH552.2 v2(69.34,13.15) ; RH523.1 71.87,10.81 v2(71.39,11.29) 70.94,10.85 RH120.1 ; v2(183.47,3.18) 182.5,4.15 182.5,7.18 v2(179.33,10.36)
  vias: v2(59.07,5.1) v2(59.16,5.72) v2(59.92,5.22) v2(79.39,10.33) v2(80.71,8.37) v2(97.96,3.63)
+3V_PCH_AZIO: length 25.8
  TOP w0.14: v2(114.24,10.42) v3(114.94,11.12)
  TOP w0.508: v2(92.06,6.82) 92.5,6.82 CH200.1 ; LH1.2 113.92,10.11 v2(114.24,10.42)
  IN5 w0.508: 94.68,8.33 94.68,9.68 95.8,10.81 97.39,10.81 97.99,10.21 105.2,10.21 106.17,11.18 107.31,11.18 108.08,10.42 114.23,10.42 v2(114.24,10.42)
  BOTTOM w0.203: UH2.BA15 92.62,6.26 92.18,6.7 92.14,6.7 92.06,6.78 v2(92.06,6.82)
+3V_PCH_DSW: length 255.1
  TOP w0.508: RH453.2 111.04,4.33 111.41,3.96 v2(111.41,3.77) ; v2(87.49,5.15) 87.49,4.83 86.86,4.2 RH137.2 ; v2(92.48,16.14) 92.76,16.43 CH82.1
  IN3 w0.508: v2(114.56,8.26) 114.56,8.49 113.89,9.15 105.67,9.15 101.49,13.33 99.54,13.33 99.05,13.81 99.05,14.3 97.83,15.52 93.07,15.52 92.48,16.1 v2(92.48,16.14) ; v2(194.63,54.63) 193.13,56.13 193.13,68.23 195.01,70.11 195.01,83.02 190.44,87.59 185.84,87.59 182.3,91.13 180.03,91.13 177.7,93.46 176.86,93.46 176.32,94 174.49,94 173.33,95.16 173.33,95.79 172.89,96.24 171.84,96.24 171.6,96 144.81,96 144.25,95.44 v2(134.74,95.44)
  BOTTOM w0.127: v2(87.49,5.15) 87.75,5.41 87.75,5.89 UH2.BA24
  BOTTOM w0.203: UH2.W15 92.33,16.3 v2(92.48,16.14)
  BOTTOM w0.508: RH2.1 133.86,94.56 v2(134.74,95.44) ; v2(194.63,54.63) 178.03,38.03 178.03,29.87 178.97,28.93 178.97,24.86 177.75,23.65 177.75,18.13 175.33,15.72 172.45,15.72 172.1,16.06 117.33,16.06 115.32,14.04 115.32,9.03 v2(114.56,8.26) 114.56,7.13 113.87,6.45 RH545.2 113.87,3.83 112.33,2.29 110.81,2.29 110.62,2.49 v2(110.62,2.55)
+3V_PCH_SPI: length 0.6
  TOP w0.089: v3(78.33,2.37) 78.42,2.37 78.74,2.69 v2(78.74,2.74)
  vias: v2(78.74,3.37)
+3V_PS8723: length 11.3
  TOP w0.127: v2(315.63,28.93) v1(316.14,28.43)
  BOTTOM w0.254: CI4.1 315.93,29.8 317.27,31.14 UI3.1 ; CI3.1 322.68,33.64 UI3.13
  BOTTOM w0.508: RI16.2 RI24.2 v2(324.87,33.35) ; v2(315.63,28.93) 315.93,29.22 CI4.1 ; RI22.2 v2(314.91,36.66) ; v2(324.99,32.46) 324.99,31.95 324.61,31.57 RI19.2 RI15.2 RI20.2
  vias: v2(314.31,31.7) v2(322.38,35.05) v2(322.71,35.53)
+3V_ROM: length 32.4
  TOP w0.381: 75.39,1.56 75.03,1.56 74.96,1.48 74.02,1.48 73.97,1.53 v2(73.64,1.53) 73.2,1.96 RH78.1
  TOP w0.508: RH75.1 79.88,2.42 v3(79.88,1.66) 79.78,1.56 75.39,1.56 ; v2(60.22,8.04) 60.22,7.41 RH585.1
  IN5 w0.508: v2(58.09,5.06) 58.09,3.77 59.26,2.6 64.47,2.6
  IN6 w0.508: v2(60.22,8.04) 60.22,7.6 59.82,7.2 58.05,7.2 57.41,6.55 57.41,5.52 57.86,5.06 v2(58.09,5.06)
  BOTTOM w0.305: RH74.1 64.92,11.52 63.88,10.47
  BOTTOM w0.508: 63.88,10.47 62.46,9.05 61.55,9.05 UH8.8 61.09,8.9 60.33,8.14 60.3,8.14 60.22,8.06 v2(60.22,8.04)
+3V_TBT: length 27.6
  TOP w0.305: RT202.1 v1(24.02,50.5) 23.98,50.45 v2(22.15,50.45)
  IN5 w0.508: 20.3,45.45 20.3,48.6 v2(22.15,50.45)
  IN6 w0.508: v2(21.08,42.23) 21.09,42.22 24.34,42.22 ; 31.27,47.63 29.85,47.63 29.35,47.14 27.75,47.14 27.49,47.39 24.02,47.39 23.69,47.06 23.69,46.86 22.3,45.47
  BOTTOM w0.254: RT34.1 RT33.1 ; UT1.H9 v2(24.76,41.64)
  BOTTOM w0.356: v2(34.84,46.01) 34.76,45.93 34.76,45.85 34.67,45.76 34.67,44.36 RT21.1 ; v2(32.39,48.68) 32.89,48.68 33.02,48.55 RT34.1
  BOTTOM w0.381: v2(21.08,42.23) 20.59,42.23 CT53.1
  vias: v2(21.06,45.38) v2(21.52,45)
+3V_TBT_PWR: length 3.1
  TOP w0.127: v1(22.03,30.77) 21.62,31.18 19.08,31.18
+3V_TBT_S0: length 27.5
  TOP w0.14: v2(19.29,40.42) v1(19.29,39.82)
  TOP w0.254: v2(28.66,39.69) 28.66,39.97 CT163.1
  TOP w0.381: v2(19.29,40.42) 19.1,40.61 CT165.1 ; v2(23.72,34.79) 22.94,35.56 CT164.1
  IN5 w0.381: v2(28.66,39.69) 29.17,39.69 30.45,38.4 31.36,38.4 31.75,38.01 31.75,36.78 30.69,35.72 24.65,35.72 v2(23.72,34.79)
  IN6 w0.381: v2(23.72,34.79) 21.59,36.91 21.59,39.41 20.59,40.42 v2(19.29,40.42)
  BOTTOM w0.254: UT1.R13 28.66,39.69 v2(28.66,39.69)
  BOTTOM w0.381: LT14.1 18.63,40.42 v2(19.29,40.42)
+3V_TBT_SPI: length 50.3
  TOP w0.381: RT242.2 32.05,36.58 30.91,36.58 30.61,36.89 v2(30.61,37.07)
  IN2 w0.508: v2(32.26,32.04) 32.26,31.86 31.77,31.36 31.12,31.36 30.71,30.95 25.49,30.95 24.26,29.72 20,29.72 19.23,28.94 18.11,28.94 17.83,28.65 17.83,27.48 16.69,26.34 14.49,26.34 v2(14.24,26.09)
  IN4 w0.508: 35.19,33.5 34.59,34.11 31.73,34.11 30.61,35.23 v2(30.61,37.07) ; 35.19,33.5 33.7,32 32.3,32 v2(32.26,32.04) ; 35.19,33.5 37.42,35.72 40.82,35.72 43.12,33.42 v2(43.12,30.29)
  BOTTOM w0.254: RT16.1 RT17.1 31.24,31.29 RT18.1 32.26,31.92 v2(32.26,32.04)
  BOTTOM w0.508: RT243.2 v2(14.24,26.09)
  vias: v1(42.98,26.73)
+3V_VC: length 117.2
  TOP w0.14: v2(11,23.38) 11.6,23.38 v1(11.75,23.53)
  TOP w0.254: v2(11,23.38) 10.94,23.31 10,23.31 PR257.2 8.78,23.85 PR252.2
  TOP w0.381: PC225.1 9.83,12.52 9.72,12.41 PU204.5 ; CT161.1 12.32,40.51 v2(12.31,40.52)
  TOP w0.508: v2(34.37,30.72) 34.09,30.72 33.71,31.1 PR281.2 34.16,31.5 PR275.1 PC223.1 ; PR274.2 23.06,11.13 v2(22.67,10.74) ; PR278.1 18.09,21.78 17.64,21.33 16.31,21.33 15.73,21.9 PQ233.2 15.73,23.12 v2(16.27,23.66) ; PQ224.3 21.01,19.17 21.82,19.99 21.82,20.56 v2(20.72,21.66) ; PQ221.3 35.36,27.47 34.87,27.95 v2(33.84,27.95) ; PC225.1 v2(10.21,13.15)
  IN2 w0.508: v2(16.27,23.66) 15.89,23.28 11.1,23.28 v2(11,23.38) ; 11.43,40.01 11.13,39.71 11.13,36.89 11.48,36.53 v2(11.89,36.53)
  IN3 w0.508: v2(33.84,27.95) 34.74,27.95 35.1,27.59 35.1,26.48 33.55,24.92 32.01,24.92 31.07,25.86 29.01,25.86 26.81,23.66 25.48,23.66 23.48,21.66 v2(20.72,21.66) ; v2(22.67,10.74) 21.97,11.44 10.8,11.44 10.21,12.02 v2(10.21,13.15) 10.21,13.9 11.18,14.87 15.75,14.87 18.16,17.28 18.16,19.44 15.37,22.23 12.51,22.23 11.37,23.38 v2(11,23.38)
  IN5 w0.508: v2(20.72,21.66) 20.72,21.78 20.19,22.31 17.62,22.31 v2(16.27,23.66) ; v2(33.84,27.95) 33.53,28.26 33.53,29.33 34.37,30.17 v2(34.37,30.72) ; v2(11,23.38) 11.08,23.3 12.93,23.3 14.48,24.85 14.48,25.47 16.38,27.38 16.38,32.52 14.7,34.2 11.99,34.2
  BOTTOM w0.254: v2(12.31,40.52) 12.28,40.55 12.15,40.55 11.77,40.16 11.56,40.16 11.31,39.92 UT4.B1 ; v2(11.89,36.53) 11.89,36.56 11.81,36.64 11.66,36.64 11.38,36.92 UT4.H1
  BOTTOM w0.508: v2(16.27,23.66) PR254.2 PR255.2
+3VA_TBT: length 54.4
  TOP w0.381: RT25.1 24.58,48.5 v2(24.69,48.61) ; v2(13.15,41.97) 13.15,42.21 12.77,42.59 12.13,42.59 11.91,42.81 QT1.5 QT1.2 ; CT143.1 24.26,42.34 24.26,42.79 v2(24.11,42.94)
  TOP w0.508: QV89.2 16.36,27.17 RT194.1 14.82,27.17 v2(14.4,27.59)
  IN2 w0.508: v2(13.15,41.97) 13.15,41.46 13.28,41.33 13.28,40.42 13.55,40.15 v2(13.55,39)
  IN3 w0.508: v2(14.4,27.59) 14.58,27.77 14.58,29.48 15.15,30.05 v2(15.15,31.1) 15.15,34.26 14.76,34.65 ; 13.26,36.43 13.26,37.6 13.01,37.85 13.01,38.45 v2(13.55,39)
  IN4 w0.254: 25.15,47.78 25.15,47.38 27.15,45.38 27.15,44.04 25.6,42.49 24.56,42.49 v2(24.11,42.94)
  IN6 w0.508: v2(15.15,31.1) 15.28,31.1 17.97,33.79 17.97,40.14 20.41,42.58 20.41,47.38 21.63,48.6 22.58,48.6
  BOTTOM w0.203: UT1.F8 v2(24.11,42.94)
  BOTTOM w0.305: RT167.1 13.55,39.48 v2(13.55,39)
  BOTTOM w0.356: v2(30.35,48.57) 30.1,48.32 RT35.1 RT36.1
  BOTTOM w0.381: RT22.1 31.8,48.31 v2(31.8,48.72)
  vias: v2(14.43,33.46) v2(14.48,32.77)
+3VA_TBT_LC: length 40.3
  TOP w0.356: CT50.1 RT6.1 RT9.1 RT8.1 RT7.1 35.18,45.44 v2(35.23,45.49)
  TOP w0.381: v2(33.17,35.65) 32.94,35.87 RT242.1
  IN2 w0.508: v2(33.17,35.65) 33.17,40.1 31.8,41.47 31.8,42.52 31.38,42.94 v2(28.66,42.94) ; v2(35.23,45.49) 34.8,45.06 34.8,43.96 35.96,42.81 35.96,40.79 38.75,37.99 39.71,37.99 40.54,37.17 41.49,37.17 41.75,37.42 v2(43.02,37.42)
  IN4 w0.508: v2(33.17,35.65) 36.48,35.65 37.16,36.33 40.58,36.33 41.68,37.42 v2(43.02,37.42)
  BOTTOM w0.203: UT1.R6 v2(28.66,42.94)
+3VALW: length 547.2
  TOP w0.254: UE6.1 222.01,6.73 v2(222.23,6.51) 222.51,6.79 UE6.2
  TOP w0.381: PR245.2 26.62,27.42 25.97,26.77 PR241.2 ; PR236.2 27.51,32.11 27,32.62 v2(26.52,32.62) ; 107.36,53.36 UZ23.5 108.79,53.36 ; v2(121.29,64.08) 121.08,63.87 UZ22.5 ; UZ18.5 126.69,68.86 126.27,68.44 v2(126.27,68.34)
  TOP w0.457: UI4.5 26.16,85.4 CI21.1 26.57,86.67 v2(26.8,86.9) ; UI5.5 v2(321.31,53.16)
  TOP w0.508: PR256.1 25.07,29.27 v2(25.03,29.31) ; 108.79,53.36 109.28,53.36 111.19,55.28 111.43,55.52 v1(112.18,55.52) 121.89,55.52 v2(121.97,55.43) ; CI22.1 321.68,53.53 v2(321.31,53.16) ; PQ221.1 36.1,24.88 v2(35.26,25.71) ; v2(48.17,31.76) 48.1,31.84 PR101.1 ; v2(83.86,5.8) 83.63,5.57 83.63,4.73 83.44,4.54 RH137.1 ; RI5.1 28.41,88.87 28.41,85.77 v2(28.23,85.59) ; v2(105.73,62.94) 104.29,61.5 104.29,56.32 104.88,55.74 106.26,55.74 107.19,54.81 107.19,53.54 107.36,53.36 ; PR905.1 v2(222.89,51.95) ; RI4.1 28.32,93.65 v2(28.08,93.89) ; v2(124.85,16.71) 126.39,15.17 135.17,15.17 138.84,11.51 v1(138.84,8.71) 138.84,4.94 138.39,4.49 137.08,4.49 136.46,5.11 v2(134.88,5.11) ; RZ12.1 v2(236.86,106.51) ; v2(27.23,27.28) 27,27.5 PR245.2 ; v2(320.23,43) RI30.1 321.31,43.27 RI31.1 ; RE56.1 v2(310.11,11.95) ; v2(19.3,9.11) 19.3,9.83 PR112.2 ; v2(132.68,1.58) 132.72,1.62 132.72,1.93 132.46,2.18 PR510.1 ; v2(348.74,116.47) 348.87,116.47 349.14,116.73 CE15.1 349.51,116.98 348.95,117.53 RE15.1 348.95,117.92 348.68,118.18 348.68,118.68 348.9,118.9 UE2.2
  IN1 w0.508: v2(105.73,62.94) 105.73,63.92 107.08,65.27 107.79,65.27 108.14,65.63 v2(108.14,66.05) ; v2(232.07,48.71) 231.71,49.07 231.71,50.39 233.8,52.47 233.8,54.06 232.69,55.16 232.69,57.92 234.38,59.61 234.66,59.61 234.95,59.9 237.24,59.9 237.81,59.33 239.34,59.33 242.41,62.4 243.35,62.4 244.73,63.78 246.2,63.78 246.99,64.56 246.99,65.85 247.71,66.57 247.71,96.31 246.67,97.35 246.67,102.12 242.01,106.78 237.12,106.78 v2(236.86,106.51) ; v2(48.17,31.76) 47.54,31.12 41.68,31.12 41.26,30.7 v2(41.26,30.29)
  IN1 w1.016: 308.32,23.34 309.17,24.19 310.42,24.19 313.2,26.97 315.79,26.97 316.57,27.76 316.57,30.37
  IN2 w0.508: v2(121.97,55.43) 120.28,55.43 119.64,56.08 119.64,58.81 120.27,59.44 120.27,63.06 v2(121.29,64.08) ; v2(58.48,6.36) 59.32,7.2 63.73,7.2 64.43,7.9 67.88,7.9 68.35,8.37 70.13,8.37 72.39,6.1 72.85,6.1 74.2,4.76 75.27,4.76 75.65,4.38 76.31,4.38 76.44,4.51 76.45,4.51 76.49,4.55 83.05,4.55 83.86,5.36 v2(83.86,5.8) ; v2(320.23,43) 320.23,43.51 322.44,45.72 322.44,52.03 v2(321.31,53.16)
  IN3 w0.508: v2(27.23,27.28) 26.66,27.85 26.66,28.41 25.75,29.31 v2(25.03,29.31) ; v2(25.03,29.31) 22.11,29.31 20.78,30.64 21.41,31.27 21.41,32.01 20.43,32.98 20.43,38.21 17.86,40.78 17.86,44.27 21.3,47.71 26.28,47.71 v2(27.34,46.64) ; v2(25.03,29.31) 25.03,30.1 25.46,30.53 26.09,30.53 26.52,30.96 v2(26.52,32.62) ; v2(232.07,48.71) 226.34,48.71 223.1,51.95 v2(222.89,51.95) 220.84,49.91 218.36,49.91 v2(217.55,49.09) ; v2(124.85,16.71) 124.85,16.89 121.58,20.17 121.58,24.28 122.1,24.8 122.1,42.52 v2(128.57,48.99)
  IN4 w0.508: v2(27.23,27.28) 27.8,27.84 31.98,27.84 34.11,25.71 v2(35.26,25.71) 36.25,26.7 38.66,26.7 41.26,29.31 v2(41.26,30.29)
  IN5 w0.254: 26.44,51.95 26.44,51.85 28.32,49.97 28.32,49.33 27.97,48.98 27.97,47.27 v2(27.34,46.64) 25.88,48.11 25.88,49.52 25.44,49.96 25.44,50.78 26.16,51.51
  IN5 w0.508: v2(28.08,93.89) 28.08,92.26 26.67,90.85 26.67,87.03 v2(26.8,86.9) 27.08,86.9 28.23,85.75 v2(28.23,85.59) 28.23,85.3 27.01,84.08 27.01,83.75 26.11,82.85 26.11,81.19 24.56,79.64 24.56,78.46 22.54,76.44 22.54,67.67 24.58,65.64 24.58,63.57 25.17,62.98 25.17,59.72 24.77,59.32 24.77,58.13 25.96,56.93 25.96,53.87 26.44,53.39 26.44,51.95 ; v2(177.62,8.33) v2(176.09,8.33)
  BOTTOM w0.305: JAPS.3 v2(177.62,8.33) 177.62,9.33 175.81,11.14 170.55,11.14 170.21,11.49 162.7,11.49 162.27,11.06 JKB.3 ; JAPS.7 175.62,7.86 v2(176.09,8.33)
  BOTTOM w0.381: PU201.8 24.75,29.03 v2(25.03,29.31)
  BOTTOM w0.508: v2(128.57,48.99) 128.42,48.99 v2(121.97,55.43) ; v2(326.26,60.08) 326.06,59.88 RI9.1 RI10.1 ; v2(126.27,68.34) 125.86,68.34 125.29,67.76 125.29,66.65 124.65,66.02 122.36,66.02 121.13,64.78 121.13,64.24 v2(121.29,64.08) ; RE141.1 152.15,4.64 151.83,4.33 v2(151.83,3.76) ; v2(232.07,48.71) 233.45,47.33 237.7,47.33 246.1,38.93 246.1,33.71 248.49,31.33 251.86,31.33 253.22,29.97 253.22,25.25 251.46,23.49 251.2,23.49 250.2,22.5 250.2,20.73 250.59,20.35 251.01,20.35 251.54,19.82 251.54,15.52 250.99,14.97 232.09,14.97 231.45,14.33 231.45,12.39 230,10.94 230,6.8 229.6,6.41 227.53,6.41 226.7,7.25 222.76,7.25 222.23,6.72 v2(222.23,6.51) ; PR242.2 24.78,29.56 v2(25.03,29.31) ; v2(67.55,13.27) 67.55,13.12 67.08,12.65 66.5,12.65 66.23,12.38 65.22,12.38 PR109.1 ; PR811.1 108.14,65.49 v2(108.14,66.05)
  vias: v1(322.53,29.55) v2(12.49,18.47) v2(12.94,18.84) v2(14.54,30.88) v2(14.54,30.3) v2(42.49,30.29) v2(58.01,5.9) v2(68.17,13.26) v2(242.44,2.21) v2(242.6,2.77) v2(243.04,2.23) v2(243.33,2.77) v2(243.62,2.27) v2(274.45,9.28) v2(275.67,9.05) v2(307.34,23.44) v2(307.34,22.68) v2(316.61,35.99) v2(316.61,35.38) v2(316.68,36.58) v2(321.44,27.03) v2(322.05,27.68) v2(322.05,27.05) v2(322.54,28.11) v2(322.56,28.74) v2(322.63,27.48) v2(322.73,26.89) v2(323.19,29.09) v2(323.2,28.49) v2(323.19,27.9) v2(323.74,28.86) v2(323.79,28.1) v2(338.79,100.86) v2(338.79,100.22) v2(344.23,43.73) v2(344.89,43.51)
