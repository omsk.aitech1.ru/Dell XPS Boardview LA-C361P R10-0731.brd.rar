# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCH_JTAG_TDI: length 145.9
  TOP w0.14: v2(109.56,16.68) 109.54,16.68 109.07,17.15 v1(108.65,17.15)
  IN4 w0.091: v2(109.56,16.68) 109.56,18.06 111.19,19.69 111.19,26.35 111.09,26.45 111.09,34.07 124.65,47.63 124.65,51.76 131.44,58.55 131.44,64.15 128.84,66.75 128.84,68.96 130.05,70.17 130.05,75.88 132.91,78.74 133.12,78.74 133.35,78.98 133.35,80.48 134.62,81.75 134.61,81.75 134.61,84.99 134.62,84.99 134.13,85.48 134.13,94.56 133.46,95.24 133.46,95.77 133.54,95.85 133.54,98.4 130.94,101 121.39,101 120.19,99.8 120.19,95.03 120.17,95 120.17,94.09 120.21,94.04 120.21,93.71 119.98,93.47 118.18,93.47 v2(117.64,94.01)
  BOTTOM w0.089: UH2.AP2 98.97,9.34 99.2,9.1 100.19,9.1 100.81,8.49 101.48,8.49 101.51,8.45 101.77,8.45
  BOTTOM w0.127: v2(109.56,16.68) 109.56,16.68 110.07,16.17 110.96,16.17 112.74,14.39 112.74,11.79 109.78,8.83 109.78,7.88 108.83,6.93 108.45,6.93 RH100.2 107.75,8.15 107.1,8.8 104.52,8.8 104.27,9.05 102.36,9.05 101.77,8.45
  BOTTOM w0.14: RH477.2 118.11,94.48 v2(117.64,94.01)
PCH_JTAG_TDO: length 128
  TOP w0.127: v2(115.26,48) 116.41,46.85 116.41,39.61 v1(110.03,33.23) 106.71,29.91 102.17,29.91 99.95,27.69 99.95,25.86 100.33,25.48 100.33,23.31 101.66,21.98 102.17,21.98 102.74,21.41 103.42,21.41 103.7,21.69 104.05,21.69 104.34,21.39 104.34,21.13 104.79,20.68 105.01,20.68 105.33,20.37 105.33,19.74 105.3,19.71 105.3,19.25 105.87,18.68 106.63,18.68 107.01,18.3 108.91,18.3 109.5,17.71 113.31,17.71 113.96,17.06 113.96,15.05 114.25,14.76 114.25,12.97 111.63,10.35 109.02,10.35 RH97.2
  TOP w0.14: v2(107.95,8.54) 107.94,8.56 RH97.2
  IN4 w0.091: v2(121.03,95.26) 121.49,94.8 121.49,93.45 122.78,92.16 122.78,86.85 124.27,85.37 124.27,71.35 121.44,68.52 121.44,67.39 117.24,63.19 117.24,52.84 116.78,52.38 116.78,49.52 v2(115.26,48)
  BOTTOM w0.089: 101.65,8.66 100.88,8.66 100.21,9.34 UH2.AP1
  BOTTOM w0.127: v2(107.95,8.54) 107.47,9.03 104.62,9.03 104.37,9.28 102.27,9.28 101.65,8.66
  BOTTOM w0.14: RH478.2 120.21,94.48 120.52,94.8 120.52,94.93 120.85,95.26 v2(121.03,95.26)
PCH_JTAG_TMS: length 142.3
  TOP w0.127: 112.9,10.27 114.86,12.23 114.86,16.83 113.73,17.96 109.57,17.96 109,18.53 108.1,18.53 107.67,18.96 106.65,18.96 106.3,19.3 106.3,19.44 105.67,20.07 105.67,21 104.62,22.04 104.62,22.13 102.2,24.56 101.77,24.56 101.16,25.17 100.95,25.17 100.19,25.93 100.19,27.6 102.27,29.68 107.05,29.68 v1(113.07,35.71) 116.71,39.35 116.71,47.82 v2(115.09,49.45)
  TOP w0.14: 112.9,10.27 112.55,9.91 110.82,9.91 110.63,9.72 RH98.2 111.08,8.82 111.89,8.82 v2(112.54,8.17)
  IN5 w0.099: v2(112.54,8.17) 111.92,8.79 109.73,8.79 108.83,7.9 103.32,7.9 103.11,8.1 v2(103.11,8.1)
  IN6 w0.099: v2(118.62,92.85) 118.48,92.99 118.48,94.5 119.88,95.89 121.67,95.89 122.12,95.44 122.12,87.05 126,83.17 126,71.4 124.1,69.5 124.1,66.55 123.74,66.2 121.23,66.2 117.14,62.1 117.14,56.74 115.17,54.78 115.17,50.87 114.68,50.38 114.68,49.85 v2(115.09,49.45)
  BOTTOM w0.089: UH2.AR2 98.92,8.71 100.08,8.71 100.66,8.13 101.22,8.13 101.31,8.04 101.96,8.04
  BOTTOM w0.127: v2(103.11,8.1) 103.02,8.01 101.98,8.01 101.96,8.04
  BOTTOM w0.14: v2(118.62,92.85) 118.48,92.99 118.48,93.77 RH12.2
PCH_JTAGX: length 125.1
  TOP w0.14: RH491.1 131.89,100.94 v1(131.99,100.83) 132.27,100.55 v2(133.05,100.55)
  IN4 w0.089: 134.62,85.37 135.2,84.78 135.2,82.05 134.62,81.47
  IN4 w0.091: v2(110.81,16.67) 110.68,16.8 110.68,18.91 111.44,19.66 111.44,26.37 111.28,26.53 111.28,33.88 124.84,47.44 124.84,51.68 131.63,58.47 131.63,64.26 129.03,66.86 129.03,68.88 130.59,70.44 130.59,75.51 132.91,77.83 132.91,78.26 133.54,78.9 133.54,80.4 134.62,81.47 ; 134.62,85.37 134.33,85.66 134.33,95.1 134.28,95.15 134.28,98.46 133.05,99.69 v2(133.05,100.55)
  BOTTOM w0.089: UH2.AR3 98.53,8.72 98.77,8.96 99.08,8.96 99.11,8.92 100.12,8.92 100.74,8.31 101.29,8.31 101.35,8.25 101.89,8.25
  BOTTOM w0.127: 101.89,8.25 102.46,8.82 103.93,8.82 104.89,7.86 106.71,7.86 108.14,6.42 109.64,6.42 110.01,6.79 110.01,8.61 110.23,8.83
  BOTTOM w0.14: v2(110.81,16.67) 110.81,16.65 112.97,14.48 112.97,11.57 110.23,8.83
PCH_PCIE_WAKE#: length 234.4
  TOP w0.14: v2(107.67,5.36) 107.67,4.81 108.15,4.33 RH453.1 ; v2(297.66,19.33) 297.52,19.47 UE3.B46
  IN3 w0.089: v2(94.13,2.37) 94.59,2.83 94.59,3.26 95.24,3.91 97.62,3.91 97.7,3.99 99.08,3.99 99.44,3.63 101.98,3.63
  IN3 w0.091: 105.41,3.63 101.98,3.63 ; 105.41,3.63 105.41,4.23 106.65,5.46 107.57,5.46 v2(107.67,5.36) ; 105.41,3.63 106.15,2.89 106.76,2.89 107.07,2.57 108.82,2.57 109.34,2.06 115.09,2.06 119.27,6.24 121.27,6.24 122.74,7.71 127.63,7.71 127.98,7.37 129.61,7.37 130.35,6.63 135.5,6.63 137.01,8.13 144.22,8.13 145.9,6.45 152.81,6.45 154.08,7.72 154.53,7.72 155.91,6.34 162.26,6.34 163.1,7.18 175.39,7.18 175.84,7.63 178.18,7.63 179.04,8.49 210.35,8.49 214.69,4.15 227.06,4.15 228.26,5.35 234.64,5.35 235.44,6.14 236.09,6.14 237.14,7.18 241.81,7.18 244.12,4.88 246.39,4.88 247,5.49 258.08,5.49 260.17,7.57 262.43,7.57 262.65,7.35 272.27,7.35 273.02,8.1 275.53,8.1 276.25,8.82 276.25,10.2 283.14,17.1 283.14,18.97 283.34,19.17 283.7,19.17 284.34,19.81 291.6,19.81 292.8,21.01 296.49,21.01 297.41,20.09 297.46,20.09 297.66,19.89 v2(297.66,19.33)
  BOTTOM w0.089: v2(94.13,2.37) 93.63,2.88 93.63,3.19 93.56,3.25 93.56,4.29 93.42,4.43 93.42,4.75 93.68,5 UH2.BC13
PCH_PECI: length 4.6
  BOTTOM w0.089: UH2.AL3 98.53,10.99 98.77,11.23 99.09,11.23 99.22,11.1 101.22,11.1 v3(101.57,11.44) 101.94,11.82 101.98,11.82
  BOTTOM w0.14: 101.98,11.82 102.41,11.82 RH539.1
PCH_PLTRST#: length 36.5
  TOP w0.14: UH7.2 UH7.1 61.79,8.5 61.95,8.35 61.95,7.47 v1(62.51,6.9) 63.39,6.03 63.39,4.92 64.09,4.23 64.09,3.84 v2(64.79,3.13)
  IN5 w0.089: 75.06,1.76 82.88,1.76 83.84,2.72 84.86,2.72 85.68,1.9 87.31,1.9 v2(87.41,1.8)
  IN5 w0.099: 75.06,1.76 73.43,3.39 72.06,3.39 71.57,3.88 69.75,3.88 69.03,3.16 68.56,3.16 68.28,2.88 66.32,2.88 66.07,3.13 v2(64.79,3.13)
  BOTTOM w0.089: v2(87.41,1.8) 87.5,1.89 87.5,2.31 87.44,2.37 87.44,2.82 87.5,2.88 87.5,3.4 87.21,3.69 87.21,4 87.14,4.08 87.14,4.57 87.09,4.61 87.09,5.17 UH2.BB27
PCH_PLTRST#_EC: length 661.9
  TOP w0.089: 27.05,47.13 26.41,46.49 26.41,44.6 v2(26.06,44.25)
  TOP w0.127: UE1.17 151.16,8.93 150.92,9.18 150.92,10.2 151.49,10.78 v2(151.49,10.8) ; v2(151.49,10.8) 151.49,10.8 v2(151.49,10.8)
  TOP w0.14: RE31.2 311.63,17.66 v2(311.97,18) ; v2(62.95,5.62) 62.95,5.83 61.71,7.07 61.71,7.31 61.28,7.74 61.28,7.93 60.89,8.32 60.84,8.37 60.84,10.66 RH77.1 60.22,10.36 60.22,10.05 59.97,9.8 UH7.4 ; v2(302.07,16.61) 302.52,17.05 303.01,17.05 303.33,17.38 UE3.B30 ; v2(261.74,6.87) v1(261.74,8.94) 261.74,9.95 260.61,11.08 260.61,24.15 260.17,24.59 260.17,27.81 259.72,28.26 259.72,30.81 248.79,41.74 230.91,41.74 229.41,43.24 213.22,43.24 207.58,48.88 203.38,48.88 202.59,49.67 201.85,49.67 200.69,48.5 200.69,47.23 199.28,45.82 UV14.2 ; v2(22.54,52.86) 22.55,52.86 22.55,52.83 22.99,52.38 23.67,52.38 24.09,52.8 25.57,52.8 25.95,52.42 25.95,52.34 27.86,50.43 27.86,47.93 27.05,47.13
  IN1 w0.099: v2(336.58,33.68) 335.22,35.04 335.22,48.23 333.9,49.55 333.9,56.68 334.82,57.6 334.82,82.11 337.37,84.65 337.37,86.59 341.07,90.29 v2(341.28,90.29)
  IN2 w0.089: 75.06,3.24 75.73,3.24 75.97,3.48 76.47,3.48 76.76,3.77 78.86,3.77 79.61,3.02 80.61,3.02 80.79,3.2 81.83,3.2 82.4,3.77 83.32,3.77 83.89,4.34 84.97,4.34 85.42,4.79 88.07,4.79 89.07,5.79 89.07,7.03 89.41,7.36 89.92,7.36 90.86,6.42 93.17,6.42 93.77,7.02 93.77,7.48 94.84,8.55 99.01,8.55 99.45,8.99 101.91,8.99 101.98,9.06
  IN2 w0.099: 75.06,3.24 74.55,3.24 72.58,5.21 63.36,5.21 v2(62.95,5.62) ; v2(310.01,5.22) 309.3,5.93 307.8,5.93 307.17,5.29 303.8,5.29 303.32,5.77 301.5,5.77 300.64,4.92 296.11,4.92 295.95,4.75 285.44,4.75 284.49,5.7 283.28,5.7 282.52,4.94 272.26,4.94 270.8,6.39 v2(270.38,6.39) 269.9,6.88 261.75,6.88 v2(261.74,6.87) 261.1,6.23 258.38,6.23 258.28,6.13 252.55,6.13 252.3,6.38 246,6.38 245.15,5.53 240.27,5.53 240.14,5.41 240.14,5.41 238.63,3.9 227.8,3.9 227.28,4.41 214.63,4.41 209.98,9.06 200.78,9.06 200.16,8.44 179.22,8.44 178.58,7.79 154.49,7.79 151.49,10.8 151.49,10.8 151.49,10.8 v2(151.49,10.8) 151.1,11.2 150.74,11.2 150.7,11.16 148.11,11.16 147.54,11.73 114.32,11.73 113.3,10.71 106.76,10.71 105.8,9.75 102.67,9.75 101.98,9.06
  IN3 w0.091: v2(22.54,52.86) 22.54,53.56 21.7,54.41 19.89,54.41 16.63,51.15 16.63,45.62 14.08,43.07 11.77,43.07 11.24,42.54 8.36,42.54 7.64,43.26 7.64,44.11 7.39,44.35 5.76,44.35 4.3,42.89 4.3,40.88 3.41,39.99 v2(2.49,39.99) ; v2(62.95,5.62) 60.67,7.9 60.67,14.23 58.59,16.32 57.81,16.32 56.63,17.49 56.63,17.69 53.97,20.35 53.08,20.35 52.59,20.84 51.18,20.84 50.67,21.35 50.19,21.35 49.86,21.68 47.09,21.68 46.74,22.03 41.92,22.03 39.43,24.52 31.66,24.52 30.72,25.46 29.45,25.46 28.61,24.62 28.61,22.14 26.47,20 22.76,20 21.71,21.06 19.12,21.06 17.03,23.14 15.51,23.14 12.61,26.03 12.61,29.92 10.8,31.73 10.53,31.73 10.16,32.1 7.75,32.1 7.59,32.26 6.43,32.26 6.15,31.98 v2(6.15,31.11) ; v2(310.01,5.22) 310.16,5.36 310.16,11.23 308.77,12.61 308.77,14.23 308.26,14.73 304.47,14.73 303.06,16.14 302.54,16.14 v2(302.07,16.61) ; v2(336.58,33.68) 336.08,33.18 336.08,32.48 335.6,32.01 324.8,32.01 324.24,32.57 322.54,32.57 319.98,30.01 v2(317.46,30.01)
  IN5 w0.099: v2(6.15,31.11) 4.34,32.91 4.34,37.53 2.9,38.97 2.9,39.58 v2(2.49,39.99)
  IN6 w0.099: v2(302.07,16.61) 302.46,16.99 303.55,16.99 304.15,17.59 311.56,17.59 v2(311.97,18) 312.45,18 315.55,21.09 315.55,27.46 317.46,29.37 v2(317.46,30.01)
  BOTTOM w0.089: UT1.L4 v2(26.06,44.25)
  BOTTOM w0.14: v2(270.38,6.39) 270.38,9.37 269.46,10.29 JNGFF2.50 ; v2(302.07,16.61) 302.06,16.61 301.31,17.36 301.31,17.9 301.85,18.45 301.85,19.55 299.93,21.47 299.93,25.08 299.7,25.31 298.32,25.31 297.18,26.45 297.18,27.57 296.93,27.82 296.93,30.31 296.99,30.37 296.99,30.6 297.2,30.81 JLPDE1.8 ; v2(341.28,90.29) 341.3,90.32 JNGFF1.44 ; UR1.1 335.28,33.69 335.43,33.54 336.44,33.54 v2(336.58,33.68)
PCH_PWROK: length 17.1
  TOP w0.127: RH529.1 109.32,7.64 109.45,7.77 UH14.4
  TOP w0.14: v2(106.21,8.38) 106.73,7.86 107.23,7.86 v1(107.44,7.64) RH529.1
  IN6 w0.089: 101.98,8.5 99.18,8.5 98.57,7.89 97.63,7.89 97.34,7.6 97.34,7.6 97.27,7.54 95.44,7.54 95.12,7.22 v2(95.12,7.22)
  IN6 w0.099: v2(106.21,8.38) 105.4,9.19 102.67,9.19 101.98,8.5
  BOTTOM w0.089: v2(95.12,7.22) 95.03,7.22 UH2.AW11
PCH_RSMRST#: length 353.6
  TOP w0.089: RH133.1 96.28,9.51 v2(96.2,9.43)
  TOP w0.14: RH481.1 v2(131.12,92.74) ; v2(297.45,22.36) 297.45,22.35 296.77,21.67 UE3.A45 ; v2(74.5,22.97) 74.5,24.39 74.22,24.67 74.22,31.95 75.45,33.18 79.35,33.18 v2(80.47,34.3)
  IN3 w0.089: 101.98,6.23 100.59,6.23 98.3,8.52 97.12,8.52 v2(96.2,9.43) 94.83,10.8 91.77,10.8 91.14,11.44 86.85,11.44 86.18,12.11 86.18,12.38 85.29,13.27 85.29,13.83 84.79,14.33 79.93,14.33 78.16,16.11 78.16,16.54 77.78,16.93 76.43,16.93 75.13,18.22 75.13,22.34 75.06,22.41
  IN3 w0.091: 101.98,6.23 104.14,6.23 105.66,7.76 113.61,7.76 113.77,7.6 114.75,7.6 115.12,7.98 115.12,8.66 115.92,9.46 119.97,9.46 122.1,11.6 146.71,11.6 147.19,11.12 149,11.12 149.48,11.6 210.29,11.6 214.05,7.84 221.29,7.84 223.13,9.69 230.82,9.69 231.64,10.51 242.52,10.51 243.29,11.28 252.6,11.28 254.31,12.99 256.96,12.99 257.18,13.21 261.12,13.21 261.23,13.33 267.01,13.33 269.05,15.37 277.95,15.37 280.51,17.93 280.51,18.26 281.09,18.83 281.09,19.84 282.45,21.19 290.68,21.19 292.24,22.76 297.04,22.76 297.45,22.35 v2(297.45,22.36) ; v2(74.5,22.97) 75.06,22.41 ; v2(80.47,34.3) 80.52,34.25 83.8,34.25 85.37,35.82 86.23,35.82 87.22,36.81 94.9,36.81 95.99,37.91 98.12,37.91 101.52,41.31 101.52,42.27 112.22,52.97 112.37,52.97 117.95,58.55 117.95,63.93 119.22,65.2 119.87,65.2 123.14,68.47 123.14,71.24 124.94,73.05 124.94,84.66 128.91,88.63 128.91,91.72 129.93,92.74 v2(131.12,92.74)
PCH_RSMRST#_R: length 5.2
  TOP w0.089: v2(95.11,6.65) 94.63,7.12 94.63,8 94.82,8.19 RH88.2 v3(94.82,9.53) 94.82,9.94 RH133.2
  BOTTOM w0.089: UH2.BA11 94.59,6.13 v2(95.11,6.65)
PCH_RTCRST#: length 94.7
  TOP w0.089: v2(94.98,2.63) 94.98,2.63 95.32,2.63 96.66,3.97 96.75,3.97 RH84.2
  TOP w0.14: CH53.1 106.58,4.05 v2(106.83,3.8) ; v2(174.62,8.24) v1(174.62,8.89)
  IN1 w0.076: 101.98,3.62 100.75,3.62 99.41,2.27 97.46,2.27 97.23,2.5 96.44,2.5 96.32,2.63 v2(94.98,2.63)
  IN1 w0.099: v2(106.83,3.8) 103.15,3.8 102.97,3.62 101.98,3.62
  IN3 w0.091: v2(106.83,3.8) 106.98,3.65 109.31,3.65 109.85,3.12 115.29,3.12 119.02,6.84 120.69,6.84 122.11,8.26 127.86,8.26 128.21,7.92 129.84,7.92 130.53,7.23 135.25,7.23 136.71,8.68 144.52,8.68 146.15,7.05 152.01,7.05 153.23,8.27 154.76,8.27 155.15,7.88 172.98,7.88 173.8,8.71 174.15,8.71 v2(174.62,8.24)
  BOTTOM w0.089: v2(94.98,2.63) 94.98,2.69 94.67,3 94.67,4.81 UH2.BC10
  BOTTOM w0.14: JAPS.9 v2(174.62,8.24) ; CLRP1.1 106.83,2.93 v2(106.83,3.8)
PCH_RTCX1: length 9.5
  TOP w0.089: v2(95.75,2.23) 95.98,2.45 97.47,2.45 97.7,2.69 RH70.1
  TOP w0.14: RH70.1 98.81,2.69 CH45.1 99.33,2.27 100.67,2.27 100.76,2.18 YH1.1
  BOTTOM w0.089: UH2.BC9 95.2,4.97 95.2,4.35 95.07,4.23 95.07,3.49 95.08,3.49 95.08,3.29 95.2,3.17 95.21,3.17 95.29,3.08 95.3,3.08 95.61,2.78 95.61,2.37 v2(95.75,2.23)
PCH_RTCX2: length 12.9
  TOP w0.089: v2(95.2,2.09) 95.2,1.84 95.47,1.57 v3(96.96,1.57) 97.71,1.57 RH70.2
  TOP w0.14: YH1.2 103.93,1.83 103.15,1.05 100.56,1.05 100.27,1.34 99.32,1.34 98.86,1.8 CH46.1 98.81,1.77 RH70.2
  BOTTOM w0.089: v2(95.2,2.09) 95.2,2.29 95.35,2.45 95.35,2.77 95.13,2.99 95.13,2.99 95.02,3.1 95,3.1 94.84,3.26 94.84,4.26 94.95,4.37 UH2.BD10
PCH_SATA_LED#: length 7.6
  BOTTOM w0.089: UH2.AD44 77.98,14.18 76.9,14.18 76.76,14.04 v3(75.58,14.04) 75.55,14.07 75.06,14.07
  BOTTOM w0.127: 75.06,14.07 72.86,14.07 72.69,13.9 71.15,13.9 RH512.1
PCH_SMBCLK: length 409.1
  TOP w0.127: v2(171.64,9.37) 171.81,9.55 171.81,16.7 v2(171.98,16.87) ; v2(67.51,8.61) 67.88,8.61 69.19,7.3 70.4,7.3 RH463.2 70.7,7.57 71.89,6.37 QH4.1
  TOP w0.14: JXDP.53 129.6,98.51 130.03,98.93 130.51,98.93 130.98,99.4 134.01,99.4 137.76,95.65 137.76,88.4 v2(137.93,88.23) ; UF1.4 229.53,57.12 v2(229.69,57.29)
  IN1 w0.099: v2(137.93,88.23) 137.74,88.03 137.74,87.64 137.44,87.34 137.44,71.49 136.72,70.77 130.81,70.77 129.26,69.22 129.26,66.4 131.51,64.15 131.51,44.52 146.16,29.88 153.7,29.88 155.54,28.04 155.54,27.42 157.35,25.6 159.4,25.6 161.09,23.91 161.09,20.25 161.48,19.87 173.02,19.87 173.27,20.12 173.27,20.86 173.49,21.08 174.04,21.08 v2(174.25,21.28)
  IN3 w0.091: v2(248.98,27.82) 248.02,26.86 248.02,20.89 247.08,19.95 231.03,19.95 230.48,19.4 229.34,19.4 228.58,18.64 222.44,18.64 222.21,18.41 176.5,18.41 175.44,19.47 175.44,20.09 v2(174.25,21.28)
  IN6 w0.089: 101.98,7.6 101.53,7.15 99.65,7.15 99.07,6.57 97.82,6.57 97.15,5.9 96.14,5.9 95.4,5.15 92.59,5.15 92.05,4.62 88.57,4.62 87.91,3.96 86.63,3.96 86.4,4.19 82.21,4.19 81.85,4.55 81.85,5.62 81.31,6.17 79.35,6.17 78.97,5.79 78.73,5.79 78.28,6.24 75.93,6.24 75.8,6.11 75.06,6.11
  IN6 w0.099: 101.98,7.6 102.95,8.57 104.1,8.57 105.16,7.51 106.84,7.51 107.1,7.77 116.01,7.77 117.1,8.86 117.65,8.86 118.38,9.59 126.47,9.59 127.21,8.86 134.4,8.86 135.42,9.88 146.16,9.88 149.53,6.5 156.64,6.5 157.93,7.79 170.72,7.79 171.81,8.88 171.81,9.19 v2(171.64,9.37) ; v2(67.51,8.61) 67.7,8.8 68.99,8.8 69.47,8.32 70.81,8.32 70.99,8.14 70.99,7.71 72.21,6.49 72.21,6.32 72.43,6.11 75.06,6.11
  BOTTOM w0.127: JDIMM1.253 172.38,25.43 ; v2(174.25,21.28) 174.98,20.54 174.98,17.94 175.69,17.23 175.69,16.67 175.27,16.25 172.59,16.25 v2(171.98,16.87)
  BOTTOM w0.14: 172.38,25.43 174.25,23.56 v2(174.25,21.28) ; v2(229.69,57.29) 229.69,56.95 229.97,56.67 231.53,56.67 231.72,56.48 231.72,53.7 232.06,53.37 232.06,52.59 231.55,52.08 228.31,52.08 227.16,53.23 226.46,53.23 226.24,53.01 226.24,50.76 226.53,50.47 226.53,50.38 230.57,46.34 237.58,46.34 245.23,38.69 245.23,33.02 247.87,30.37 248.67,30.37 248.98,30.06 v2(248.98,27.82) 248.68,27.51 JDIMM2.253
PCH_SMBDATA: length 412.1
  TOP w0.127: v2(172.57,16.87) 172.04,16.34 172.04,9.55 172.22,9.37 v2(172.22,9.35)
  TOP w0.14: QH4.4 74.88,5.07 74.94,5.01 RH462.2 76.01,5.01 v2(76.07,4.95) ; v2(226.77,52.71) 226.77,54.48 227.71,55.42 UF1.6 ; JXDP.51 129.24,98.01 129.5,98.27 129.7,98.27 130.13,98.69 130.61,98.69 131.08,99.16 133.91,99.16 137.52,95.55 137.52,88.4 v2(137.34,88.23)
  IN1 w0.099: v2(174.25,20.68) 174.04,20.88 173.57,20.88 173.47,20.78 173.47,20.04 173.1,19.66 161.32,19.66 160.88,20.1 160.88,23.83 159.32,25.4 157.27,25.4 155.34,27.33 155.34,27.96 153.62,29.68 146.07,29.68 131.31,44.44 131.31,45.18 131.13,45.36 130.4,45.36 130.22,45.54 130.22,45.79 130.4,45.97 131.13,45.97 131.31,46.15 131.31,64.07 129.06,66.31 129.06,69.3 130.73,70.97 136.64,70.97 137.24,71.57 137.24,87.43 137.54,87.73 137.54,88.03 v2(137.34,88.23)
  IN3 w0.091: v2(249.62,20.27) 249.62,24.35 249.21,24.76 248.68,24.76 248.21,24.29 248.21,20.81 247.16,19.76 231.11,19.76 230.56,19.2 229.42,19.2 228.66,18.44 222.52,18.44 222.29,18.22 176.42,18.22 175.25,19.39 175.25,20.01 174.58,20.68 v2(174.25,20.68)
  IN6 w0.089: v2(76.07,4.95) 75.93,4.95 75.31,5.57 75.06,5.57 ; 75.06,5.91 75.43,5.91 75.97,5.37 76.81,5.37 76.94,5.5 77.75,5.5 77.84,5.41 78.49,5.41 78.66,5.58 78.91,5.58 79.55,4.94 79.55,4.25 79.68,4.12 80.41,4.12 80.5,4.21 80.5,4.47 80.38,4.59 80.06,4.59 79.94,4.72 79.94,5.15 80.04,5.25 80.27,5.25 80.57,4.95 80.77,4.95 80.86,4.86 80.86,4.19 80.94,4.12 81.14,4.12 81.24,4.21 81.24,5.55 81.33,5.63 81.5,5.63 81.59,5.55 81.59,4.26 81.86,4 82.36,4 82.46,3.89 82.46,3.28 82.57,3.18 82.71,3.18 82.82,3.28 82.82,3.89 82.92,4 83.07,4 83.17,3.89 83.17,3.28 83.28,3.18 83.42,3.18 83.53,3.28 83.53,3.89 83.63,4 83.78,4 83.88,3.89 83.88,3.28 83.99,3.18 84.14,3.18 84.24,3.28 84.24,3.89 84.34,4 84.49,4 84.6,3.89 84.6,3.28 84.7,3.18 84.85,3.18 84.95,3.28 84.95,3.89 85.05,4 85.2,4 85.31,3.89 85.31,3.28 85.41,3.18 85.56,3.18 85.66,3.28 85.66,3.89 85.77,4 86.32,4 86.55,3.77 87.99,3.77 88.65,4.43 92.13,4.43 92.67,4.96 95.72,4.96 95.82,4.86 96.61,4.86 96.87,5.12 97.89,5.12 99.72,6.94 101.63,6.94 101.98,7.3
  IN6 w0.099: 75.06,5.91 72.2,5.91 72.1,5.81 72.1,5.67 72.2,5.57 75.06,5.57 ; v2(172.22,9.35) 172.01,9.15 172.01,8.8 170.8,7.59 158.01,7.59 156.73,6.3 149.45,6.3 146.08,9.67 135.5,9.67 134.49,8.66 127.13,8.66 126.39,9.39 118.47,9.39 117.73,8.66 117.18,8.66 116.1,7.57 107.18,7.57 106.93,7.31 104.99,7.31 104.61,7.69 102.38,7.69 101.98,7.3
  BOTTOM w0.127: v2(172.57,16.87) 172.63,16.92 JDIMM1.254
  BOTTOM w0.14: v2(226.77,52.71) 226.77,50.48 230.67,46.58 237.68,46.58 245.47,38.79 245.47,33.12 247.97,30.62 251.97,30.62 252.79,29.79 252.79,26.02 251.61,24.84 251.08,24.84 249.62,23.38 v2(249.62,20.27) 249.62,19.69 248.93,19 JDIMM2.254 ; JDIMM1.254 172.63,19.09 173.55,20.01 173.55,20.44 173.79,20.68 v2(174.25,20.68)
PCH_SPI_CLK: length 11.1
  BOTTOM w0.14: UH8.6 61.36,6.36 60.35,5.34 60.35,4.88 60.78,4.44 62.21,4.44 62.9,3.76 63.4,3.76 64.01,3.15 64.01,2.6 64.22,2.39 65.26,2.39 65.85,1.8 v3(66.12,1.8) 67.38,1.8 67.56,1.99 RP4.1
PCH_SPI_CLK_R: length 24.5
  TOP w0.14: RH579.2 70.21,1.71 v2(70.26,1.76)
  IN1 w0.076: v2(84.14,1.72) 84.14,2.02 84.08,2.08 82.68,2.08 82.32,1.72 76.77,1.72 76.3,2.19 76.18,2.19 76.07,2.08
  IN1 w0.099: 76.07,2.08 76.07,1.64 75.95,1.52 75.79,1.52 75.67,1.64 75.67,2.46 75.55,2.57 75.39,2.57 75.27,2.46 75.27,2.11 75.16,1.99 74.99,1.99 74.88,2.11 74.88,2.13 74.41,2.6 72.81,2.6 72.44,2.23 70.33,2.23 70.26,2.16 v2(70.26,1.76)
  BOTTOM w0.089: v2(84.14,1.72) 84.24,1.72 84.37,1.85 84.37,2.11 84.25,2.22 v3(84.25,2.22) 84.25,2.41 84.79,2.95 84.79,4.35 84.89,4.45 84.89,4.61 84.58,4.92 UH2.BC31
  BOTTOM w0.14: v2(70.26,1.76) 70.26,1.76 70.11,1.91 69.6,1.91 69.47,1.79 69.47,1.48 69.34,1.36 69.09,1.36 68.96,1.48 68.96,1.99 RP4.8
PCH_SPI_CS1#: length 1.1
  TOP w0.089: v2(84.02,7.21) 84.4,6.83 T18.1
  BOTTOM w0.089: UH2.AW31 v2(84.02,7.21)
PCH_SPI_CS2#: length 92.3
  TOP w0.14: RE126.1 155.53,10.92 v2(155.22,10.61) ; RE133.1 148.26,8.59 147.7,9.15 147.7,9.66 v2(147.9,9.86) v3(147.9,10.8) ; RE132.1 162.31,9.15 161.53,9.93 160.58,9.93 160.4,10.11 v2(160.4,11.15)
  IN3 w0.089: 101.98,5.85 100.47,5.85 98.63,7.69 96.02,7.69 95.51,8.2 94.25,8.2 93.68,7.63 93.68,6.92 93.5,6.74 92.89,6.74 92.61,7.02 92.61,7.86 92.44,8.02 91.68,8.02 91.36,8.34 90.58,8.34 90.18,8.74 89.25,8.74 88.87,8.36 87.01,8.36 86.44,8.92 85.66,8.92 84.89,8.15 v2(84.89,7.97)
  IN3 w0.091: 101.98,5.85 105.1,5.85 106.63,7.37 111.2,7.37 111.32,7.25 114.89,7.25 115.47,7.83 115.47,8.52 116.07,9.12 120.11,9.12 121.84,10.85 146.83,10.85 146.91,10.77 146.92,10.77 147.83,9.86 v2(147.9,9.86) 147.99,9.95 148.67,9.95 149.97,11.25 154.58,11.25 v2(155.22,10.61) 155.25,10.58 159.86,10.58 160.4,11.12 v2(160.4,11.15)
  BOTTOM w0.089: v2(84.89,7.97) 84.87,7.97 84.46,8.38 UH2.AT31
PCH_SPI_CS2#_R: length 7.3
  TOP w0.14: v1(146.23,10.33) 146.94,9.62 146.94,9.15 147.7,8.39 147.7,7.92 147.94,7.68 RE133.2 148.77,7.25 150.62,7.25 150.81,7.43 UE1.20
PCH_SPI_CS#: length 36
  IN1 w0.076: v2(83.4,1.71) 83.25,1.56 77.15,1.56 77,1.41
  IN1 w0.099: v2(64.07,8.53) 64.07,8.14 65.79,6.42 65.79,5.98 66.93,4.83 67.78,4.83 68.22,4.4 68.22,2.42 69.3,1.33 72.49,1.33 73.15,1.99 73.81,1.99 74.47,1.33 76.92,1.33 77,1.41
  BOTTOM w0.089: UH2.BD31 84.58,3.08 83.83,2.33 83.83,2.14 v2(83.4,1.71)
  BOTTOM w0.14: UH8.1 69.32,8.9 69.44,9.03 69.44,9.24 68.96,9.72 68.96,9.97 RH74.2 66.73,9.01 64.55,9.01 v2(64.07,8.53)
PCH_SPI_HOLD#: length 18
  TOP w0.14: RH576.1 70.16,3.95 69.47,3.95 68.96,3.44 67.63,3.44 67.18,3.89 v2(66.91,3.89)
  IN1 w0.099: v2(59.79,4.23) 59.98,4.03 59.98,3.97 61.49,2.46 65.49,2.46 v2(66.91,3.89)
  BOTTOM w0.14: v2(59.79,4.23) 59.49,4.52 59.49,5.41 60.12,6.03 60.12,6.64 v3(59.87,6.89) 60.29,7.31 60.52,7.31 60.83,7.63 UH8.7
PCH_SPI_HOLD#_R: length 19.3
  TOP w0.14: 76.23,3.02 75.53,3.02 v3(75.3,2.79) 74.68,2.17 RH78.2 73.64,2.64 72.8,2.64 72.14,3.31 RH576.2 ; 76.23,3.02 76.23,2.41 RH455.2 ; 76.23,3.02 v2(76.23,3.03)
  IN1 w0.076: v2(76.23,3.03) 76.23,2.77 76.95,2.05 81.93,2.05 82.17,2.29 82.17,2.69 82.41,2.93 82.55,2.93 82.68,2.8 82.68,2.55 82.79,2.43 83.45,2.43 83.57,2.55 83.57,2.8 83.69,2.93 84.33,2.93 84.71,2.55 v2(84.71,2.36)
  BOTTOM w0.089: v2(84.71,2.36) 84.96,2.61 84.96,4.24 85.2,4.48 UH2.BD30
PCH_SPI_SI: length 10.3
  BOTTOM w0.14: UH8.5 63.33,5.09 63.79,5.55 63.97,5.55 64.18,5.33 64.18,5.15 63.73,4.69 63.73,4.5 64.61,3.62 v3(64.63,3.62) 64.99,3.62 65.74,2.87 66.05,2.87 66.18,2.74 66.18,2.26 66.31,2.13 66.56,2.13 66.69,2.26 66.69,2.74 66.82,2.87 67.17,2.87 67.3,2.74 67.3,2.59 67.4,2.49 RP4.2
PCH_SPI_SI_R: length 33.7
  TOP w0.14: v1(71.18,2.21) 71.02,2.37 v2(69.64,2.37) 69.56,2.29 67.74,2.29 RH578.2
  IN1 w0.076: v2(85.28,1.74) 85.28,2.29 84.43,3.15 82.26,3.15 81.33,2.22 77.74,2.22 77.33,2.63 77.33,2.88 76.51,3.7 75.6,3.7 75.06,4.25
  IN1 w0.099: 75.06,4.25 74.93,4.38 74.47,4.38 74.32,4.53 74.32,4.72 74.21,4.83 74.04,4.83 73.91,4.71 73.91,4.24 73.79,4.12 73.63,4.12 73.51,4.24 73.51,4.71 73.39,4.83 71.88,4.83 71.78,4.74 71.78,4.58 71.68,4.48 71.48,4.48 71.38,4.58 71.38,4.72 71.27,4.83 71.1,4.83 70.98,4.72 70.98,4.58 70.89,4.48 70.69,4.48 70.59,4.58 70.59,4.74 70.49,4.83 70.21,4.83 69.99,4.61 69.99,4.47 70.12,4.34 70.12,4.2 69.98,4.06 69.84,4.06 69.71,4.19 69.57,4.19 69.01,3.64 69.01,2.68 69.32,2.37 v2(69.64,2.37)
  BOTTOM w0.089: v2(85.28,1.74) 85.34,1.8 85.34,2.47 85.34,2.48 85.34,3.19 85.34,3.19 85.34,3.91 85.43,3.99 85.43,4.87 85.53,4.96 85.53,5.15 85.74,5.36 UH2.BB29
  BOTTOM w0.14: RP4.7 69.31,2.49 69.43,2.38 69.64,2.38 ; 69.64,2.38 v2(69.64,2.37) ; 69.64,2.38 70.01,2.74 70.01,2.94 RH489.1
PCH_SPI_SO: length 11.4
  BOTTOM w0.14: RP4.3 67.56,2.99 67.44,3.11 66.36,3.11 v3(66.14,3.33) 66.07,3.33 65.58,3.82 65.58,4.23 64.78,5.03 64.78,5.5 64.38,5.9 64.38,7.58 64.71,7.91 67.41,7.91 67.69,7.63 UH8.2
PCH_SPI_SO_R: length 29.9
  TOP w0.14: v2(69.91,3.47) 69.91,3.3 69.45,2.83 67.03,2.83 RH577.2
  IN1 w0.076: v2(84.71,1.72) 84.19,2.24 82.53,2.24 82.17,1.89 76.86,1.89 75.52,3.23 75.06,3.23
  IN1 w0.099: v2(69.91,3.47) 69.72,3.28 69.72,3.11 69.98,2.85 70.4,2.85 70.53,2.98 70.53,3.87 70.65,3.98 70.81,3.98 70.93,3.87 70.93,2.96 71.04,2.84 71.21,2.84 71.32,2.96 71.32,3.86 71.44,3.97 71.6,3.97 71.72,3.86 71.72,3.21 71.85,3.08 72.06,3.08 72.19,3.21 72.19,3.82 72.32,3.95 72.46,3.95 72.59,3.82 72.59,3.33 72.7,3.21 72.87,3.21 72.98,3.33 72.98,3.68 73.1,3.79 73.26,3.79 73.38,3.68 73.38,3.34 73.51,3.21 74.32,3.21 74.45,3.34 74.45,3.39 74.58,3.51 74.8,3.51 74.93,3.39 74.93,3.36 75.06,3.23
  BOTTOM w0.089: v2(84.71,1.72) 85.14,2.15 85.14,4 85.2,4.05 UH2.BE30
  BOTTOM w0.14: v2(69.91,3.47) 69.43,2.99 RP4.6
PCH_SPI_WP#: length 15.8
  BOTTOM w0.14: RP4.4 68.12,3.49 68.27,3.64 68.27,4.38 68.08,4.57 67.7,4.57 67.36,4.91 66.42,4.91 66.09,4.58 65.96,4.58 65.51,5.04 65.51,5.29 65.63,5.42 65.93,5.42 66.05,5.55 66.05,5.77 65.93,5.9 65.43,5.9 65.3,6.03 65.3,6.31 65.02,6.59 65.02,7.24 65.18,7.39 65.46,7.39 65.61,7.24 65.61,6.69 65.74,6.56 66.85,6.56 66.93,6.49 66.93,5.98 67.06,5.85 67.44,5.85 67.57,5.98 67.57,6.61 68.06,7.11 69.19,7.11 69.44,6.87 69.44,6.48 69.32,6.36 UH8.3
PCH_SPI_WP#_R: length 26.7
  TOP w0.14: v2(68.7,4.03) 68.92,4.03 69.39,4.5 RH573.2 ; RH75.2 81.03,2.74 v2(81.1,2.82)
  IN1 w0.076: v2(85.8,1.51) 85.8,1.77 85.61,1.96 85.61,2.2 84.49,3.31 82.16,3.31 81.66,2.82 v2(81.1,2.82) 79.99,2.82 79.03,3.77 77.08,3.77 76.71,4.14 75.82,4.14 75.06,4.9
  IN1 w0.099: 75.06,4.9 74.95,4.9 74.52,5.32 70,5.32 v2(68.7,4.03)
  BOTTOM w0.089: UH2.BC29 85.76,4.79 85.61,4.64 85.61,3.92 85.52,3.83 85.52,3.11 85.52,3.11 85.52,2.55 85.52,2.55 85.52,2.05 85.8,1.78 v2(85.8,1.51)
  BOTTOM w0.14: v2(68.7,4.03) 69.06,4.03 69.29,3.79 69.29,3.62 69.17,3.49 RP4.5
PCH_SRTCRST#: length 3.5
  TOP w0.089: v2(95.1,6.08) 94.71,6.08 94.11,5.47 CH52.1 93.22,4.33 RH83.2
  BOTTOM w0.089: v2(95.1,6.08) 94.83,5.81 UH2.BB10
PCH_SYS_PWROK_XDP: length 183
  TOP w0.14: JXDP.47 127.13,97.01 126.73,96.62 126.51,96.62 125.65,95.77 v2(125.65,95.61) ; v2(62.1,3.95) 62.1,5.22 61.88,5.44 61.88,6.45 61.47,6.87 61.47,7.21 61.02,7.65 61.02,7.84 60.6,8.26 60.6,9.08 60.35,9.32 59.77,9.32 59.67,9.42 59.24,9.42 59.22,9.44 58.99,9.66 58.99,10.11 59.37,10.49 59.59,10.49 60.22,11.12 60.22,11.41 v1(60.84,12.03) 61.51,12.69 61.51,13.89 64.12,16.51 64.12,17.8 65.08,18.75 65.08,20.34 64.64,20.77 64.64,21.6 64.2,22.04 63.25,22.04 61.85,23.44 61.85,27.51 62.17,27.83 v2(62.17,28.36)
  IN2 w0.099: v2(72.07,2.66) 71.96,2.78 65.84,2.78 65.01,3.61 63.71,3.61 63.63,3.69 62.36,3.69 v2(62.1,3.95) ; v2(62.17,28.36) 63.29,29.47 68.95,29.47 69.34,29.08 73.82,29.08 73.92,29.18 80.29,29.18 81.09,29.98 84.65,29.98 88.52,33.85 97.66,33.85 100.98,37.17 104.67,37.17 v2(104.89,36.95) ; v2(125.65,95.61) 125.65,95.75 126.51,96.61 127,96.61 130.39,93.21 131.64,93.21 v2(131.66,93.19)
  IN6 w0.099: v2(125.65,95.61) 124.16,95.61 123.72,95.18 123.72,93.67 123.98,93.42 126.71,93.42 127.95,92.17 127.95,85.54 129.25,84.25 129.69,84.25 130,83.94 130,79.12 127.09,76.21 127.09,71.09 125.11,69.11 125.11,66.15 124.26,65.31 121.82,65.31 120.84,64.32 120.84,63.64 117.95,60.75 117.95,56.42 116.82,55.29 116.82,53.13 116.25,52.57 116.25,45.46 108.33,37.54 105.47,37.54 v2(104.89,36.95)
  BOTTOM w0.14: RH489.2 72.07,2.82 v2(72.07,2.66) ; v2(131.66,93.19) 129.21,93.19 RH490.2 RH493.2
PCH_TPM_CLK: length 101.8
  TOP w0.14: v2(62.31,5.67) 62.31,5.58 63.63,4.26 63.63,3.45 v1(64.17,2.9) 64.53,2.55 65.1,2.55 66.31,1.34 68.03,1.34 RH579.1 ; v2(148.34,9.47) 148.34,9.47 148.66,9.15 148.79,9.15 RE115.1
  IN2 w0.089: 75.06,2.78 75.97,2.78 76.37,2.38 81.37,2.38 82.58,3.59 83.39,3.59 83.96,4.16 85.04,4.16 85.49,4.61 88.15,4.61 88.27,4.74 92.12,4.74 92.51,5.13 95.19,5.13 95.89,5.83 96.2,5.83 96.62,6.24 97.77,6.24 98.14,6.61 99.15,6.61 99.7,7.15 100.24,7.15 101.06,7.97 101.98,7.97
  IN2 w0.099: 101.98,7.97 102.31,7.97 102.93,8.59 103.37,8.59 104.07,7.89 107.94,7.89 108.06,7.77 115.99,7.77 118.7,10.47 146.19,10.47 147.26,9.41 148.13,9.41 148.2,9.47 v2(148.34,9.47) ; v2(62.31,5.67) 62.97,5.01 72.5,5.01 74.73,2.78 75.06,2.78
PCH_TPM_CLK_C: length 2.7
  TOP w0.14: RE115.2 149.33,7.71 RE11.1 150.28,7.71 v2(150.84,8.26) 150.88,8.26 151.21,7.93 UE1.19
PCH_TPM_SI: length 95.8
  TOP w0.14: v2(146.92,8.26) 146.92,7.75 148.02,6.65 RE114.1 ; v3(63.95,5.11) 64.63,4.43 v2(64.63,4.33) 64.63,3.91 65.41,3.13 65.41,2.66 65.99,2.08 RH578.1
  IN2 w0.089: 101.98,7.49 101.1,7.49 100.41,6.8 99.95,6.8 98.26,5.11 97.28,5.11 96.95,4.78 92.66,4.78 92.26,4.38 88.42,4.38 88.29,4.26 85.66,4.26 85.21,3.81 84.11,3.81 83.54,3.24 82.73,3.24 81.51,2.02 76.22,2.02 75.87,2.37 75.06,2.37
  IN2 w0.099: v2(146.92,8.26) 146.92,8.94 146.33,9.53 135.88,9.53 135.18,8.83 117.62,8.83 116.16,7.37 107.89,7.37 107.77,7.49 101.98,7.49 ; v2(64.63,4.33) 64.76,4.45 65.47,4.45 66.44,3.49 68.78,3.49 69.39,4.1 71.98,4.1 72.58,3.5 73.27,3.5 74.4,2.37 75.06,2.37
PCH_TPM_SO: length 98.4
  TOP w0.14: v2(65.16,4.03) 65.36,4.23 v1(65.69,4.23) 65.93,3.98 RH577.1 ; v2(146.14,9.04) 146.14,7.57 147.62,6.09 147.62,2.95 148.35,2.22 150.99,2.22 RE113.1
  IN2 w0.089: 101.98,7.29 101.22,7.29 100.55,6.62 100.02,6.62 98.33,4.93 97.35,4.93 97.02,4.6 92.74,4.6 92.34,4.2 88.49,4.2 88.37,4.08 85.73,4.08 85.28,3.63 84.44,3.63 83.24,2.43 82.17,2.43 81.59,1.84 75.39,1.84 75.06,2.17
  IN2 w0.099: v2(65.16,4.03) 66.12,3.07 73.38,3.07 74.27,2.17 75.06,2.17 ; v2(146.14,9.04) 145.95,9.23 135.87,9.23 135.26,8.63 117.7,8.63 115.46,6.39 108.59,6.39 107.69,7.29 101.98,7.29
PCH_TRIGGER: length 135.5
  TOP w0.14: RH167.1 182.96,61.65 v2(183.49,61.12) 183.49,60.37 v1(183.48,60.36)
  IN5 w0.099: v2(176.37,23.86) 176.63,23.6 176.63,20.66 175.76,19.79 175.76,19.32 174.78,18.35 149.85,18.35 149.68,18.51 141.81,18.51 141.48,18.18 134.44,18.18 134.2,18.42 106.71,18.42 v2(105.72,19.42)
  IN6 w0.099: v2(183.49,61.12) 183.49,55.9 184.21,55.18 184.21,53.61 184.21,53.27 184.21,38.15 177.27,31.2 177.27,27.18 176.8,26.71 175.91,26.71 175.52,26.32 175.52,24.39 176.05,23.86 v2(176.37,23.86)
  BOTTOM w0.089: 101.96,11.22 101.63,10.89 99.12,10.89 99.02,10.99 UH2.AL2
  BOTTOM w0.127: v2(105.72,19.42) 105.72,18.23 106.26,17.69 106.26,15.93 106.33,15.87 106.33,12.66 105.34,11.67 104.34,11.67 103.9,11.22 101.96,11.22
PCH_TRIGGER_R: length 21.5
  TOP w0.14: RH167.2 182.76,63 v2(182.1,63.65) 182.44,63.99 v1(182.44,64.32)
  IN6 w0.089: 181.1,64.05 179.58,64.05 177.78,65.86 177.78,67.86 177.47,68.17 177.47,75.62 177.23,75.87 174.25,75.87 v2(173.86,75.47)
  IN6 w0.099: v2(182.1,63.65) 181.7,64.05 181.1,64.05
  BOTTOM w0.076: v2(173.86,75.47) 173.48,75.84 UH1.H23
PCH_XDP_CLK_N: length 98.8
  TOP w0.152: v2(125.83,94.98) 125.73,94.88 124.93,94.88 124.38,95.42 123.74,95.42 123.65,95.51 JXDP.42
  IN6 w0.107: v2(100.72,20.47) 100.67,20.52 100.67,21.87 99.47,23.07 99.47,24.46 99.14,24.79 99.14,28.17 102.38,31.41 104.57,31.41 116.94,43.78 116.94,51.83 117.57,52.46 117.57,54.97 118.63,56.03 118.63,59.96 122.12,63.45 123.32,63.45 125.86,65.99 125.86,68.79 127.77,70.7 127.77,75.93 131.03,79.18 131.03,84.79 129.08,86.73 129.08,92.9 127.31,94.67 126.14,94.67 v2(125.83,94.98)
  BOTTOM w0.102: v2(100.72,20.47) 100.31,20.05 100.01,20.05 99.71,20.35 99.71,20.51 99.51,20.7 UH2.L1
PCH_XDP_CLK_P: length 98.3
  TOP w0.152: JXDP.40 123.63,95.01 123.71,95.09 124.25,95.09 124.79,94.55 125.67,94.55 v2(125.83,94.38)
  IN6 w0.107: v2(125.83,94.38) 125.92,94.47 127.22,94.47 128.88,92.81 128.88,86.65 130.82,84.71 130.82,79.27 127.57,76.01 127.57,70.78 125.66,68.87 125.66,66.07 123.23,63.65 122.04,63.65 118.43,60.04 118.43,56.12 117.36,55.05 117.36,52.54 116.74,51.92 116.74,43.87 104.49,31.62 102.3,31.62 98.93,28.26 98.93,24.71 99.26,24.38 99.26,22.99 100.47,21.78 100.47,20.75 v2(100.17,20.44)
  BOTTOM w0.102: UH2.L2 98.93,20.7 99.21,20.98 99.63,20.98 99.82,20.79 99.82,20.79 v2(100.17,20.44)
PCI_CLK_LPC1: length 214.3
  IN3 w0.091: v2(283.3,20.74) 283.13,20.57 283.04,20.57 281.68,19.21 281.68,17.33 275.55,11.2 274.42,11.2 271.79,8.56 263.14,8.56 262.92,8.77 259.67,8.77 257.58,6.69 246.5,6.69 245.89,6.08 244.62,6.08 242.26,8.43 236.03,8.43 234.15,6.55 226.26,6.55 225.57,5.86 214.7,5.86 210.88,9.69 174.93,9.69 173.86,10.75 165.89,10.75 164.72,9.58 158.69,9.58 158.35,9.91 156.04,9.91 155.7,9.58 152.85,9.58 152.12,8.85 147.67,8.85 146.53,9.99 135.84,9.99 135.05,9.2 128.62,9.2 128.36,9.46 121.39,9.46 120.06,8.12 117.8,8.12 115.25,5.58 109.35,5.58 108.64,4.86 106.89,4.86 v2(106.86,4.9)
  BOTTOM w0.14: CH199.1 108.81,4.96 108.75,4.9 v2(106.86,4.9) 106.38,5.38 RH428.2 ; JLPDE1.10 296.2,30.78 295.4,29.98 295.4,29.8 295.43,29.8 295.43,26.86 294.95,26.37 294.92,26.37 294.41,25.87 294.4,25.87 294.36,25.82 293.71,25.82 v3(293.11,25.22) 292.46,24.57 289.97,24.57 289.51,24.11 287.86,24.11 284.48,20.74 v2(283.3,20.74)
PCIE_PRX_CARDTX_N2: length 264.4
  IN2 w0.107: v2(91.9,23.43) 91.9,23.22 92.04,23.08 92.48,23.08 92.66,22.9 92.66,21.61 93.14,21.13 93.85,21.13 94.3,20.68 94.3,18.4 94.88,17.82 130.06,17.82 130.37,17.51 151.1,17.51 151.52,17.09 151.52,16.58 152.06,16.04 154.38,16.04 157.01,13.41 175.23,13.41 175.92,12.72 211.91,12.72 214.23,10.39 224.29,10.39 224.89,11 235.98,11 236.67,11.69 253.18,11.69 253.43,11.44 263.08,11.44 263.54,11.89 268.27,11.89 269.07,11.09 280.84,11.09 283.09,8.85 287.97,8.85 288.35,8.46 292.98,8.46 293.61,7.83 295.44,7.83 295.9,8.28 295.9,8.77 296.94,9.82 302.87,9.82 303.35,9.33 310.01,9.33 313.44,12.76 313.44,15.87 326.45,28.89 328.36,28.89 328.5,29.02 328.5,29.16 v2(328.33,29.32)
  BOTTOM w0.089: v2(91.9,23.43) 91.56,23.77 UH2.E17
  BOTTOM w0.152: v2(328.33,29.32) 328.46,29.45 328.46,29.74 328.81,30.08 332.13,30.08 332.26,30.21 332.26,30.3 CR13.1
PCIE_PRX_CARDTX_N2_C: length 2.7
  BOTTOM w0.152: CR13.2 332.12,31.89 332.12,32.26 332.26,32.4 332.26,33.46 332.48,33.68 UR1.8
PCIE_PRX_CARDTX_P2: length 264.4
  IN2 w0.107: v2(328.92,29.32) 328.7,29.1 328.7,28.94 328.45,28.69 326.54,28.69 313.64,15.79 313.64,12.68 310.09,9.13 303.27,9.13 302.78,9.62 297.03,9.62 296.1,8.69 296.1,8.2 295.53,7.63 293.53,7.63 292.89,8.26 288.27,8.26 287.89,8.65 283,8.65 280.76,10.89 268.99,10.89 268.19,11.69 263.62,11.69 263.17,11.24 253.35,11.24 253.09,11.49 236.76,11.49 236.07,10.8 224.97,10.8 224.37,10.19 214.15,10.19 211.82,12.52 175.83,12.52 175.15,13.2 156.93,13.2 154.29,15.84 151.97,15.84 151.32,16.49 151.32,17.01 151.02,17.31 130.28,17.31 129.98,17.62 94.79,17.62 94.1,18.31 94.1,20.6 93.77,20.93 93.06,20.93 92.46,21.53 92.46,22.82 92.39,22.88 92.13,22.88 v2(91.94,22.69)
  BOTTOM w0.089: v2(91.94,22.69) 91.62,23.01 UH2.G17
  BOTTOM w0.152: v2(328.92,29.32) 328.79,29.45 328.79,29.6 328.94,29.75 332.27,29.75 332.59,30.07 332.59,30.55 CR10.1
PCIE_PRX_CARDTX_P2_C: length 2.7
  BOTTOM w0.152: CR10.2 332.45,31.91 332.45,32.13 332.59,32.27 v4(332.59,32.74) 332.59,33.32 332.88,33.62 UR1.7
PCIE_PRX_SSDTX_N10: length 188.5
  IN1 w0.119: v2(85.02,22.75) 85.15,22.88 85.53,22.88 85.88,23.23 85.88,23.66 86.23,24.01 88.4,24.01 89.53,25.14 93.9,25.14 94.22,25.46 98.32,25.46 98.62,25.17 101.79,25.17 102.22,24.74 102.22,19.9 103.42,18.7 130.57,18.7 131.63,17.64 151.23,17.64 151.68,17.18 151.68,16.64 152.11,16.21 154.4,16.21 155.81,14.8 244.23,14.8 244.98,14.05 251.07,14.05 251.87,13.25 256.89,13.25 257.69,14.05 258.98,14.05 259.47,14.54 259.47,15.13 259.21,15.39 258.9,15.39 v2(258.75,15.54)
  BOTTOM w0.089: v2(85.02,22.75) 85.38,23.11 UH2.G29
  BOTTOM w0.17: v2(258.75,15.54) 258.81,15.48 259.34,15.48 259.41,15.54 JNGFF2.29
PCIE_PRX_SSDTX_N11: length 194.4
  IN1 w0.119: v2(83.92,20.54) 83.78,20.69 83.56,20.69 83.21,21.04 83.21,21.65 83.32,21.76 83.32,23.1 84.5,24.28 85.03,24.28 86.18,25.43 88.13,25.43 90.73,28.02 102.76,28.02 103.3,28.55 110.66,28.55 111.25,27.96 111.25,26.53 112.25,25.53 112.87,25.53 115.13,23.28 115.13,20.28 115.52,19.88 131.04,19.88 132,18.93 147.08,18.93 147.39,18.62 154,18.62 155.31,17.31 155.31,16.72 156.29,15.75 244.63,15.75 245.22,15.16 251.46,15.16 252.32,14.3 255.7,14.3 258.52,17.12 258.52,18.15 258.78,18.41 259.05,18.68 v2(259.22,18.68)
  BOTTOM w0.089: v2(83.92,20.54) 84.17,20.8 UH2.L31
  BOTTOM w0.17: JNGFF2.17 259.71,18.54 259.57,18.68 v2(259.22,18.68)
PCIE_PRX_SSDTX_N12: length 197.7
  IN1 w0.119: v2(82.92,22.68) 82.92,22.51 82.81,22.4 82.59,22.4 82.49,22.5 82.49,23.47 85.06,26.04 87.68,26.04 90.08,28.44 102.29,28.44 102.91,29.07 111.41,29.07 112.15,28.34 112.15,27.22 112.69,26.68 113.02,26.68 114.91,24.79 149.25,24.79 149.93,24.11 149.93,20.46 150.55,19.85 151.46,19.85 151.94,19.36 154.38,19.36 156.52,17.23 156.52,16.74 157.07,16.18 246.75,16.18 246.87,16.06 251.31,16.06 252.58,14.79 255.59,14.79 257.5,16.7 257.5,19.37 258.17,20.04 259.03,20.04 259.47,20.47 259.47,21.1 259.15,21.41 259.01,21.41 v2(258.8,21.62)
  BOTTOM w0.089: v2(82.92,22.68) 83.17,22.93 UH2.G33
  BOTTOM w0.17: v2(258.8,21.62) 258.88,21.54 JNGFF2.5
PCIE_PRX_SSDTX_P10: length 188.6
  IN1 w0.119: v2(258.75,14.96) 258.92,15.13 259.1,15.13 259.21,15.02 259.21,14.65 258.87,14.31 257.58,14.31 256.79,13.51 251.98,13.51 251.18,14.31 245.08,14.31 244.34,15.06 155.92,15.06 154.51,16.47 152.22,16.47 151.94,16.74 151.94,17.29 151.34,17.9 131.73,17.9 130.67,18.96 103.53,18.96 102.48,20.01 102.48,24.85 101.9,25.43 98.72,25.43 98.43,25.72 94.11,25.72 93.79,25.4 89.42,25.4 88.3,24.27 86.13,24.27 85.62,23.76 85.62,23.33 85.42,23.14 84.89,23.14 84.79,23.24 84.79,23.39 84.91,23.51 v2(85.02,23.51)
  BOTTOM w0.089: v2(85.02,23.51) 85.49,23.51 85.66,23.68 85.66,23.77 UH2.E29
  BOTTOM w0.17: v2(258.75,14.96) 258.84,15.04 JNGFF2.31
PCIE_PRX_SSDTX_P11: length 194.5
  IN1 w0.119: v2(259.22,18.1) 259.1,18.22 258.95,18.22 258.88,18.15 258.78,18.04 258.78,17.01 255.8,14.04 252.21,14.04 251.35,14.9 245.11,14.9 244.52,15.49 156.18,15.49 155.05,16.62 155.05,17.2 153.89,18.37 147.28,18.37 146.97,18.67 131.89,18.67 130.94,19.63 115.41,19.63 114.87,20.17 114.87,23.17 112.77,25.27 112.14,25.27 110.99,26.42 110.99,27.85 110.56,28.29 103.4,28.29 102.87,27.76 90.83,27.76 88.24,25.17 86.28,25.17 85.14,24.02 84.61,24.02 83.58,23 83.58,21.65 83.47,21.54 83.47,21.15 83.67,20.95 84.06,20.95 84.18,21.07 84.18,21.23 84.06,21.34 v2(83.92,21.34)
  BOTTOM w0.089: UH2.K31 84.42,21.33 84.33,21.23 84.04,21.23 v2(83.92,21.34)
  BOTTOM w0.17: v2(259.22,18.1) 259.37,18.25 259.41,18.25 259.62,18.04 JNGFF2.19
PCIE_PRX_SSDTX_P12: length 197.6
  IN1 w0.119: v2(258.8,21.04) 258.92,21.15 259.04,21.15 259.21,20.99 259.21,20.58 258.92,20.3 258.06,20.3 257.24,19.48 257.24,16.81 255.48,15.05 252.69,15.05 251.42,16.32 246.98,16.32 246.86,16.44 157.17,16.44 156.77,16.84 156.77,17.34 154.49,19.62 152.05,19.62 151.57,20.11 150.65,20.11 150.19,20.57 150.19,24.22 149.36,25.05 115.02,25.05 113.13,26.94 112.8,26.94 112.41,27.33 112.41,28.44 111.52,29.33 102.81,29.33 102.18,28.7 89.97,28.7 87.57,26.3 84.95,26.3 82.23,23.58 82.23,22.39 82.48,22.14 82.66,22.14 v2(82.89,21.9)
  BOTTOM w0.089: UH2.H33 83.15,22.16 v2(82.89,21.9)
  BOTTOM w0.17: JNGFF2.7 259.41,21.04 259.34,21.11 258.88,21.11 v2(258.8,21.04)
PCIE_PRX_TBTX_N15: length 57.1
  IN6 w0.107: v2(31.2,32.62) 30.98,32.39 30.98,32.13 31.54,31.57 32.46,31.57 35.45,34.55 42.61,34.55 46.87,30.29 50.61,30.29 50.98,29.93 59.67,29.93 60.63,28.97 63.63,28.97 66.75,25.85 74.39,25.85 75.38,24.86 79.11,24.86 79.52,24.46 79.65,24.46 79.86,24.25 79.86,23.91 80,23.77 v2(80.16,23.77)
  BOTTOM w0.089: v2(80.16,23.77) 79.91,23.52 UH2.F41
  BOTTOM w0.152: CT3.1 31.05,33.05 31.05,32.76 v2(31.2,32.62)
PCIE_PRX_TBTX_N15_C: length 3
  BOTTOM w0.089: UT1.V22 30.02,35.84 30.02,35.84 30.03,35.83 30.03,35.29 30.28,35.05 30.52,35.05 31.07,34.5 31.07,34.3
  BOTTOM w0.152: 31.07,34.3 31.07,33.88 CT3.2
PCIE_PRX_TBTX_N16: length 59.2
  IN6 w0.107: v2(28.53,32.62) 28.41,32.62 28.04,32.24 28.04,31.99 29.27,30.76 32.53,30.76 35.7,33.93 42.37,33.93 46.62,29.68 50.36,29.68 50.72,29.31 59.41,29.31 60.83,27.89 63.84,27.89 66.55,25.18 74.18,25.18 75.89,23.47 78.16,23.47 78.33,23.64 78.33,23.71 v2(78.17,23.87)
  BOTTOM w0.089: UH2.D43 78.54,24.1 78.54,23.95 78.47,23.89 78.18,23.89 v2(78.17,23.87)
  BOTTOM w0.152: v2(28.53,32.62) 28.29,32.86 28.29,33.09 CT7.1
PCIE_PRX_TBTX_N16_C: length 2.5
  BOTTOM w0.089: 28.18,34.87 28.19,34.88 28.19,35.83 28.18,35.84 28.18,35.84 UT1.P22
  BOTTOM w0.102: 28.18,34.87 28.18,34.42 28.22,34.39 28.22,34.3
  BOTTOM w0.152: 28.22,34.3 28.22,33.93 CT7.2
PCIE_PRX_TBTX_P15: length 57.1
  IN6 w0.107: v2(79.36,23.72) 79.58,23.72 79.66,23.8 79.66,24.16 79.57,24.25 79.43,24.25 79.02,24.66 75.3,24.66 74.31,25.65 66.66,25.65 63.55,28.76 60.55,28.76 59.59,29.72 50.89,29.72 50.53,30.09 46.79,30.09 42.52,34.35 35.54,34.35 32.55,31.36 31.45,31.36 30.77,32.04 30.77,32.31 30.77,32.31 30.77,32.46 v2(30.61,32.62)
  BOTTOM w0.089: v2(79.36,23.72) 79.66,24.03 UH2.E41
  BOTTOM w0.152: v2(30.61,32.62) 30.72,32.72 30.72,33.07 CT1.1
PCIE_PRX_TBTX_P15_C: length 3
  BOTTOM w0.089: 30.74,34.3 30.74,34.31 30.77,34.34 30.77,34.42 30.41,34.78 30.15,34.78 29.56,35.37 29.56,35.68 29.63,35.76 29.72,35.76 29.79,35.69 UT1.V23
  BOTTOM w0.152: CT1.2 30.62,33.77 30.74,33.88 30.74,34.3
PCIE_PRX_TBTX_P16: length 59.3
  IN6 w0.107: v2(27.83,32.62) 27.83,31.91 29.19,30.55 32.61,30.55 35.78,33.72 42.28,33.72 46.53,29.47 50.27,29.47 50.64,29.11 59.32,29.11 60.75,27.68 63.76,27.68 66.46,24.98 74.09,24.98 75.81,23.26 78.25,23.26 78.39,23.41 v2(78.73,23.41)
  BOTTOM w0.089: v2(78.73,23.41) 78.92,23.59 UH2.E42
  BOTTOM w0.152: CT5.1 27.96,33.04 27.96,32.74 v2(27.83,32.62)
PCIE_PRX_TBTX_P16_C: length 2.4
  BOTTOM w0.089: UT1.P23 27.95,35.69 27.88,35.76 27.79,35.76 27.72,35.68 27.72,35.37 27.95,35.14 27.95,34.84
  BOTTOM w0.102: 27.95,34.84 27.95,34.42 27.9,34.38 27.9,34.33 27.89,34.31 27.89,34.3
  BOTTOM w0.152: CT5.2 27.89,33.84 27.89,34.3
PCIE_PRX_WLANTX_N1: length 330.8
  IN2 w0.119: v2(338.99,85.35) 338.8,85.17 338.8,84.81 333.93,79.94 333.93,67.52 340.83,60.62 340.83,35.57 339.4,34.14 339.4,33.64 336.09,30.33 327.2,30.33 322.97,26.11 322.97,26.11 312.78,15.91 312.78,12.83 309.82,9.86 303.52,9.86 303.07,10.31 296.66,10.31 296.08,9.74 292.64,9.74 292.14,10.23 289.33,10.23 288.44,9.34 286.15,9.34 284.93,10.56 284.06,10.56 283.76,10.85 282.11,10.85 280.62,12.35 276.02,12.35 274.3,14.07 265.79,14.07 265.03,14.84 265.03,15.53 264.64,15.92 264.35,15.92 v2(264.22,15.79)
  IN3 w0.112: v2(264.22,15.79) 264.06,15.96 257.09,15.96 255.94,14.82 253.56,14.82 251.84,13.1 233.22,13.1 232.63,12.51 225.03,12.51 224.06,11.53 215.87,11.53 215.17,10.83 212.29,10.83 211.02,12.1 124.29,12.1 121.4,14.99 108.09,14.99 107.64,15.44 107.64,16.23 106.61,17.26 104.22,17.26 103.54,17.94 94.39,17.94 93.58,18.75 93.58,21.85 93.43,22 93.21,22 v2(93.09,21.88)
  BOTTOM w0.089: v2(93.09,21.88) 92.73,22.24 UH2.H15
  BOTTOM w0.17: v2(338.99,85.35) 338.86,85.23 338.86,84.92 339.05,84.73 JNGFF1.35
PCIE_PRX_WLANTX_P1: length 330.8
  IN2 w0.119: v2(338.41,85.35) 338.54,85.21 338.54,84.92 333.68,80.05 333.68,67.41 340.57,60.52 340.57,35.68 339.14,34.25 339.14,33.75 335.99,30.59 327.09,30.59 322.87,26.37 322.86,26.37 312.52,16.02 312.52,12.93 309.71,10.12 303.63,10.12 303.18,10.57 296.55,10.57 295.98,9.99 292.74,9.99 292.25,10.49 289.22,10.49 288.34,9.6 286.25,9.6 285.04,10.81 284.17,10.81 283.87,11.11 282.21,11.11 280.72,12.6 276.13,12.6 274.4,14.33 265.9,14.33 265.28,14.94 265.28,15.64 264.75,16.18 264.42,16.18 v2(264.22,16.38)
  IN3 w0.112: v2(264.22,16.38) 264.06,16.21 256.99,16.21 255.84,15.06 253.45,15.06 251.74,13.35 233.12,13.35 232.53,12.75 224.93,12.75 223.95,11.78 215.77,11.78 215.07,11.07 212.39,11.07 211.12,12.35 124.39,12.35 121.5,15.24 108.19,15.24 107.89,15.55 107.89,16.33 106.71,17.51 104.32,17.51 103.64,18.19 94.49,18.19 93.83,18.85 93.83,21.97 93.54,22.26 93.02,22.26 92.94,22.34 92.94,22.54 v2(93.05,22.65)
  BOTTOM w0.089: UH2.G15 92.78,23.01 93.05,22.73 v2(93.05,22.65)
  BOTTOM w0.17: v2(338.41,85.35) 338.41,85.32 338.43,85.3 338.43,84.74 338.55,84.62 JNGFF1.33
PCIE_PTX_CARDRX_N2: length 275
  IN2 w0.107: v2(89.98,26.36) 90.03,26.36 90.39,26.01 90.62,26.01 90.83,25.79 90.83,24.26 91.5,23.59 91.5,21.28 92.79,20 92.79,18.27 93.85,17.2 101.79,17.2 102.29,16.7 102.29,16.22 102.72,15.79 151.36,15.79 151.82,15.33 154.12,15.33 156.68,12.77 174.98,12.77 175.7,12.05 211.71,12.05 213.99,9.76 225.66,9.76 226.7,8.73 234.47,8.73 234.98,9.24 234.98,9.43 235.93,10.38 249.83,10.38 250.02,10.19 260.22,10.19 260.41,10.38 272.76,10.38 275.99,7.16 279.75,7.16 280.83,8.23 287.71,8.23 288.19,7.76 292.56,7.76 293.1,7.21 296.11,7.21 296.53,7.64 307.14,7.64 308.17,8.67 310.22,8.67 314.38,12.84 318.18,12.84 320.92,15.58 320.92,22.49 326.61,28.18 329,28.18 330.24,29.42 334.66,29.42 334.77,29.53 334.77,29.65 v2(334.57,29.85)
  BOTTOM w0.089: UH2.B19 90.7,25.48 90.53,25.65 90.53,25.82 v2(89.98,26.36)
  BOTTOM w0.152: v2(334.57,29.85) 334.72,30.01 334.72,30.03 334.75,30.06 334.75,30.41 CR9.1
PCIE_PTX_CARDRX_N2_C: length 2.8
  BOTTOM w0.152: UR1.4 334.08,33.59 334.15,33.52 334.15,33 334.77,32.38 334.77,31.94 CR9.2
PCIE_PTX_CARDRX_P2: length 275
  IN2 w0.107: v2(90.02,25.8) 90.53,25.8 90.63,25.71 90.63,24.18 91.3,23.5 91.3,21.2 92.58,19.91 92.58,18.19 93.77,17 101.7,17 102.08,16.62 102.08,16.14 102.63,15.59 151.27,15.59 151.74,15.13 154.04,15.13 156.6,12.57 174.9,12.57 175.62,11.85 211.62,11.85 213.91,9.56 225.58,9.56 226.61,8.53 234.56,8.53 235.18,9.15 235.18,9.35 236.01,10.18 249.75,10.18 249.94,9.99 260.3,9.99 260.49,10.18 272.68,10.18 275.9,6.96 279.84,6.96 280.91,8.03 287.62,8.03 288.1,7.55 292.48,7.55 293.02,7.01 296.19,7.01 296.61,7.43 307.22,7.43 308.26,8.47 310.3,8.47 314.47,12.64 318.26,12.64 321.13,15.5 321.13,22.4 326.7,27.97 329.08,27.97 330.33,29.22 334.75,29.22 334.98,29.45 334.98,29.68 v2(335.15,29.85)
  BOTTOM w0.089: v2(90.02,25.8) 90.08,25.8 90.43,25.45 90.43,25.06 90.7,24.79 UH2.C19
  BOTTOM w0.152: v2(335.15,29.85) 335.13,29.88 335.13,30.49 CR7.1
PCIE_PTX_CARDRX_P2_C: length 2.8
  BOTTOM w0.152: UR1.3 334.48,33.14 v4(334.82,32.81) 335.1,32.52 335.1,31.86 CR7.2
PCIE_PTX_SSDRX_N10: length 188.6
  IN1 w0.119: v2(83.78,27.28) 83.89,27.17 84.68,27.17 84.76,27.1 87.35,27.1 89.79,29.54 102,29.54 102.61,30.15 113.03,30.15 114.24,28.94 114.24,26.83 115.29,25.78 153.22,25.78 154.59,24.42 154.59,20.7 157.64,17.64 251.31,17.64 253.09,15.86 255.11,15.86 v2(255.31,16.06)
  BOTTOM w0.089: v2(83.78,27.28) 83.38,26.87 83.38,26.55 83.4,26.53 83.4,25.66 83.61,25.46 83.61,24.93 UH2.C32
  BOTTOM w0.17: CD45.1 256.87,14 256.59,14 256.22,14.37 256.22,15.45 255.69,15.99 255.38,15.99 v2(255.31,16.06)
PCIE_PTX_SSDRX_N10_C: length 2.7
  BOTTOM w0.17: JNGFF2.35 258.91,14.04 258.79,13.92 258.33,13.92 CD45.2
PCIE_PTX_SSDRX_N11: length 190.5
  IN1 w0.119: v2(256.47,18.1) 256.46,18.09 256.46,17.48 256.19,17.2 254.92,17.2 254.06,18.07 157.87,18.07 155.72,20.21 155.72,24.36 153.85,26.23 116.87,26.23 115.63,27.47 115.63,29.01 113.98,30.66 102.35,30.66 101.72,30.04 89.57,30.04 87.63,28.1 83.9,28.1 83.41,27.61 83.41,27.29 83.08,26.97 83.03,26.97 82.8,26.73 v2(82.8,26.73)
  BOTTOM w0.089: v2(82.8,26.73) 82.79,26.73 82.65,26.59 82.65,26.41 82.74,26.32 82.89,26.32 83,26.22 83,25.35 83.16,25.18 83.16,24.91 83.25,24.82 83.36,24.82 UH2.C33
  BOTTOM w0.17: v2(256.47,18.1) 256.28,18.1 256.15,17.97 256.15,16.94 256.25,16.84 256.53,16.84 256.62,16.93 256.62,17.31 256.71,17.4 256.86,17.4 CD43.1
PCIE_PTX_SSDRX_N11_C: length 2.6
  BOTTOM w0.17: CD43.2 258.27,16.9 259.15,16.9 259.3,17.04 JNGFF2.23
PCIE_PTX_SSDRX_N12: length 189.5
  IN1 w0.119: v2(255.9,20.09) 255.98,20.01 256.46,20.01 256.7,19.78 256.7,19.14 256.32,18.76 159.5,18.76 158.17,20.08 158.17,23.31 154.56,26.92 118.91,26.92 114.41,31.42 102.09,31.42 101.44,30.78 89.2,30.78 87.19,28.76 83.34,28.76 82.25,27.67 82.25,27.33 82.34,27.24 82.34,26.59 81.95,26.2 v2(81.95,26.14)
  BOTTOM w0.089: UH2.B35 82.75,25.19 82.62,25.07 82.49,25.07 82.36,25.19 82.36,25.8 82.02,26.14 v2(81.95,26.14)
  BOTTOM w0.17: CD37.1 256.15,20.2 256.03,20.09 v2(255.9,20.09)
PCIE_PTX_SSDRX_N12_C: length 2.8
  BOTTOM w0.17: JNGFF2.11 259.4,20.04 259.1,19.74 258.47,19.74 CD37.2
PCIE_PTX_SSDRX_P10: length 188.7
  IN1 w0.119: v2(83.74,26.69) 83.97,26.91 84.58,26.91 84.65,26.84 87.46,26.84 89.9,29.28 102.1,29.28 102.71,29.89 112.92,29.89 113.98,28.83 113.98,26.72 115.18,25.52 153.11,25.52 154.33,24.31 154.33,20.59 157.53,17.39 251.21,17.39 252.99,15.6 255.18,15.6 v2(255.31,15.48)
  BOTTOM w0.089: v2(83.74,26.69) 83.9,26.69 84.02,26.56 84.02,26.31 83.94,26.22 83.67,26.22 83.62,26.17 83.62,25.74 83.88,25.48 83.98,25.48 84.11,25.35 84.11,24.96 84.05,24.9 83.98,24.9 83.88,25.01 UH2.B32
  BOTTOM w0.17: v2(255.31,15.48) 255.38,15.55 255.51,15.55 255.79,15.27 255.79,14.19 256.49,13.49 256.95,13.49 CD46.1
PCIE_PTX_SSDRX_P10_C: length 2.5
  BOTTOM w0.17: JNGFF2.37 v3(259.03,13.54) 258.96,13.48 258.15,13.48 CD46.2
PCIE_PTX_SSDRX_P11: length 190.5
  IN1 w0.119: v2(255.72,18.11) 255.86,18.11 256.21,17.76 256.21,17.59 256.08,17.46 255.03,17.46 254.17,18.33 157.98,18.33 155.98,20.32 155.98,24.47 153.96,26.49 116.98,26.49 115.89,27.58 115.89,29.12 114.09,30.92 102.24,30.92 101.62,30.3 89.46,30.3 87.52,28.36 83.79,28.36 83.15,27.72 83.15,27.4 82.97,27.22 82.82,27.22 82.72,27.33 v2(82.72,27.48)
  BOTTOM w0.089: UH2.B33 83.36,25.42 83.2,25.59 83.2,26.45 83.16,26.49 83.16,27.03 82.88,27.31
  BOTTOM w0.17: 82.88,27.31 v2(82.72,27.48) ; CD44.1 256.96,16.4 256.07,16.4 255.72,16.76 v2(255.72,18.11)
PCIE_PTX_SSDRX_P11_C: length 2.6
  BOTTOM w0.17: CD44.2 258.22,16.47 v3(259.02,16.47) 259.33,16.47 259.41,16.54 JNGFF2.25
PCIE_PTX_SSDRX_P12: length 189.7
  IN1 w0.119: v2(255.9,19.5) 256.15,19.75 256.36,19.75 256.44,19.67 256.44,19.25 256.21,19.02 159.6,19.02 158.43,20.19 158.43,23.42 154.67,27.18 119.02,27.18 114.52,31.68 101.98,31.68 101.33,31.03 89.09,31.03 87.08,29.02 83.23,29.02 83.1,28.89 81.99,27.78 81.99,27.22 82.08,27.13 82.08,26.7 81.94,26.56 81.64,26.56 81.52,26.68 81.52,26.84 81.64,26.96 v2(81.69,26.96)
  BOTTOM w0.089: UH2.A35 82.32,26.17 82.32,26.31 81.68,26.96 v2(81.69,26.96)
  BOTTOM w0.17: v2(255.9,19.5) 256.07,19.5 256.34,19.77 256.64,19.77 CD42.1
PCIE_PTX_SSDRX_P12_C: length 2.6
  BOTTOM w0.17: CD42.2 v3(258.99,19.31) 259.28,19.31 259.51,19.54 JNGFF2.13
PCIE_PTX_TBRX_N15: length 58.4
  IN6 w0.107: v2(32.48,32.62) 32.27,32.83 32.27,33.43 32.81,33.98 34.27,33.98 35.26,34.97 42.78,34.97 46.98,30.76 49.67,30.76 50.74,31.83 51.95,31.83 53.44,30.34 59.99,30.34 60.94,29.4 65.22,29.4 68.29,26.32 74.52,26.32 75.52,25.33 80.21,25.33 80.66,25.78 80.97,25.78 81.15,25.97 81.15,26.12 81.04,26.23 v2(80.77,26.23)
  BOTTOM w0.089: v2(80.77,26.23) 80.67,26.34 80.51,26.34 80.36,26.19 80.36,25.61 80.52,25.46 80.52,25.46 80.58,25.4 UH2.B39
  BOTTOM w0.152: CT4.2 32.35,33.09 32.35,32.74 v2(32.48,32.62)
