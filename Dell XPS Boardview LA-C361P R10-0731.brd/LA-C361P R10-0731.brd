# Allegro board LA-C361P R10-0731.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
LDO_EN: length 42.5
  TOP w0.508: PD202.1 v2(30.06,23.34) PR272.2 28.28,23.34 27.71,22.77 27.71,22.11 27.43,21.83 PC219.1 28.2,19.57 28.2,20.2 28.33,20.34 PU203.1 ; v2(19.08,4.07) 19.31,3.84 19.31,2.79 v1(19,2.49) 16.51,2.49 16.29,2.27 PD203.1
  IN3 w0.508: v2(19.08,4.07) 23.38,4.07 24.69,5.38 24.69,6.31 24.13,6.87 24.13,7.92 28.07,11.86 28.07,19.72 29.62,21.27 29.62,22.49 30.06,22.93 v2(30.06,23.34)
LG_3V: length 2.7
  IN1 w1.016: 340.55,21.66 338.2,21.66 337.95,21.41
  vias: v2(337.5,20.71) v2(338.2,20.71) v2(341.69,21.79) v2(342.2,21.47) v3(338.25,20.15)
LG_5V: length 8.8
  TOP w0.14: v2(332.55,17.22) 332.39,17.05 v3(331.99,17.05)
  IN1 w1.016: 332.61,18.11 333.57,19.06 340.38,19.06
  vias: v2(332.55,16.58) v2(341.5,19.22) v2(342.1,19.22)
LID_CL_SIO#: length 5.9
  TOP w0.14: UE3.A21 305.54,13.63 305.86,13.31 305.86,12.37 CE31.1 RE45.2 RE41.2 309.12,11.9 v3(309.13,11.88)
LID_SW_IN#: length 135.4
  TOP w0.14: v2(347.28,117.04) 347.66,117.04 347.97,116.73 CE16.1 348.04,117.6 RE15.2 348.03,118.94 348.46,119.37 348.46,120.37 348.88,120.8 UE2.3 ; v1(310.5,10.69) 310.2,10.99 v2(309.75,10.99) 309.18,10.42 307.77,10.42 RE45.1
  IN6 w0.099: v2(309.75,10.99) 311.35,10.99 313.76,13.41 313.76,16.58 317.71,20.53 317.71,24.87 318.2,25.36 318.2,26.66 321.64,30.09 321.64,32.24 323.25,33.85 323.25,35.28 323.8,35.83 323.8,37.96 325.34,39.5 325.34,43.79 327.16,45.61 327.16,51.51 327.63,51.98 327.63,53.37 329.25,54.98 329.25,57.67 333.21,61.63 333.21,83.14 338.33,88.26 342.65,88.26 343.9,89.51 343.9,114.47 346.46,117.03 347.28,117.03 v2(347.28,117.04)
LPC_AD0: length 271.5
  TOP w0.14: v2(305.28,18.54) 304.87,18.13 UE3.A30 ; v2(312.36,4.46) v1(312.36,5.08)
  IN1 w0.076: 101.98,9.21 101.93,9.16 100.87,9.16 100.23,9.81 96.85,9.81 96.45,10.21 94.85,10.21 93.81,9.17 91.81,9.17 90.99,8.35 89.74,8.35 v2(89.71,8.33)
  IN1 w0.099: 101.98,9.21 102.31,9.54 102.78,9.54 103.03,9.78 105.92,9.78 106.53,10.4 113.21,10.4 113.82,9.8 126.29,9.8 127.17,8.91 133.89,8.91 134.36,9.38 145.07,9.38 147.71,6.74 156.74,6.74 157.12,6.36 163.07,6.36 163.78,5.64 172.07,5.64 172.34,5.91 181.97,5.91 184.23,8.17 205.2,8.17 205.46,7.92 209.77,7.92 212.19,5.5 212.25,5.5 213.23,4.52 225.72,4.52 225.96,4.28 225.96,4.28 225.98,4.26 233.65,4.26 233.74,4.18 238.38,4.18 239.6,5.4 246.02,5.4 246.28,5.66 250.17,5.66 250.95,4.88 257.98,4.88 258.7,5.6 263.31,5.6 263.55,5.84 266.81,5.84 267.28,5.37 272.49,5.37 273.05,4.81 300.82,4.81 301.1,5.08 303.01,5.08 303.54,4.54 306.98,4.54 307.44,4.08 310.8,4.08 311.18,4.45 312.35,4.45 v2(312.36,4.46)
  IN3 w0.091: v2(305.28,18.54) 305.62,18.88 306.06,18.88 306.51,19.33 307.67,19.33 309.49,17.51 310.57,17.51 310.96,17.12 310.96,15.09 311.52,14.53 311.52,11.86 311.6,11.79 311.6,7.49 311.97,7.11 311.97,4.84 v2(312.36,4.46)
  BOTTOM w0.089: UH2.AT22 89.24,8.33 v2(89.71,8.33)
  BOTTOM w0.14: v2(305.28,18.54) 305.52,18.54 306.39,19.4 306.39,24.93 305.63,25.69 303.81,25.69 302.82,26.68 302.54,26.68 302.11,27.11 302.11,27.34 301.48,27.97 301.48,28.24 301,28.71 301,29.45 299.7,30.76 JLPDE1.3
LPC_AD1: length 275.7
  TOP w0.14: UE3.B32 302.96,18.38 302.58,17.99 302.44,17.99 v2(302.08,17.64) ; v2(311.07,3.58) 310.55,4.1 v1(310.55,4.44)
  IN1 w0.076: 101.07,8.67 100.1,9.64 96.78,9.64 96.38,10.04 94.92,10.04 93.88,9 92.74,9 92.11,8.38 91.65,8.38 90.89,7.62 89.86,7.62 v2(89.72,7.76)
  IN1 w0.099: v2(311.07,3.58) 307.26,3.58 306.78,4.06 300.95,4.06 300.68,4.33 286.08,4.33 285.33,3.58 268.39,3.58 266.61,5.36 263.75,5.36 263.43,5.04 258.85,5.04 258.21,4.4 250.75,4.4 250.06,5.1 246.52,5.1 246.34,4.92 239.8,4.92 238.48,3.6 225.96,3.6 225.76,3.8 225.76,3.8 225.62,3.95 212.92,3.95 209.42,7.44 205.26,7.44 205,7.69 184.43,7.69 181.67,4.93 179.51,4.93 179.22,4.64 177.61,4.64 177.36,4.9 176.4,4.9 176.28,4.77 170.92,4.77 170.53,5.16 163.59,5.16 162.87,5.88 156.92,5.88 156.86,5.94 156.17,5.94 155.86,6.26 147.16,6.26 144.52,8.9 134.56,8.9 133.95,8.29 127.12,8.29 126.09,9.32 113.62,9.32 113.01,9.92 107.93,9.92 107.32,9.3 103.22,9.3 102.98,9.06 102.51,9.06 102.12,8.67 101.07,8.67
  IN3 w0.091: v2(302.08,17.64) 302.11,17.64 302.73,17.01 303.09,17.01 304.17,15.93 306.81,15.93 306.99,15.76 308.96,15.76 310.58,14.14 310.58,11.47 310.63,11.42 310.63,7.11 311.03,6.71 311.03,3.63 v2(311.07,3.58)
  BOTTOM w0.089: UH2.AV22 89.43,7.76 v2(89.72,7.76)
  BOTTOM w0.14: JLPDE1.4 299.2,30.52 300.42,29.3 300.42,28.07 302.32,26.16 302.61,26.16 304.19,24.58 304.19,23.07 304.6,22.67 304.6,22.34 305.84,21.09 305.84,19.67 305.54,19.36 305.41,19.36 303.16,17.12 302.6,17.12 v2(302.08,17.64)
LPC_AD2: length 272
  TOP w0.089: v2(90.75,8.71) 91.02,8.98 v1(91.02,9.44)
  TOP w0.14: UE3.A31 304.74,18.63 305.31,19.2 v2(305.31,19.88)
  IN1 w0.076: v2(90.75,8.71) 91.12,8.71 92.29,9.89 94.16,9.89 94.73,10.45 94.97,10.45 95.09,10.56 97.15,10.56 97.71,10.01 101.72,10.01 101.98,10.26
  IN1 w0.099: v2(313.32,4.85) 312.23,5.94 307.95,5.94 307.04,5.02 303.74,5.02 303.2,5.56 300.9,5.56 300.62,5.29 285.75,5.29 284.81,6.23 277.26,6.23 276.87,5.85 267.48,5.85 267.01,6.32 263.35,6.32 263.11,6.08 258.5,6.08 257.83,5.41 251.1,5.41 250.27,6.24 246.03,6.24 245.68,5.88 239.17,5.88 238.7,5.41 227.27,5.41 226.7,5.98 212.39,5.98 209.97,8.4 205.69,8.4 205.43,8.66 189.56,8.66 189.56,8.66 184.03,8.66 182.39,7.02 173.4,7.02 172.78,7.63 157.42,7.63 157,7.22 154.94,7.22 154.53,7.63 151.8,7.63 151.6,7.42 148.48,7.42 145.87,10.03 134.33,10.03 133.7,9.39 127.37,9.39 125.88,10.88 105.79,10.88 105.18,10.26 101.98,10.26
  IN3 w0.091: v2(313.32,4.85) 312.93,5.24 312.93,18.27 312.07,19.14 309.75,19.14 308.61,20.27 305.7,20.27 v2(305.31,19.88)
  BOTTOM w0.089: UH2.AT19 90.29,8.29 90.71,8.71 v2(90.75,8.71)
  BOTTOM w0.14: v2(305.31,19.88) 305.31,20.87 304.06,22.11 304.06,22.46 303.09,23.44 303.09,24.94 302.39,25.64 301.6,25.64 300.34,26.89 299.68,26.89 299.47,27.11 299.47,29.01 299.38,29.09 299.38,29.6 298.96,30.02 298.96,30.18 298.7,30.44 JLPDE1.5
LPC_AD3: length 286.5
  TOP w0.14: v2(302.97,19.29) 302.97,19.15 303.24,18.88 UE3.B33 ; v2(313.06,3.65) v1(314.45,3.65)
  IN1 w0.076: v2(91.26,1.93) 91.83,2.5 91.83,2.76 91.85,2.78 93.14,4.07 95.04,4.07 95.04,4.07 97.01,4.07 97.41,3.68 97.41,3.24 97.74,2.9 99.34,2.9 100.59,4.15 101.07,4.15 101.14,4.22 101.14,4.86 100.94,5.06 100.94,6.73 101.98,7.77
  IN1 w0.099: 101.98,7.77 102.79,8.58 103.9,8.58 104.14,8.82 107.57,8.82 108.19,9.44 112.56,9.44 113.16,8.84 125.89,8.84 127.43,7.3 133.64,7.3 134.75,8.42 144.32,8.42 147.45,5.29 149.77,5.29 150,5.06 151.5,5.06 151.84,5.41 156.03,5.41 156.08,5.36 162.71,5.36 163.39,4.68 170.34,4.68 171.29,3.73 178.98,3.73 179.71,4.45 181.87,4.45 184.63,7.21 204.8,7.21 205.55,6.47 205.55,2.72 206.47,1.8 223.06,1.8 224.16,2.9 238.66,2.9 239.71,3.95 246.04,3.95 246.61,4.52 246.72,4.62 249.69,4.62 250.39,3.92 258.91,3.92 259.08,3.75 262.82,3.75 263.95,4.88 266.41,4.88 268.19,3.1 285.9,3.1 286.65,3.85 300.48,3.85 300.75,3.58 306.58,3.58 307.06,3.1 311.7,3.1 311.76,3.16 311.77,3.16 312.06,3.46 312.06,3.46 312.26,3.65 v2(313.06,3.65)
  IN3 w0.091: v2(302.97,19.29) 305.38,19.29 305.58,19.49 306,19.49 306.31,19.8 308.41,19.8 309.55,18.66 311.87,18.66 312.45,18.08 312.45,12.48 312.08,12.1 312.08,7.71 312.45,7.33 312.45,5.05 313.06,4.45 v2(313.06,3.65)
  BOTTOM w0.089: UH2.BD16 92.02,4.54 91.7,4.22 91.7,2.91 91.64,2.86 91.64,2.28 91.29,1.93 v2(91.26,1.93)
  BOTTOM w0.14: v2(302.97,19.29) 302.97,20.38 303.45,20.86 303.45,22.34 301.44,24.35 301.44,25.04 300.12,26.36 299.48,26.36 298.93,26.91 298.93,28.6 298.43,29.1 298.43,30.18 298.2,30.41 JLPDE1.6
LPC_FRAME#: length 281.1
  TOP w0.14: v1(312.94,2.93) 312.64,2.93 v2(312.42,3.14) ; UE3.B31 303.11,17.88 302.88,17.65 v2(302.88,17.64)
  IN1 w0.076: v2(91.81,1.93) 92,2.12 92,2.7 93.21,3.91 95.11,3.91 95.11,3.91 96.94,3.91 97.24,3.61 97.24,3.15 97.65,2.74 99.41,2.74 100.64,3.97 101.58,3.97 101.98,4.38 101.98,4.78 101.88,4.89 101.88,6.99 101.98,7.1
  IN1 w0.099: 101.98,7.1 102.43,7.55 108.8,7.55 110.21,8.96 112.36,8.96 113.65,7.67 116.03,7.67 116.36,7.99 126.06,7.99 127.35,6.7 133.72,6.7 134.84,7.82 144.24,7.82 147.25,4.81 149.4,4.81 149.66,4.56 151.72,4.56 152.09,4.93 155.83,4.93 155.88,4.88 162.51,4.88 163.19,4.2 170.05,4.2 171.01,3.25 181.61,3.25 184.15,5.79 186.66,5.79 187.61,6.73 204.6,6.73 205.07,6.27 205.07,2.52 206.27,1.32 223.42,1.32 224.52,2.42 239.02,2.42 239.97,3.37 246.15,3.37 246.91,4.14 249.49,4.14 250.19,3.44 258.71,3.44 258.88,3.27 263.02,3.27 264.14,4.4 266.21,4.4 267.99,2.62 311.9,2.62 v2(312.42,3.14)
  IN3 w0.091: v2(302.88,17.64) 302.88,17.54 302.93,17.49 303.28,17.49 303.53,17.24 306.98,17.24 307.94,16.28 309.11,16.28 311.05,14.33 311.05,11.67 311.11,11.61 311.11,7.3 311.5,6.91 311.5,4.62 312.42,3.7 v2(312.42,3.14)
  BOTTOM w0.089: v2(91.81,1.93) 91.82,1.94 91.82,2.78 91.88,2.84 91.88,3.98 UH2.BE16
  BOTTOM w0.14: v2(302.88,17.64) 302.88,18.77 302.38,19.27 302.38,21.03 302.01,21.4 302.01,22.82 300.57,24.26 300.57,25.18 299.9,25.84 299.26,25.84 298.58,26.53 298.22,26.53 297.71,27.03 297.71,27.59 297.89,27.77 297.89,30.23 297.7,30.43 JLPDE1.7
LX_0.95V: length 1
  TOP w0.14: v2(110.62,61.41) v1(110.62,62.42)
  vias: v2(110.62,60.78)
LX_1.05V:
  vias: v1(218.85,55.36) v2(218.06,54.68) v2(218.06,54.05) v2(218.5,49.09) v2(218.69,54.05) v2(219.14,49.09) v2(219.33,54.68) v2(219.33,54.05)
LX_1V: length 1
  TOP w0.14: v3(131.01,7.03) 130.6,6.62 130.6,6.25
  vias: v2(130.56,5.82)
LX_3V: length 3.8
  TOP w0.14: PR413.1 338.23,29.47 339.6,30.84 v1(339.6,31.43)
  TOP w0.203: PU400.8 344.4,22.49
  vias: v2(338.38,28.38) v2(339.01,28.38) v2(344.36,23.53) v2(344.36,22.93)
LX_5V: length 20.7
  TOP w0.14: v1(341.17,9.37) 339.87,10.68 PR414.1
  IN1 w1.016: 338.27,8.52 338.96,7.82 345.76,7.82 349.31,11.38 349.31,15.57 348.43,16.46
  vias: v2(336.61,9.22) v2(337.25,9.22) v2(346.65,17.47) v2(347.03,17.03)
M_CLK_DDR0: length 55.4
  IN6 w0.079: v2(156.29,53.28) 156.29,53.25 156.12,53.09 155.76,53.09 155.61,52.94 155.61,51.89 156.09,51.41 156.09,50.58 155.89,50.38 155.89,49.92 155.82,49.85 155.68,49.85 155.47,49.65 155.47,49.35 155.68,49.15 155.84,49.15 155.95,49.03 155.95,48.87 155.84,48.75 155.68,48.75 155.47,48.55 155.47,48.26 155.68,48.05 155.84,48.05 155.95,47.94 155.95,47.77 155.84,47.66 155.68,47.66 155.47,47.45 155.47,47.16 155.68,46.95 155.72,46.95 155.79,46.89 155.79,46.72 154.66,45.59 154.66,43.55 144.5,33.4 144.5,33.16 144.64,33.03 144.64,32.86 144.52,32.75 144.36,32.75 144.23,32.88 143.99,32.88 143.73,32.62 143.73,32.38 144.12,31.99 144.12,31.83 144,31.71 143.84,31.71 143.45,32.1 143.21,32.1 142.95,31.85 142.95,31.61 143.34,31.21 143.34,31.03 143.22,30.91 143.04,30.91 142.79,31.15 142.5,31.15 142.29,30.95 142.29,30.66 142.54,30.4 142.54,30.3 142.29,30.05 142.29,27.28 141.88,26.87 141.88,24.51 141.69,24.33 141.69,23.28 141.89,23.08 142.13,23.08 142.3,22.91 v2(142.3,22.89)
  BOTTOM w0.076: UH1.AG1 159.03,59.91 159.11,59.98 159.25,59.98 159.33,59.9 159.33,59.56 159.22,59.45 159.22,57.33 158.93,57.05 158.93,54.83 157.22,53.12 156.45,53.12 v2(156.29,53.28)
  BOTTOM w0.102: v2(142.3,22.89) 142.11,23.08 141.88,23.08 141.53,23.43 141.53,25.34 141.39,25.48 JDIMM1.137
M_CLK_DDR1: length 57.9
  IN6 w0.079: v2(142.3,20.35) 142.5,20.15 142.93,20.15 143.06,20.28 143.06,24.63 142.95,24.73 142.75,24.73 142.53,24.95 142.53,25.27 142.75,25.49 143.92,25.49 144.04,25.61 144.04,25.8 143.92,25.93 142.69,25.93 142.52,26.1 142.52,26.46 142.69,26.63 143.92,26.63 144.04,26.76 144.04,27.03 143.92,27.16 143.47,27.16 143.25,27.38 143.25,27.73 143.47,27.95 143.9,27.95 144.03,28.08 144.03,28.28 143.9,28.41 143.49,28.41 143.25,28.64 143.25,30.04 145.28,32.06 145.28,33.27 155.3,43.29 155.3,45.33 156.59,46.62 156.59,50.06 157.03,50.5 157.03,53.43 156.68,53.77 156.68,54.25 156.31,54.62 156.31,55.59 156.8,56.08 156.8,57.41 156.71,57.5 156.33,57.5 v2(156.14,57.31)
  BOTTOM w0.089: UH1.AK2 156.52,60.27 156.11,59.86 156.11,59.55 155.39,58.84 155.39,57.78 155.62,57.55 155.9,57.55 v2(156.14,57.31)
  BOTTOM w0.14: v2(142.3,20.35) 142.13,20.18 141.87,20.18 141.62,19.92 141.62,19.34 141.79,19.17 141.79,19.11 141.63,18.94 JDIMM1.138
M_CLK_DDR2: length 98.2
  IN3 w0.081: v2(154.85,64.63) 154.86,64.63 155.23,64.26 155.23,63.33 155.53,63.04 156.27,63.04 156.82,62.5 156.92,62.5 157.26,62.15 157.26,61.85 156.44,61.02 156.44,60.06 156.85,59.66 156.85,53.76 157.65,52.96 157.65,52.7 157.37,52.42 157.37,52.08 157.65,51.8 157.65,48.74 166.29,40.09 207.25,40.09 217.58,29.76 217.58,23.33 217.79,23.11 218.01,23.11 218.15,22.97 v2(218.15,22.89)
  BOTTOM w0.076: UH1.AM9 155.17,64.95 v2(154.85,64.63)
  BOTTOM w0.14: JDIMM2.137 217.69,25.55 217.39,25.26 217.39,23.35 217.71,23.04 218,23.04 v2(218.15,22.89)
M_CLK_DDR3: length 99.2
  IN3 w0.081: v2(155.76,63.97) 155.69,64.05 155.69,64.17 155.78,64.26 156.09,64.26 156.17,64.18 156.17,63.62 156.41,63.38 156.91,63.38 157.66,62.63 157.66,61.26 157.32,60.91 157.32,59.83 157.9,59.25 157.9,53.31 158.09,53.11 158.09,51.1 158.31,50.89 158.31,49 166.56,40.74 207.65,40.74 218.24,30.16 218.24,25.43 218.76,24.91 218.76,20.33 218.5,20.07 218.31,20.07 218.15,20.24 v2(218.15,20.35)
  BOTTOM w0.076: UH1.AM7 v2(155.76,63.97)
  BOTTOM w0.14: v2(218.15,20.35) 217.67,19.87 217.67,19.52 217.93,19.26 JDIMM2.138
M_CLK_DDR#0: length 55.4
  IN6 w0.079: v2(156.29,52.65) 156.29,52.87 156.23,52.93 156.16,52.93 156.16,52.93 155.82,52.93 155.77,52.88 155.77,51.95 156.25,51.47 156.25,50.52 156.05,50.31 156.05,49.86 155.89,49.7 155.74,49.7 155.63,49.58 155.63,49.42 155.74,49.3 155.9,49.3 156.11,49.1 156.11,48.81 155.9,48.6 155.74,48.6 155.63,48.48 155.63,48.32 155.74,48.21 155.9,48.21 156.11,48 156.11,47.71 155.9,47.5 155.74,47.5 155.63,47.39 155.63,47.22 155.74,47.11 155.78,47.11 155.94,46.95 155.94,46.66 154.81,45.53 154.81,43.49 144.66,33.34 144.66,33.22 144.79,33.09 144.79,32.8 144.59,32.59 144.3,32.59 144.16,32.73 144.05,32.73 143.88,32.56 143.88,32.45 144.27,32.06 144.27,31.77 144.06,31.56 143.77,31.56 143.38,31.95 143.27,31.95 143.11,31.78 143.11,31.67 143.5,31.28 143.5,30.97 143.28,30.75 142.97,30.75 142.72,31 142.56,31 142.44,30.88 142.44,30.72 142.7,30.47 142.7,30.23 142.44,29.98 142.44,27.21 142.03,26.8 142.03,24.45 141.85,24.26 141.85,23.34 141.95,23.24 142.02,23.24 v2(142.3,23.52)
  BOTTOM w0.076: UH1.AG2 159.03,60.29 159.12,60.2 159.34,60.2 159.55,59.99 159.55,59.47 159.46,59.39 159.46,57.23 159.17,56.95 159.17,54.73 157.32,52.88 156.52,52.88 v2(156.29,52.65)
  BOTTOM w0.102: JDIMM1.139 141.89,26.35 141.89,25.45 141.76,25.32 141.76,23.53 141.98,23.31 142.09,23.31 v2(142.3,23.52)
M_CLK_DDR#1: length 57.8
  IN6 w0.079: v2(156.14,57.95) 156.14,57.75 156.23,57.66 156.77,57.66 156.96,57.47 156.96,56.02 156.47,55.53 156.47,54.69 156.84,54.31 156.84,53.84 157.19,53.49 157.19,50.44 156.75,50 156.75,46.56 155.45,45.26 155.45,43.22 145.43,33.2 145.43,32 143.41,29.97 143.41,28.7 143.55,28.56 143.97,28.56 144.19,28.34 144.19,28.01 143.97,27.8 143.54,27.8 143.41,27.67 143.41,27.44 143.54,27.31 143.98,27.31 144.2,27.1 144.2,26.7 143.98,26.48 142.75,26.48 142.68,26.4 142.68,26.16 142.75,26.08 143.98,26.08 144.2,25.87 144.2,25.55 143.98,25.33 142.81,25.33 142.69,25.2 142.69,25.02 142.81,24.89 143.02,24.89 143.21,24.69 143.21,20.21 142.99,20 142.5,20 142.49,19.99 142.47,19.99 142.3,19.82 v2(142.3,19.71)
  BOTTOM w0.089: v2(156.14,57.95) 156,57.81 155.72,57.81 155.65,57.88 155.65,58.73 156.26,59.34 156.4,59.34 156.58,59.17 156.73,59.17 156.84,59.28 156.84,59.67 156.78,59.74 UH1.AK1
  BOTTOM w0.14: v2(142.3,19.71) 142.14,19.87 142,19.87 141.87,19.75 141.87,19.45 142.03,19.29 142.03,19.16 142.12,19.07 JDIMM1.140
M_CLK_DDR#2: length 98.2
  IN3 w0.081: v2(154.85,65.26) 155.4,64.71 155.4,63.4 155.59,63.2 156.34,63.2 156.89,62.66 156.99,62.66 157.43,62.22 157.43,61.78 156.6,60.96 156.6,60.13 157.01,59.72 157.01,53.83 157.81,53.03 157.81,52.63 157.53,52.35 157.53,52.15 157.81,51.87 157.81,48.8 166.36,40.26 207.32,40.26 217.74,29.83 217.74,23.39 217.86,23.28 217.98,23.28 218.15,23.44 v2(218.15,23.52)
  BOTTOM w0.076: UH1.AN9 154.53,64.95 v2(154.85,65.26)
  BOTTOM w0.14: v2(218.15,23.52) 217.96,23.34 217.84,23.34 217.7,23.48 217.7,25.13 217.91,25.34 218.13,25.56 218.19,25.56 JDIMM2.139
M_CLK_DDR#3: length 99.1
  IN3 w0.081: v2(218.15,19.71) 218.34,19.91 218.57,19.91 218.92,20.27 218.92,24.98 218.4,25.5 218.4,30.22 207.72,40.91 166.63,40.91 158.47,49.07 158.47,50.95 158.26,51.17 158.26,53.18 158.06,53.38 158.06,59.32 157.49,59.9 157.49,60.85 157.83,61.19 157.83,62.7 156.98,63.55 156.47,63.55 156.33,63.69 156.33,64.25 156.16,64.43 155.96,64.43 v2(155.76,64.62)
  BOTTOM w0.076: UH1.AM8 v2(155.76,64.62)
  BOTTOM w0.14: JDIMM2.140 218.43,18.99 218.32,19.1 218.32,19.23 218.62,19.53 218.62,19.69 218.48,19.83 218.27,19.83 v2(218.15,19.71)
M_ODT0: length 57.4
  IN6 w0.089: v2(159.92,54.74) 159.52,54.74 159.36,54.58 159.36,52.48 161.84,50
  IN6 w0.117: v2(149.18,23.25) 149.48,23.25 149.69,23.04 149.69,21.49 149.82,21.37 150.1,21.37 150.23,21.49 150.23,23.32 150.1,23.44 149.83,23.44 149.71,23.57 149.71,23.77 149.83,23.9 149.97,23.9 150.08,24.01 150.08,25.6 150.21,25.73 150.79,25.73 150.92,25.85 150.92,26.07 150.79,26.2 150.21,26.2 150.08,26.32 150.08,26.56 150.21,26.69 150.76,26.69 150.92,26.84 150.92,27.07 150.76,27.22 150.21,27.22 150.08,27.35 150.08,28.73 152.05,30.7 152.05,32.61 160.59,41.15 160.59,43.19 161.84,44.45 161.84,50
  BOTTOM w0.076: UH1.AD3 161.32,61.04 161.27,60.98 161.27,59.41 161.53,59.14 161.53,55.42 160.86,54.74 v2(159.92,54.74)
  BOTTOM w0.221: v2(149.18,23.25) 148.81,23.25 148.15,23.91 148.15,24.46 148,24.6 148,24.81 147.87,24.94 JDIMM1.155
M_ODT1: length 56.4
  IN6 w0.117: v2(160.13,52.58) 160.53,52.58 162.27,50.84 162.27,49.62 162.38,49.5 162.52,49.5 162.64,49.39 162.64,49.15 162.52,49.04 162.38,49.04 162.27,48.92 162.27,48.68 162.38,48.57 162.52,48.57 162.64,48.45 162.64,48.22 162.52,48.1 162.38,48.1 162.27,47.98 162.27,47.75 162.38,47.63 162.52,47.63 162.64,47.52 162.64,47.28 162.52,47.17 162.38,47.17 162.27,47.05 162.27,46.82 162.38,46.7 162.52,46.7 162.64,46.58 162.64,46.35 162.52,46.23 162.38,46.23 162.27,46.11 162.27,45.88 162.38,45.76 162.52,45.76 162.64,45.65 162.64,45.41 162.52,45.3 162.38,45.3 162.27,45.18 162.27,44.27 161.01,43.02 161.01,40.98 153.96,33.92 153.96,33.18 153.83,33.05 153.22,33.05 153.09,32.93 153.09,32.75 153.22,32.62 153.83,32.62 153.96,32.5 153.96,32.28 153.83,32.15 152.6,32.15 152.47,32.03 152.47,31.81 152.6,31.68 153.43,31.68 153.55,31.56 153.55,31.32 153.43,31.2 152.57,31.2 152.47,31.09 152.47,30.31 151.34,29.17 151.22,29.06 151.01,29.06 150.88,28.93 150.88,28.72 151.01,28.59 151.21,28.59 151.34,28.46 151.34,28.25 151.21,28.12 151.02,28.12 150.89,27.99 150.89,27.78 151.02,27.65 151.22,27.65 151.34,27.54 151.34,25.44 151.2,25.3 150.59,25.3 150.5,25.22 150.5,24.61 150.63,24.49 v2(150.74,24.49)
  BOTTOM w0.076: v2(160.13,52.58) 160.05,52.5 159.49,52.5 159.34,52.65 159.34,56.8 160.3,57.76 160.3,58.55 160.48,58.74 160.48,59.4 160.37,59.52 160.37,61.44 160.62,61.69 UH1.AE4
  BOTTOM w0.221: v2(150.74,24.49) 150.57,24.49 150.18,24.1 149.99,24.1 149.37,24.72 JDIMM1.161
M_ODT2: length 100.1
  IN3 w0.122: v2(160.33,64) 160.8,63.53 160.8,60.91 161.9,59.81 161.9,56.85 162.25,56.5 163.47,56.5 169.34,50.64 171.01,50.64 174.75,46.9 180.98,46.9 181.1,47.02 181.1,47.37 181.23,47.49 181.47,47.49 181.59,47.37 181.59,47.02 181.71,46.9 181.96,46.9 182.08,47.02 182.08,47.37 182.2,47.49 182.44,47.49 182.57,47.37 182.57,47.02 182.69,46.9 210.2,46.9 225.71,31.4 225.71,27.77 225.39,27.46 225.39,22.66 v2(226.26,21.79)
  BOTTOM w0.076: UH1.AF7 159.98,63.65 v2(160.33,64)
  BOTTOM w0.221: v2(226.26,21.79) 224.18,23.87 JDIMM2.155
M_ODT3: length 99.8
  IN3 w0.122: v2(226.26,24.84) 227.14,25.72 227.14,31.17 210.51,47.8 198.13,47.8 198.01,47.92 198.01,48.31 197.88,48.43 197.64,48.43 197.52,48.31 197.52,47.92 197.4,47.8 197.15,47.8 197.03,47.92 197.03,48.31 196.91,48.43 196.67,48.43 196.54,48.31 196.54,47.92 196.42,47.8 196.18,47.8 196.06,47.92 196.06,48.31 195.93,48.43 195.69,48.43 195.57,48.31 195.57,47.92 195.45,47.8 195.2,47.8 195.08,47.92 195.08,48.31 194.96,48.43 194.71,48.43 194.59,48.31 194.59,47.92 194.47,47.8 194.23,47.8 194.11,47.92 194.11,48.31 193.98,48.43 193.74,48.43 193.62,48.31 193.62,47.92 193.5,47.8 193.25,47.8 193.13,47.92 193.13,48.31 193.01,48.43 192.76,48.43 192.64,48.31 192.64,47.92 192.52,47.8 192.21,47.8 192.09,47.92 192.09,48.29 191.97,48.41 191.73,48.41 191.6,48.29 191.6,47.92 191.48,47.8 191.24,47.8 191.12,47.92 191.12,48.29 190.99,48.41 190.68,48.41 190.56,48.29 190.56,47.9 190.44,47.77 190.2,47.77 190.08,47.9 190.08,48.29 189.95,48.41 189.71,48.41 189.59,48.29 189.59,47.9 189.47,47.77 189.22,47.77 189.1,47.9 189.1,48.29 188.98,48.41 174.45,48.41 171.37,51.49 169.68,51.49 163.32,57.84 163.32,59.89 162.37,60.84 162.37,62.47 161.57,63.27 161.57,63.52 v2(161.22,63.87)
  BOTTOM w0.076: UH1.AE8 v2(161.22,63.87)
  BOTTOM w0.221: v2(226.26,24.84) 225.67,25.42 JDIMM2.161
MCARD_PCIE#_SATA: length 195.4
  TOP w0.089: 81.91,13.18 v3(81.92,13.18) ; 81.91,13.18 82.22,12.87 v2(82.22,12.7) ; 81.91,13.18 80.28,13.18 80.13,13.33 78.13,13.33 77.7,13.76 76.32,13.76 RH508.1
  IN2 w0.089: 101.98,11.97 98.29,11.97 97.87,11.55 92.92,11.55 92.7,11.34 92.7,10.83 91.54,9.67 90.38,9.67 90.13,9.42 89.03,9.42 88.76,9.15 87.71,9.15 87.21,9.65 86.07,9.65 83.46,12.25 82.67,12.25 v2(82.22,12.7)
  IN2 w0.099: v2(253.58,8.2) 253.07,8.71 245.53,8.71 245.2,8.38 240.07,8.38 238.87,7.18 235.91,7.18 235.26,6.54 227.82,6.54 226.42,7.93 213.88,7.93 210.85,10.97 175.32,10.97 174.73,11.56 163.96,11.56 163.15,10.75 160.14,10.75 159.43,11.46 155.27,11.46 152.65,14.08 149.88,14.08 149.69,14.27 122.07,14.27 121.56,14.78 115.33,14.78 112.66,12.12 102.62,12.12 102.47,11.97 101.98,11.97
  BOTTOM w0.089: v2(82.22,12.7) 81.87,13.06 UH2.AG36
  BOTTOM w0.127: RD58.1 255.62,4.95 UD2.4
  BOTTOM w0.14: v2(253.58,8.2) 253.39,8.01 253.39,4.62 254.19,3.82 RD58.1
MCARD_PCIE_SATA#: length 9.9
  BOTTOM w0.127: JNGFF2.61 259.2,5.54 259.14,5.6 257.46,5.6 257.19,5.33 257.19,4.82 257.49,4.52 257.49,4.12 RD10.2
  BOTTOM w0.14: v3(253.44,3.77) 253.44,3.54 253.65,3.34 254.93,3.34 RD58.2 255.98,4.39 256.62,4.39 RD10.2
ME_EN: length 3.6
  TOP w0.127: RH487.1 RH454.1 115.7,5.44 SW4.2
  TOP w0.14: RH487.1 116.7,5.88 v3(115.99,6.59)
ME_FWP_EC: length 190.6
  TOP w0.127: RH487.2 117.4,5.3 SW4.3
  TOP w0.14: v2(294.06,10.41) 294.86,10.41 295.02,10.58 UE3.B1 ; RH487.2 116.99,6.14 v2(116.99,6.46) 116.99,6.47 v3(117.43,6.9)
  IN5 w0.099: v2(294.06,10.41) 290.64,6.99 276.74,6.99 275.15,8.58 265.9,8.58 264.78,9.7 252.55,9.7 251.79,8.94 234.47,8.94 233.39,10.01 214.15,10.01 213.03,8.89 186.07,8.89 180.45,3.27 171.85,3.27 170.21,4.9 166.22,4.9 165.56,5.57 159.88,5.57 158.89,6.55 147.16,6.55 145.19,8.52 119.59,8.52 117.53,6.46 v2(116.99,6.46)
ME_SUS_PWR_ACK: length 244.1
  TOP w0.127: RH506.1 74.56,4.45 74.81,4.45 75.61,3.65 76.14,3.65 76.66,3.14 76.66,3.02 v2(76.84,2.85)
  TOP w0.14: UE3.A8 298.77,9.46 298.67,9.36 298.67,8.94 v2(298.2,8.47)
  IN2 w0.089: v2(90.58,3.22) 90.62,3.26 91.9,3.26 92.83,4.19 96.98,4.19 97.16,4.01 98.38,4.01 99.39,5.02 99.39,5.47 100.1,6.18 101.98,6.18
  IN2 w0.099: v2(183.94,4.76) 177.66,4.76 177.46,4.96 176.69,4.96 175.2,3.46 171.07,3.46 169.75,4.79 163.55,4.79 163.15,5.19 159.57,5.19 159.32,5.44 156.49,5.44 155.99,4.94 150.65,4.94 149.13,6.46 147.49,6.46 145.16,8.78 136.28,8.78 134.89,7.4 129.67,7.4 129.13,7.94 125.6,7.94 125.07,7.4 118.51,7.4 117.03,5.93 106.69,5.93 106.43,6.18 101.98,6.18
  IN3 w0.089: v2(76.84,2.85) 76.89,2.85 77.64,2.09 80.98,2.09 82.77,3.89 85.67,3.89 85.98,4.2 86.58,4.2 86.89,3.89 88.4,3.89 88.58,4.07 89.73,4.07 v2(90.58,3.22)
  IN3 w0.091: v2(296.04,3.43) 296.04,3.41 296.51,3.89 296.51,6.54 297.94,7.96 297.94,8.21 v2(298.2,8.47)
  IN5 w0.099: v2(296.04,3.43) 295.62,3.01 283.42,3.01 281.58,4.85 273.69,4.85 272.84,5.7 227.62,5.7 226.28,7.05 218.15,7.05 217.95,6.84 211.18,6.84 210.74,7.27 190.08,7.27 186.74,3.93 184.76,3.93 v2(183.94,4.76)
  BOTTOM w0.089: v2(90.58,3.22) 90.53,3.27 90.53,4.38 UH2.BD19
MEC_XTAL1: length 6.6
  TOP w0.14: YE1.1 288.38,12.82 288.48,12.91 CE42.1 289.62,12.91 289.99,13.28 292.27,13.28 v3(292.42,13.13) UE3.A61
MEC_XTAL2: length 5.4
  TOP w0.14: v1(285.23,10.91) 285.82,10.32 YE1.2 287.37,10.22 CE43.1 289.26,10.55 RE51.2
MEC_XTAL2_R: length 3.5
  TOP w0.14: RE51.1 291.42,10.55 v3(292.28,11.41) 292.28,11.57 293,12.29 293,12.48 293.15,12.63 UE3.A62
MEDIACARD_IRQ#: length 286.9
  TOP w0.089: RH546.1 82.92,10.56 82.68,10.8 81.09,10.8 v2(80.71,10.42)
  TOP w0.14: v2(322.71,32.17) v1(322.71,31.54)
  IN3 w0.091: v2(336.6,33.08) 336.42,32.9 336.42,32.2 336.03,31.81 324.72,31.81 324.37,32.17 v2(322.71,32.17)
  IN6 w0.089: v2(80.71,10.42) 80.71,10.69 81.09,11.07 81.09,11.44 81.55,11.9 83.78,11.9 83.92,11.75 84.79,11.75 85.67,12.63 91.45,12.63 91.93,12.15 95.21,12.15 95.57,12.51 98.77,12.51 99.38,11.9 101.54,11.9 101.98,12.34
  IN6 w0.099: 101.98,12.34 102.11,12.46 107.45,12.46 108.13,11.78 112.5,11.78 113.18,12.46 125.61,12.46 126.05,12.9 159.3,12.9 160.15,12.06 169.16,12.06 169.35,12.25 176.71,12.25 176.91,12.45 186.37,12.45 186.96,13.04 200.3,13.04 200.75,12.59 215.36,12.59 215.52,12.43 224.95,12.43 225.11,12.59 228.14,12.59 228.66,12.07 228.66,11.22 228.86,11.03 229.37,10.52 230.6,10.52 234.28,10.52 234.67,10.13 236.33,10.13 236.56,9.9 249.84,9.9 250.34,9.41 262.06,9.41 262.67,10.02 270.29,10.02 270.89,9.43 270.89,9.08 271.27,8.69 274.68,8.69 275.2,8.18 278.21,8.18 279.81,9.77 283.78,9.77 284.86,8.7 287.86,8.7 288.8,9.63 288.8,10.02 289.21,10.43 292.53,10.43 293.33,11.23 294.43,11.23 295.21,10.45 303.6,10.45 303.94,10.1 311.31,10.1 314.37,13.16 314.37,16.33 318.32,20.28 318.32,24.62 318.8,25.11 318.8,26.41 322.53,30.14 322.53,31.99 v2(322.71,32.17)
  BOTTOM w0.089: v2(80.71,10.42) 80.37,10.76 UH2.AL39
  BOTTOM w0.14: RR10.1 v2(336.6,33.08)
MSATA_DEVSLP: length 211.4
  TOP w0.14: RD7.2 v1(267.51,12.14) 267.51,12.07 266.85,11.41 v2(266.85,11.28)
  IN5 w0.089: v2(79.31,12.65) 79.91,13.24 90.46,13.24 92.05,14.83 96.32,14.83 96.72,14.42 101.14,14.42 101.26,14.54 101.98,14.54
  IN5 w0.099: v2(266.85,11.28) 266.72,11.28 265.93,12.07 262.13,12.07 261.62,11.56 252.23,11.56 246.16,17.63 221.34,17.63 219.02,19.96 219.02,24.42 217.92,25.53 186.79,25.53 186.6,25.72 182.73,25.72 179.58,22.57 179.58,19 174.58,14 124.13,14 123.79,13.66 115.69,13.66 114.74,14.61 102.06,14.61 101.98,14.54
  BOTTOM w0.089: UH2.AG42 v2(79.31,12.65)
  BOTTOM w0.14: v2(266.85,11.28) 266.64,11.5 266.64,12.9 267.03,13.29 JNGFF2.38
MSCLK: length 7.5
  TOP w0.14: RE63.2 309.06,29.15 v2(308.15,30.06) 308.04,30.17 v1(306.36,30.17) 305.73,30.17 304.47,28.91 RE103.1
  BOTTOM w0.14: v2(308.15,30.06) 308.61,30.53 JDEG1.6
MSCLK_R: length 18.5
  TOP w0.14: v3(302.57,27.82) 303.35,27.82 303.51,27.97 ; RE103.2 RE119.2 303.51,27.97 ; 303.51,27.97 v2(303.51,26.86) ; v2(298.5,18.39) 299.02,18.91 UE3.B43
  IN4 w0.091: v2(298.5,18.39) 298.97,18.86 298.97,19.92 298.63,20.27 298.63,21.34 298.98,21.7 298.98,23.73 300.03,24.77 300.03,25.95 300.33,26.26 300.33,27.34 300.65,27.66 302.71,27.66 v2(303.51,26.86)
MSDATA: length 17
  TOP w0.14: RE102.1 299.39,27.09 RE27.1 299.9,28.58 300.91,28.58 v2(301.65,29.32) ; v2(308.11,29.41) 308.17,29.36 RE65.2 307.66,28.15 307.66,26.95 v1(308.06,26.54)
  IN4 w0.091: v2(301.65,29.32) 301.91,29.32 302.49,28.74 307.44,28.74 v2(308.11,29.41)
  BOTTOM w0.14: JDEG1.7 308.11,30.72 307.72,30.32 307.72,29.8 v2(308.11,29.41)
MSDATA_R: length 5.5
  TOP w0.14: UE3.A40 299.27,21.73 v3(299.42,21.88) 299.52,21.98 299.59,21.98 299.98,22.36 RE118.2 300.51,23.83 300.51,24.72 299.98,25.26 RE102.2
MULTI_STRAP_REF0_GND: length 5.7
  TOP w0.127: v3(219.86,60.13) 219.86,60.56 220.04,60.74 v2(220.63,60.74)
  TOP w0.14: v3(219.86,60.13) 220.36,59.64 RV318.1
  BOTTOM w0.089: 220.2,62.97 UV1.J1
  BOTTOM w0.127: v2(220.63,60.74) 220.2,61.17 220.2,62.97
NB_MUTE#: length 304.3
  TOP w0.14: UE4.20 276.58,17.56 276.11,18.03 276.11,18.5 275.67,18.94 274.08,18.94 270.9,15.76 v1(270.9,12.61) 270.9,9.67 v2(271.3,9.27) ; JAUDIO.10 7.2,16.01 7.51,16.32 9.45,16.32 v2(9.93,15.83)
  IN6 w0.099: v2(9.93,15.83) 10.44,16.34 16.99,16.34 18.9,18.24 18.9,20.84 20.18,22.12 21.02,22.12 22.66,23.76 24.69,23.76 25,24.06 30.2,24.06 30.48,24.35 36.42,24.35 36.42,24.34 37.53,24.34 38.49,24.34 40.35,22.49 48.3,22.49 48.51,22.28 50.17,22.28 50.26,22.18 54.26,22.18 55.08,21.36 55.08,20.11 56.92,18.27 56.92,15.86 56.82,15.76 56.82,13.8 56.85,13.78 56.85,13.47 57.23,13.09 61.34,13.09 63.25,14.99 65.43,14.99 65.46,14.97 70.02,14.97 72.54,12.45 72.54,10.42 73.15,9.81 75.04,9.81 75.26,10.02 77.77,10.02 79.82,12.08 83.85,12.08 84,11.94 84.71,11.94 85.64,12.86 91.7,12.86 91.85,13.01 94.99,13.01 95.26,12.73 98.87,12.73 99.53,12.08 101.41,12.08 102,12.67 107.53,12.67 108.21,11.98 112.42,11.98 113.1,12.67 125.53,12.67 125.97,13.1 159.39,13.1 160.23,12.26 169.08,12.26 169.32,12.51 176.59,12.51 176.74,12.65 186.29,12.65 186.88,13.25 200.38,13.25 200.83,12.8 215.44,12.8 215.6,12.63 224.87,12.63 225.03,12.8 228.61,12.8 230.69,10.72 231.02,10.72 234.42,10.72 234.81,10.33 236.42,10.33 236.64,10.11 249.92,10.11 250.42,9.61 261.97,9.61 262.59,10.22 270.41,10.22 271.3,9.33 v2(271.3,9.27)
NC_B4: length 2.5
  BOTTOM w0.089: UT1.B4 22.36,44.35 22.14,44.57 21.36,44.57 21.08,44.85 v1(20.96,44.85) 20.84,44.97 20.58,44.97
  BOTTOM w0.14: 20.58,44.97 RT207.2
NC_B5: length 2.5
  BOTTOM w0.089: UT1.B5 22.21,43.67 21.74,43.67 21.31,43.24 20.58,43.24
  BOTTOM w0.14: RT208.2 20.28,43.24 20.58,43.24
NC_G2: length 2.6
  BOTTOM w0.089: UT1.G2 24.97,45.51 24.97,45.91 25.21,46.15 25.25,46.15 25.63,46.53 25.63,46.81 25.39,47.04 25.39,47.13
  BOTTOM w0.14: RT209.2 25.39,47.13
NGFF_ON: length 4.5
  TOP w0.14: UN3.3 339.01,101.54 339.35,101.88 v3(339.35,102.52) RN33.2 339.08,103.96 DN3.1
NGFF_PWREN: length 391.8
  TOP w0.089: v2(86.91,1.52) 86.51,1.93 86.2,1.93 84.73,3.39 83.17,3.39 82.87,3.69 82.87,4.67 83.21,5.01 83.21,6.12 83.35,6.25 83.35,8.61 83.11,8.85 81.46,8.85 81.13,9.18 81.13,9.56 80.9,9.79 79.89,9.79 79.86,9.76 78.23,9.76 77.24,8.77 76.28,8.77 RH520.2
  TOP w0.14: v2(344.74,106.24) 344.3,106.24 343.79,105.74 v3(339.15,105.74) 337.43,105.74 DN3.2
  IN6 w0.089: 98.11,1.41 98.21,1.51 98.21,1.52 100.33,3.63 101.98,3.63 ; 87.03,1.41 86.92,1.53 86.92,1.52 v2(86.91,1.52)
  IN6 w0.099: v2(344.74,106.24) 344.74,105.16 345.33,104.58 345.33,89.8 342.19,86.66 342.19,85.51 341.22,84.54 337.11,84.54 334.27,81.71 334.27,61.28 330.25,57.26 330.25,53.6 329.27,52.62 329.27,47.28 328.61,46.62 328.61,40.79 325.6,37.78 325.6,31.23 324.96,30.58 324.96,26.84 320.28,22.17 320.28,10.06 316.31,6.08 307.98,6.08 306.01,4.11 295.07,4.11 294.9,4.28 291.15,4.28 290.32,3.45 268.69,3.45 266.94,5.2 263.45,5.2 262.33,4.07 254.35,4.07 252.96,5.46 246.61,5.46 245.54,4.4 243.63,4.4 242.75,3.52 238.2,3.52 237.47,2.78 215.86,2.78 210.51,8.13 179.1,8.13 177.68,6.71 176.17,6.71 174.26,4.8 169.84,4.8 167.9,2.87 151.2,2.87 149.52,4.54 147.85,4.54 144.81,7.58 142.3,7.58 141.16,6.43 139.95,6.43 139.58,6.8 135.25,6.8 135.06,6.61 134.06,6.61 133.59,6.61 132.37,5.38 130.38,5.38 129.37,6.39 118.98,6.39 115.89,3.31 109.58,3.31 108.68,2.4 106.28,2.4 105.05,3.63 101.98,3.63 ; 87.03,1.41 87.11,1.33 98.03,1.33 98.11,1.41
  BOTTOM w0.089: UH2.BC27 86.11,4.97 86.11,4.35 85.97,4.21 85.97,3.77 85.88,3.68 85.88,2.97 85.88,2.26 86.23,1.9 86.56,1.9 86.91,1.55 v2(86.91,1.52)
NRB_BIT: length 8.2
  TOP w0.089: RH524.2 82.58,2.38 83.24,2.38 83.8,2.94 v3(83.96,2.94) 84.93,2.94 v2(86.36,1.51)
  BOTTOM w0.089: UH2.BD28 85.86,4.39 85.79,4.32 85.79,3.85 85.7,3.76 85.7,3.04 85.7,3.04 85.7,2.62 85.7,2.18 86.36,1.53 v2(86.36,1.51)
P_SYS: length 426.6
  TOP w0.14: v2(104.23,34.66) 104.23,35.48 v1(104.47,35.72) ; UE3.A57 293.12,15.13 292.98,14.98 292.18,14.98 v2(291.91,15.25)
  TOP w0.203: v2(63.43,18.98) 62.89,18.44 62.89,17.25 61.27,15.63 PR324.1 ; PU1100.1 113.81,108.09 113.55,108.34 113.55,109.17 v2(112.71,110) 112.03,110 PC1100.2
  IN2 w0.089: 76.27,26.68 75.85,26.27
  IN2 w0.099: v2(74.49,15.07) 74.49,20.08 75.62,21.21 75.62,26.03 75.85,26.27 ; 76.27,26.68 76.42,26.83 79.44,26.83 81.13,28.52 83.25,28.52 83.5,28.77 86.27,28.77 90.01,32.52 98.16,32.52 100.55,34.91 103.98,34.91 v2(104.23,34.66)
  IN5 w0.089: 101.98,16.67 101.54,17.12 92.17,17.12 90.78,15.73 84.49,15.73 83.83,15.07 77.75,15.07 77.02,14.34 75.22,14.34 75.06,14.5
  IN5 w0.099: v2(291.9,11.76) 291.9,11.36 291.38,10.84 290.16,10.84 289.02,11.98 289.02,12.79 288.32,13.49 284.74,13.49 283.68,12.43 281.56,12.43 281.42,12.58 272.14,12.58 272.11,12.55 266.95,12.55 266.05,13.45 255.24,13.45 254.73,13.96 254.14,13.96 251.89,16.21 251.89,16.91 249.97,18.82 222.67,18.82 221.38,20.11 221.38,24.01 219.04,26.35 187.1,26.35 186.93,26.53 182.38,26.53 178.65,22.79 178.65,19.21 174.95,15.5 105.53,15.5 105.37,15.66 102.85,15.66 102.11,16.41 102.11,16.55 101.98,16.67 ; v2(63.43,18.98) 63.03,19.38 62.69,19.38 62.69,19.38 61.32,19.38 60.54,18.6 60.54,17 62.32,15.22 74.33,15.22 v2(74.49,15.07) 75.06,14.5
  IN6 w0.099: v2(112.71,110) 112.15,110 112.1,109.96 107.58,109.96 107.34,109.71 107.34,108.87 108.76,107.45 108.76,102.96 109.64,102.08 109.64,100.72 111.85,98.51 113.24,98.51 113.4,98.68 115.49,98.68 116.07,98.09 116.4,97.76 119.19,97.76 119.66,97.29 121.23,97.29 122.73,95.8 122.73,87.53 126.81,83.45 128.32,83.45 128.64,83.13 128.64,78.73 126.41,76.49 126.41,71.24 124.51,69.34 124.51,66.4 123.91,65.79 121.6,65.79 120.34,64.53 120.34,63.76 117.54,60.96 117.54,56.58 115.57,54.61 115.57,49.12 114.85,48.4 114.85,45.02 108.07,38.24 105.14,38.24 104.09,37.18 104.09,34.8 v2(104.23,34.66)
  BOTTOM w0.14: v2(291.9,11.76) 291.9,12.53 292.57,13.21 292.96,13.21 293.19,13.44 293.19,13.97 v2(291.91,15.25)
  BOTTOM w0.254: v2(112.71,110) 112.7,109.99 PR1100.2
PANEL_BKEN_EC: length 276.5
  TOP w0.127: DV1.2 50.72,23.01 v1(50.72,22.67) 50.72,21.88 v2(51.18,21.42)
  TOP w0.14: UE4.4 v2(277.88,9.9)
  IN1 w0.099: v2(283.75,18.6) 282.22,18.6 281.08,17.46 278.87,17.46 277.68,16.28 270.81,16.28 266.96,12.42 266.47,12.42 264.11,10.07 262.64,10.07 262.05,9.48 249.39,9.48 248.82,10.05 233.64,10.05 233.41,10.28 224.76,10.28 224.41,10.63 218.31,10.63 217.75,10.07 213.21,10.07 211.93,11.34 175.38,11.34 174.67,12.05 154.41,12.05 153.1,13.35 129.93,13.35 128.39,14.9 105.51,14.9 104.9,14.29 102.7,14.29 101.51,13.1 99.23,13.1 99,12.88 96.62,12.88 96.13,13.36 96.13,14.1 95.48,14.75 92.32,14.75 91.18,13.61 84.95,13.61 84.64,13.31 78.61,13.31 78.17,13.75 71.69,13.75 70.39,15.06 66.33,15.06 64.03,12.75 61.21,12.75 59.42,10.97 58.58,10.97 58.2,11.34 58.2,12.57 58.35,12.73 58.35,13.83 57.6,14.58 54.16,14.58 53.58,15.17 53.58,17.54 54.14,18.11 54.14,19.62 52.27,21.5 51.26,21.5 v2(51.18,21.42)
  IN4 w0.091: v2(285.73,11.54) 285.73,11.4 284.23,9.9 v2(277.88,9.9)
  BOTTOM w0.14: v2(285.73,11.54) 285.49,11.54 284.53,12.49 284.53,13.62 283.21,14.94 283.21,18.06 v2(283.75,18.6)
PANEL_BKEN_PCH: length 35.3
  TOP w0.127: v2(54.8,26.45) 54.8,25.79 DV1.3
  TOP w0.14: v1(65.9,18.54) 65.79,18.43 v2(65.79,17.84)
  IN2 w0.099: v2(54.8,26.45) 54.8,25.88 58.36,22.32 59.76,22.32 62.44,19.64 63.38,19.64 64.38,18.64 64.99,18.64 v2(65.79,17.84)
  IN5 w0.089: 75.06,16.96 77.86,16.96 78.23,16.6 81.07,16.6 v2(81.51,16.15)
  IN5 w0.099: 75.06,16.96 74.23,16.96 74.12,16.85 66.78,16.85 v2(65.79,17.84)
  BOTTOM w0.089: v2(81.51,16.15) 81.85,16.15 82.4,16.7 UH2.W35
PBAT_PRES#: length 341.2
  TOP w0.14: UE3.A49 293.24,19.13 292.9,19.46 v2(292.9,19.65)
  TOP w0.254: PR322.1 59.12,22.42 v3(59.31,22.23) 59.51,22.03 59.51,21.47 59.23,21.19 59.22,21.19 59.22,21.18 v2(59.11,21.07) ; PR111.2 PR112.1 20.15,10.79 v2(20.38,10.79)
  IN1 w0.099: v2(285.3,12.36) 284.89,11.95 276.55,11.95 272.28,7.68 267.42,7.68 266.95,7.22 261.96,7.22 261.9,7.27 259.78,7.27 259.06,6.56 258.3,6.56 257.79,6.04 251.15,6.04 250.47,6.72 245.84,6.72 245.48,6.36 242.8,6.36 242.3,6.87 239.27,6.87 238.44,6.04 227.59,6.04 226.48,7.15 221.48,7.15 221.06,6.73 212.45,6.73 210.22,8.96 205.8,8.96 205.62,9.14 183.71,9.14 182.71,8.14 179.13,8.14 178.5,7.5 173.59,7.5 172.98,8.11 157.22,8.11 156.81,7.7 155.14,7.7 154.73,8.11 151.57,8.11 151.01,8.67 147.91,8.67 146.07,10.51 144.72,10.51 144.43,10.8 129.28,10.8 128.47,11.62 103.91,11.62 103.04,10.74 101.87,10.74 101.31,10.18 97.78,10.18 97.23,10.74 95.01,10.74 94.9,10.63 94.65,10.63 94.09,10.06 92.22,10.06 91.28,9.13 89.14,9.13 88.81,8.8 87.73,8.8 87.4,9.13 86.32,9.13 85.56,8.36 83.54,8.36 83.14,7.95 80.21,7.95 78.94,6.68 78.2,6.68 78.04,6.84 76.8,6.84 76.46,7.18 76.46,8.29 75.14,9.61 72.51,9.61 71.83,8.92 70.41,8.92 70.21,9.13 68.68,9.13 67.72,10.09 64.9,10.09 63.87,11.12 61.85,11.12 60.17,9.45 v2(60.17,8.9)
  IN2 w0.099: v2(60.17,8.9) 61.95,10.68 61.95,18.81 60.81,19.95 60.31,19.95 59.19,21.07 v2(59.11,21.07) 58.99,21.07 54.65,25.41 52.88,25.41 52.06,26.23 50.35,26.23 50.19,26.06 47.49,26.06 45.11,28.44 42.86,28.44 42.16,29.13 39.26,29.13 38.09,30.31 33.97,30.31 33.18,29.52 29.16,29.52 27.52,27.88 26.98,27.88 26.52,27.42 26.52,26.73 23.69,23.9 22.52,23.9 22.12,23.5 20.43,23.5 16.88,19.95 13.97,19.95 13.54,19.52 v2(13.54,18.54)
  IN5 w0.099: v2(20.38,10.79) 18.65,10.79 13.54,15.9 v2(13.54,18.54)
  BOTTOM w0.14: v2(292.9,19.65) 292.45,20.1 288.07,20.1 287.29,19.32 287.29,18.02 287.45,17.85 287.45,17.02 286.71,16.28 286.71,15.2 286.01,14.5 286.01,12.71 285.65,12.36 v2(285.3,12.36)
PBAT_SMBCLK: length 319.1
  TOP w0.14: RE18.2 291.35,15.69 292.2,15.69 v2(292.48,15.41) 292.9,15.41 293.11,15.63 UE3.A56 ; PR106.2 19.43,18.91 v3(20.24,19.72) 20.64,20.11 v2(20.64,20.18)
  IN3 w0.091: v2(290.82,9.75) 290.74,9.83 290.74,11.59 291.39,12.24 291.39,13.89 292.48,14.98 v2(292.48,15.41)
  IN6 w0.089: 101.98,10.56 99.5,10.56 99.26,10.32
  IN6 w0.099: 101.98,10.56 102.25,10.56 102.42,10.39 105.86,10.39 106.51,11.04 106.89,11.04 107.55,10.38 113.08,10.38 113.74,11.04 126.17,11.04 126.51,11.37 146.85,11.37 146.87,11.35 147.23,10.98 147.52,10.7 149.55,10.7 150.52,9.73 150.52,9.54 151.47,8.59 151.8,8.59 154.09,8.59 156.16,10.66 159.38,10.66 160.04,10.01 165.16,10.01 166.01,10.85 169.66,10.85 169.8,10.99 177.35,10.99 177.61,11.25 186.87,11.25 187.46,11.84 199.8,11.84 200.65,10.99 212.14,10.99 213.17,9.95 218.51,9.95 218.61,9.86 218.61,9.19 218.71,9.09 218.91,9.09 219,9.19 219,9.86 219.1,9.95 219.3,9.95 219.4,9.86 219.4,9.19 219.5,9.09 219.7,9.09 219.8,9.19 219.8,9.86 219.9,9.95 220.09,9.95 220.19,9.86 220.19,9.19 220.29,9.09 220.49,9.09 220.59,9.19 220.59,9.86 220.69,9.95 220.89,9.95 220.99,9.86 220.99,9.19 221.08,9.09 221.28,9.09 221.38,9.19 221.38,9.86 221.48,9.95 221.68,9.95 221.78,9.86 221.78,9.19 221.88,9.09 222.07,9.09 222.17,9.19 222.17,9.86 222.27,9.95 222.47,9.95 222.57,9.86 222.57,9.19 222.67,9.09 222.87,9.09 222.97,9.19 222.97,9.86 223.07,9.95 228.01,9.95 228.65,9.31 230.38,9.31 231.7,8 248.36,8 248.97,8.6 262.8,8.6 263.14,8.26 267.43,8.26 267.69,8.53 267.95,8.53 268.11,8.36 268.36,8.36 268.54,8.54 268.54,8.79 268.37,8.96 268.37,9.21 268.56,9.4 270.07,9.4 270.28,9.18 270.28,8.83 271.02,8.09 274.4,8.09 275.3,7.19 282.49,7.19 283.39,8.09 289.37,8.09 290,8.71 290.25,8.71 290.83,8.14 291.08,8.14 291.26,8.31 291.26,8.56 290.68,9.14 290.68,9.39 290.82,9.53 v2(290.82,9.75) ; v2(20.64,20.18) 20.64,20.51 21.57,21.44 21.57,22.1 22.83,23.36 24.86,23.36 25.09,23.59 27.21,23.59 28.15,22.65 29.99,22.65 30.47,23.12 30.47,23.62 30.79,23.94 37.7,23.94 38.33,23.94 40.19,22.08 48.14,22.08 48.34,21.88 50,21.88 51.01,20.87 51.25,20.87 51.7,21.32 52.84,21.32 55.5,18.65 55.93,18.65 56.52,18.07 56.52,16.06 56.41,15.96 56.41,13.62 56.44,13.6 56.44,13.27 57.07,12.63 65.32,12.63 65.51,12.44 66.78,12.44 66.94,12.61 69.81,12.61 70.4,12.02 71.61,12.02 72.13,11.5 72.13,10.25 72.99,9.4 72.99,8.86 73.47,8.38 74.34,8.38 74.71,8.76 77.5,8.76 77.68,8.94 78.55,8.94 78.65,8.84 78.82,8.84 79.12,9.14 79.63,9.14 80.01,8.76 84.34,8.76 84.69,9.1 85.88,9.1 86.07,9.3 87.67,9.3 88.19,8.78 88.8,8.78 89.21,9.19 90.21,9.19 90.4,9.38 91.47,9.38 91.69,9.6 92.39,9.6 92.84,9.15 94.2,9.15 95.89,10.84 97.45,10.84 97.97,10.32 99.26,10.32
PBAT_SMBDAT: length 318.6
  TOP w0.14: v2(291.77,16.4) 291.4,16.77 RE17.2 ; PR108.2 18.92,19.03 19.97,20.07 v2(19.97,20.2) 19.97,20.28 v1(19.07,21.18) ; v2(295.85,15.34) 295.38,15.81 294.9,15.81 294.83,15.88 UE3.B59
  IN3 w0.091: v2(291.77,16.4) 291.49,16.13 291.49,14.45 290.98,13.94 290.98,12.63 289.85,11.5 289.85,10.12 v2(290.18,9.8)
  IN6 w0.089: 101.98,10.96 99.36,10.96 99.12,10.72 98.08,10.72 97.58,11.22 95.66,11.22 94.5,10.07 91.78,10.07 91.29,9.57 ; 76.3,9.14 75.84,9.61 75.06,9.61
  IN6 w0.099: 76.3,9.14 76.5,8.94 77.42,8.94 78.12,9.65 79.38,9.65 80.05,8.98 84.07,8.98 84.4,9.31 84.4,9.74 84.64,9.99 85.4,9.99 85.9,9.48 87.75,9.48 88.27,8.96 88.72,8.96 89.23,9.47 90.13,9.47 90.23,9.57 91.29,9.57 ; v2(290.18,9.8) 290.18,9.2 289.27,8.29 284.5,8.29 283.6,9.19 281.84,9.19 280.68,8.03 278.98,8.03 278.65,7.71 275.06,7.71 274.49,8.29 271.11,8.29 270.48,8.91 270.48,9.26 270.15,9.6 262.82,9.6 262.22,9 248.8,9 248.2,8.4 234.66,8.4 233.15,9.9 228.63,9.9 228.18,10.36 213.34,10.36 212.3,11.39 200.82,11.39 199.97,12.24 187.3,12.24 186.7,11.65 177.4,11.65 177.15,11.39 169.63,11.39 169.49,11.25 163.72,11.25 162.88,10.41 160.2,10.41 159.37,11.25 155.13,11.25 152.88,8.99 151.63,8.99 150.92,9.71 150.92,9.89 150.66,10.15 149.72,11.1 147.69,11.1 147.42,11.37 147.19,11.59 147.01,11.77 126.34,11.77 126.01,11.44 113.58,11.44 112.92,10.78 107.71,10.78 107.05,11.44 106.33,11.44 105.68,10.79 102.58,10.79 102.41,10.96 101.98,10.96 ; v2(19.97,20.2) 19.97,20.57 20.59,21.19 20.84,21.19 21.29,21.64 21.29,22.1 22.74,23.56 24.78,23.56 25.08,23.86 30.28,23.86 30.57,24.14 36.34,24.14 36.34,24.14 37.62,24.14 38.41,24.14 40.27,22.28 48.22,22.28 48.43,22.08 50.08,22.08 50.18,21.98 54.18,21.98 54.88,21.28 54.88,20.01 56.72,18.17 56.72,15.96 56.62,15.86 56.62,13.7 56.64,13.67 56.64,13.37 57.16,12.85 61.39,12.85 62.47,13.93 70.65,13.93 72.34,12.24 72.34,10.34 73.07,9.61 75.06,9.61
  BOTTOM w0.14: v2(291.77,16.4) 291.52,16.66 291.52,17.1 291.89,17.47 293.27,17.47 294.92,15.82 295.36,15.82 v2(295.85,15.34)
PBTN_SW#: length 290.8
  TOP w0.14: v2(345.39,111.91) DE2.2 343.75,111.9 v1(340.17,111.9) 338.89,111.9 SW1.1 ; v2(283.46,5.29) 283.46,5.17 RE36.2 285.95,2.68 293.85,2.68 294.26,3.08 CE29.1
  IN6 w0.099: v2(173.93,8.26) 174.6,8.93 210.85,8.93 213.88,5.9 227.15,5.9 227.77,5.28 245.29,5.28 246.28,6.26 256.7,6.26 256.85,6.1 262.93,6.1 263.29,6.46 267.56,6.46 268.38,5.65 270.54,5.65 271.08,5.11 283.27,5.11 283.46,5.3 ; v2(345.39,111.91) 344.3,110.82 344.3,105.27 345.13,104.44 345.13,89.88 342.83,87.59 338.58,87.59 337.01,86.01 337.01,85.01 333.87,81.87 333.87,61.44 329.85,57.42 329.85,53.77 328.24,52.15 328.24,51.73 328.01,51.51 328.01,41.04 324.8,37.83 324.8,35.66 324.06,34.92 324.06,31.1 320.62,27.66 320.62,24.9 319.48,23.76 319.48,10.39 315.97,6.88 306.71,6.88 306.12,6.3 302.23,6.3 300.85,4.91 295.4,4.91 295.23,5.08 284.96,5.08 284.34,5.7 283.86,5.7 283.46,5.3 ; v2(283.46,5.29) 283.46,5.3
  BOTTOM w0.14: v2(173.93,8.26) 173.62,7.96 JAPS.11
PCH_ALW_ON: length 397
  TOP w0.14: UZ23.2 106.62,52.71 106.74,52.59 v2(106.74,50.75) ; v2(302.43,21.75) 302.27,21.59 UE3.A34 ; v2(127.46,9.91) 127.46,10.89 122.6,15.74 117.59,15.74 116.99,16.35 116.99,17.34 114.57,19.75 113.77,19.75 110.11,19.75 109.57,20.29 109.57,25.41 109.4,25.57 109.4,29.78 122.56,42.93 v2(122.56,51.63) ; UZ4.3 56.58,5.75 56.71,5.88 56.67,5.91 v2(56.64,5.91) 57.28,6.55 RZ46.2
  TOP w0.254: v2(127.46,9.91) 127.46,8.12 v1(129.03,6.56) 130.04,5.55 130.04,1.82 130.28,1.58 v2(130.65,1.58)
  IN2 w0.089: 101.98,7.69 101.05,7.69 100.33,6.97 99.87,6.97 98.73,5.83 98.12,5.83 97.88,6.07 96.69,6.07 96.27,5.65 95.96,5.65 95.27,4.96 92.59,4.96 92.19,4.56 88.34,4.56 88.22,4.43 85.56,4.43 85.11,3.98 84.04,3.98 83.47,3.41 82.65,3.41 81.44,2.2 76.3,2.2 75.92,2.58 75.06,2.58
  IN2 w0.099: v2(56.64,5.91) 56.64,5.17 58.09,3.72 61.11,3.72 61.8,4.41 62.21,4.41 62.68,3.95 63.63,3.95 64.48,4.8 69.1,4.8 69.57,4.33 72.03,4.33 72.62,3.74 73.38,3.74 74.55,2.58 75.06,2.58 ; v2(315.08,7.88) 314.5,7.88 313.96,7.34 313.65,7.34 310.91,4.61 310.29,4.61 309.7,4.02 303.94,4.02 302.99,4.97 301.83,4.97 300.97,4.11 296.44,4.11 296.28,3.95 289.6,3.95 288.87,3.23 269.56,3.23 267.67,5.12 263,5.12 262.06,4.17 258.17,4.17 257.24,5.1 250.97,5.1 250.78,5.29 246.48,5.29 244.83,3.64 239.88,3.64 239.01,2.78 214.78,2.78 209.56,8 201.14,8 200.57,7.43 184.01,7.43 182.66,6.08 175.92,6.08 174.85,5.01 171.6,5.01 171.3,5.31 163.6,5.31 163.28,5.63 159.7,5.63 159.48,5.86 156.19,5.86 155.75,5.42 152.35,5.42 149.33,8.43 147.92,8.43 146.62,9.73 135.8,9.73 135.1,9.03 128.35,9.03 v2(127.46,9.91) 118.42,9.91 116.08,7.57 107.98,7.57 107.86,7.69 101.98,7.69
  IN3 w0.091: v2(315.08,7.88) 314.63,8.33 314.63,10.23 315.26,10.86 315.26,11.51 315.29,11.54 315.29,11.87 315.26,11.9 315.26,11.96 314.77,12.45 314.77,12.77 314.77,19.54 311.74,22.57 308.25,22.57 307.69,22.02 304.3,22.02 304.17,22.16 302.84,22.16 v2(302.43,21.75)
  BOTTOM w0.14: v2(122.56,51.63) 121.48,52.71 120.7,52.71 120.25,52.26 111.66,52.26 110.14,50.75 v2(106.74,50.75)
  BOTTOM w0.254: PR500.2 v2(130.65,1.58)
PCH_BATLOW#: length 20.6
  IN6 w0.089: 101.98,5.7 101.22,5.7 101.02,5.5 101.02,5.27 100.71,4.96 99.99,4.96 99.65,4.61 99.65,3.71 98.46,2.52 96.5,2.52 96.27,2.75 95.42,2.75 95.14,3.03 94.13,3.03 v2(94.08,2.98)
  IN6 w0.099: v2(107.84,3.01) 106.34,3.01 104.65,4.7 104.24,4.7 103.93,5.01 103.93,5.61 103.76,5.78 102.2,5.78 102.11,5.7 101.98,5.7
  BOTTOM w0.089: UH2.BD13 93.74,4.47 93.74,3.32 v2(94.08,2.98)
  BOTTOM w0.127: RH515.1 108.99,2.52 108.32,2.52 v2(107.84,3.01)
PCH_CPU_BCLK_N: length 134.7
  IN6 w0.107: v2(177.07,82.56) 177.35,82.28 177.65,82.28 177.78,82.41 177.78,82.66 178.04,82.92 178.04,84.54 176.21,86.37 173.73,86.37 173.33,85.98 171.54,85.98 171.13,86.38 171.13,87.43 169.52,89.04 156.73,89.04 155.72,90.05 136.29,90.05 134.32,88.08 134.32,81.9 132.53,80.11 132.53,77.94 129,74.42 129,70 128.3,69.29 128.3,66.65 123.74,62.1 122.56,62.1 119.88,59.41 119.88,53.03 118.17,51.32 118.17,43.27 105.06,30.16 103.67,30.16 102.36,28.85 102.36,24.72 101.73,24.09 v2(101.73,23.85)
  BOTTOM w0.076: UH1.A32 177.12,82.61 v2(177.07,82.56)
  BOTTOM w0.102: v2(101.73,23.85) 101.73,23.66 100.41,22.34 99.91,22.34 99.91,22.34 99.9,22.34 99.61,22.34 99.58,22.3 99.09,22.3 99.07,22.32 UH2.H2
PCH_CPU_BCLK_P: length 134.8
  IN6 w0.107: v2(101.41,24.32) 101.67,24.32 102.16,24.81 102.16,28.93 103.59,30.36 104.97,30.36 117.97,43.36 117.97,51.41 119.67,53.11 119.67,59.5 122.48,62.3 123.66,62.3 128.09,66.74 128.09,69.38 128.8,70.08 128.8,74.5 132.32,78.02 132.32,80.2 134.11,81.99 134.11,88.16 136.21,90.26 155.8,90.26 156.82,89.24 169.61,89.24 171.33,87.51 171.33,86.47 171.62,86.18 173.25,86.18 173.64,86.58 176.29,86.58 178.25,84.62 178.25,82.84 177.98,82.57 177.98,82.25 v2(178.15,82.08)
  BOTTOM w0.076: UH1.B31 178.07,82.16 v2(178.15,82.08)
  BOTTOM w0.102: v2(101.41,24.32) 101.32,24.23 101.32,23.64 100.3,22.62 99.91,22.62 99.91,22.62 99.79,22.62 99.79,22.62 99.49,22.62 99.49,22.61 99.49,22.58 99.47,22.56 99.2,22.56 99.18,22.58 98.86,22.58 98.81,22.62 98.81,22.86 UH2.G2
PCH_CPU_PCIBCLK_N: length 128
  IN6 w0.107: v2(101.79,22.48) 103.28,23.96 103.28,28.28 104.43,29.43 105.2,29.43 118.78,43.02 118.78,51.07 121.51,53.8 121.51,58.64 128.93,66.06 128.93,69.02 129.62,69.71 129.62,74.16 133.21,77.75 133.21,79.14 135.04,80.97 135.04,87.78 136.61,89.35 155.26,89.35 156.34,88.27 169,88.27 170.01,87.26 170.01,86.48 171.68,84.81 173.57,84.81 174.51,85.76 175.43,85.76 175.94,85.25 v2(175.94,84.78)
  BOTTOM w0.076: v2(175.94,84.78) 175.94,84.78 176.59,84.78 UH1.C36
  BOTTOM w0.102: v2(101.79,22.48) 101.58,22.48 100.94,21.83 99.61,21.83 99.55,21.77 UH2.J1
PCH_CPU_PCIBCLK_P: length 129.3
  IN6 w0.107: v2(101.73,23.03) 102.06,23.03 103.07,24.04 103.07,28.36 104.35,29.64 105.12,29.64 118.58,43.1 118.58,51.15 121.31,53.88 121.31,58.72 128.73,66.14 128.73,69.11 129.41,69.79 129.41,74.24 133.01,77.83 133.01,79.23 134.84,81.06 134.84,87.87 136.53,89.56 155.35,89.56 156.43,88.48 169.09,88.48 170.22,87.35 170.22,86.56 171.76,85.01 173.48,85.01 174.43,85.96 175.51,85.96 176.37,85.1 176.37,84.71 v2(176.7,84.37)
  BOTTOM w0.076: v2(176.7,84.37) 176.69,84.39 UH1.D35
  BOTTOM w0.102: UH2.J2 98.99,21.85 99.2,22.06 99.44,22.06 99.5,22.11 100.81,22.11 v2(101.73,23.03)
PCH_DPWROK: length 251.8
  TOP w0.089: v2(101.02,9.52) 100.73,9.81 RH309.1
  TOP w0.14: UE3.A36 301.27,21.56 v2(301.46,21.75)
  IN2 w0.089: 101.98,9.95 101.46,9.95 v2(101.02,9.52)
  IN2 w0.099: v2(314.69,10.94) 314.16,10.94 309.34,6.13 307.72,6.13 307.1,5.51 306.65,5.51 305.75,6.4 301.82,6.4 300.54,5.12 296.03,5.12 295.87,4.96 285.54,4.96 284.6,5.9 283.19,5.9 282.44,5.14 272.33,5.14 270.37,7.11 262.21,7.11 261.95,7.37 257.32,7.37 256.28,6.33 252.63,6.33 252.36,6.61 245.93,6.61 245.06,5.73 239.74,5.73 238.1,4.1 227.88,4.1 227.37,4.61 214.71,4.61 210.06,9.26 200.7,9.26 200.07,8.64 178.01,8.64 177.36,9.28 174.21,9.28 173.26,8.33 171.39,8.33 171.05,7.99 156.8,7.99 155.83,8.97 153.6,8.97 151.91,10.66 151.91,11.66 151.6,11.97 114.27,11.97 113.21,10.91 106.68,10.91 105.72,9.95 101.98,9.95
  IN3 w0.091: v2(314.69,10.94) 314.39,11.25 314.39,12.29 314.39,19.38 311.58,22.19 308.41,22.19 307.54,21.32 303.62,21.32 303.26,20.96 302.25,20.96 v2(301.46,21.75)
PCH_DPWROK_R: length 8.8
  TOP w0.089: v2(95.1,7.79) 95.36,8.05 96.06,8.05 96.61,8.59 97.64,8.59 98.5,7.73 RH401.2 99.28,8.14 99.28,9.6 RH309.2 99.49,10.49 v1(100.03,11.02)
  BOTTOM w0.089: v2(95.1,7.79) 94.84,7.79 UH2.AV11
PCH_ITP_PMODE: length 144.5
  TOP w0.14: RH479.1 119.7,93.87 v2(119.81,93.87) 120.08,93.61 v3(120.41,93.61)
  IN4 w0.091: v2(119.81,93.87) 119.91,93.98 119.91,95.64 120,95.72 120,99.88 121.31,101.2 132.98,101.2 133.48,100.7 133.48,99.83 135.14,98.17 135.14,95.27 134.52,94.65 134.52,85.81 135.38,84.95 135.38,81.96 133.74,80.32 133.74,78.82 133.24,78.32 133.24,77.81 130.79,75.36 130.79,70.36 129.29,68.86 129.29,66.88 131.82,64.34 131.82,58.23 125.03,51.44 125.03,47.31 112.09,34.37 112.09,26.82 111.63,26.36 111.63,17.86 111.98,17.51 v2(111.98,16.7)
  BOTTOM w0.089: 101.86,7.34 101.43,7.34 101.03,7.73 100.54,7.73 99.96,8.31 99.15,8.31 99.04,8.21 UH2.AT2
  BOTTOM w0.127: 101.86,7.34 101.94,7.43 105.91,7.43 106.4,6.93 106.4,6.56 106.98,5.98 110,5.98 110.49,6.47 110.49,8.41 113.41,11.33 113.41,14.66 111.98,16.1 v2(111.98,16.7)
PCH_JTAG_TCK: length 131.2
  TOP w0.14: RH95.2 102.05,9.52 v2(101.77,9.52) ; v2(133.95,100.28) v1(133.54,99.86) 133.31,99.64 130.8,99.64 130.48,99.32 129.81,99.32 129.49,99.01 JXDP.55
  IN4 w0.089: 134.71,89.23 134.71,85.91 135.56,85.06 135.56,82.34 136.16,81.75 136.16,80.77 137.15,79.78 137.15,77.85 136.42,77.12 134.62,77.12
  IN4 w0.091: v2(108.34,16.66) 108.93,16.07 112.29,16.07 112.57,16.35 112.57,16.94 113.17,17.54 113.17,25.98 112.48,26.68 112.48,34.19 125.42,47.13 125.42,51.18 132.21,57.96 132.21,65.54 131.17,66.58 131.17,67.83 132.48,69.14 132.48,70.14 131.75,70.87 131.75,75.78 133.1,77.12 134.62,77.12 ; v2(133.95,100.28) 135.36,98.87 135.36,95.22 134.71,94.57 134.71,89.23
  BOTTOM w0.089: v2(101.77,9.52) 101.37,9.12 100.86,9.12 100.27,9.71 98.85,9.71 98.66,9.9 UH2.AN3
  BOTTOM w0.127: v2(101.77,9.52) 101.78,9.51 104.47,9.51 104.73,9.25 108.9,9.25 109.94,10.3 109.94,13.11 109.46,13.59 109.46,15.2 108.34,16.32 v2(108.34,16.66)
